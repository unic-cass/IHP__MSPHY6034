** sch_path: dependencies/DAC/DAC-main/testbenches/tran/xschem/CS_DAC_10b_test.sch
**.subckt CS_DAC_10b_test
V1 VDD GND 1
V3 VBIAS GND 1
V2 CLK GND PULSE(0 1 0n 5n 5n 20n 50n)
V4 X1 GND PULSE(0 1 0 5n 5n 45n 100n)
V5 X2 GND PULSE(0 1 0 5n 5n 95n 200n)
V6 X3 GND PULSE(0 1 0 5n 5n 195n 400n)
V7 X4 GND PULSE(0 1 0 5n 5n 395n 800n)
V8 X5 GND PULSE(0 1 0 5n 5n 795n 1600n)
V9 X6 net4 PULSE(0 1 0 5n 5n 1595n 3200n)
V13 X7 net5 PULSE(0 1 0 5n 5n 3195n 6400n)
V15 X8 net6 PULSE(0 1 0 5n 5n 6395n 12800n)
V17 X9 net7 PULSE(0 1 0 1n 1n 12795n 25600n)
V19 X10 net8 PULSE(0 1 0 1n 1n 25595n 51200n)
Vds net1 GND 1.5
Vd net1 net2 0
.save i(vd)
Vd1 net1 net3 0
.save i(vd1)
V10 X GND PULSE(1 0 0 5n 5n 45n 100n)
x2 CLK net2 net3 VBIAS VDD GND X1 X10 X2 X3 X4 X5 X6 X7 X8 X9 CS_DAC_10b_pex
**** begin user architecture code


.save  i(Vd) i(Vd1)
.control
set wr_vecnames
set wr_singlescale
tran 1n 51200n
run
write CS_DAC_10b.raw i(Vd) i(Vd1)
.endc





.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt
.include /opt/pdks/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice



**** end user architecture code
**.ends

* expanding   symbol:  CS_DAC_10b_pex.sym # of pins=16
** sym_path: dependencies/DAC/dependencies/CS_DAC-/xschem/CS_DAC_10b.sym

.subckt CS_DAC_10b_pex CLK VDD VSS X1 X10 X2 X3 X4 X5 X6 X7 X8 X9
X0 a_20738_20217.t2 a_n2044_4040.t13 a_20839_20514.t1 VSS.t3545 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1 a_24729_11890.t0 a_24639_11794# VSS.t450 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2 a_48514_26437.t0 a_48949_26480.t3 a_48254_26907.t1 VSS.t2938 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3 a_20450_17398.t0 a_20145_17794.t2 VSS.t2873 VSS.t2872 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X4 a_11689_9090.t5 a_11599_8994# a_11523_9350.t7 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5 a_23437_3694.t1 a_22840_3493.t2 VDD.t526 VDD.t297 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X6 VDD.t1190 X5.t1 a_4285_25305.t1 VDD.t77 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X7 VDD.t732 a_49148_14833.t2 a_49109_14931.t0 VDD.t3 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X8 a_21870_9029.t1 a_21581_9334.t4 a_21807_9029.t0 VSS.t1360 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X9 VSS.t1415 VDD.t1503 a_34429_9016.t0 VSS.t3868 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X10 a_23641_6494.t1 a_22840_6293.t2 VDD.t370 VDD.t139 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X11 a_44289_690.t3 a_44199_594# VSS.t3609 VSS.t3610 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X12 a_18043_14950.t9 a_18119_14594# a_18209_14690.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X13 a_24563_9350.t4 a_23437_9294.t2 6MSB_0.OUTP.t14 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X14 VSS.t2013 a_n2342_2100.t2 a_n2044_1752.t0 VSS.t2012 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X15 a_24563_3750.t8 a_24639_3394# a_24729_3490.t5 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X16 VDD.t580 X10.t3 a_n2857_2880.t0 VDD.t286 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X17 a_37769_20290.t2 a_37679_20194# VSS.t2341 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X18 VSS.t2788 a_31159_17394# a_31249_17490.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X19 a_18043_14950.t4 a_16917_14894.t2 6MSB_0.OUTP.t12 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X20 a_11523_9350.t0 VSS.t682 VSS.t683 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u w=0.5u
+ l=0.13u
X21 VSS.t746 VSS.t745 VSS.t746 VSS.t130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X22 a_42400_6293.t0 a_41550_6473.t2 a_41141_6534.t2 VDD.t125 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X23 VSS.t273 VSS.t271 a_26665_20594.t0 VSS.t272 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X24 a_7105_12194.t0 a_2713_24910.t6 VSS.t2997 VSS.t2996 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X25 a_3508_6433.t0 a_3280_6293.t2 a_3699_6216.t0 VSS.t1541 sg13_lv_nmos ad=0.1428p pd=1.52u as=37.8f
+ ps=0.6u w=0.42u l=0.13u
X26 a_15035_839.t0 a_15470_873.t3 a_15418_1007.t0 VDD.t444 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X27 a_9989_931.t0 a_9052_960.t2 a_9800_693.t0 VDD.t460 sg13_lv_pmos ad=52.5f pd=0.67u as=0.19115p
+ ps=1.565u w=0.42u l=0.13u
X28 a_11523_20550.t5 a_10818_20514.t2 6MSB_0.OUTN.t120 VSS.t2560 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X29 VSS.t361 VSS.t359 a_31083_17750.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X30 a_11689_17490.t1 a_11599_17394# VSS.t2357 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X31 VSS.t451 VSS.t449 VSS.t450 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X32 a_5003_20550.t0 VSS.t205 VSS.t207 VSS.t206 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u w=0.5u
+ l=0.13u
X33 a_3877_9294.t0 a_3280_9093.t2 VSS.t1283 VSS.t1282 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X34 VSS.t1655 a_29588_6433.t2 a_29266_6293.t1 VSS.t1654 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X35 VSS.t3253 a_42400_17493.t2 a_42997_17694.t0 VSS.t3251 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X36 a_21990_9273.t1 CLK.t28 VDD.t212 VDD.t156 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X37 VDD.t826 a_49799_26830.t2 a_50027_26708.t1 VDD.t13 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X38 a_41115_17639.t2 a_41550_17673.t3 a_40855_17416.t3 VSS.t3261 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X39 VSS.t1741 X9.t4 a_n2852_4060.t0 VSS.t2583 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1216p ps=1.02u
+ w=0.64u l=0.13u
X40 a_9800_14693.t1 a_8950_14873.t2 a_8541_14934.t1 VDD.t912 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X41 a_11689_14690.t0 a_11599_14594# VSS.t432 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X42 a_37603_14950.t8 a_37679_14594# a_37769_14690.t5 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X43 a_21990_20473.t1 CLK.t59 VDD.t994 VDD.t11 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X44 VDD.t323 a_3280_6293.t2 a_3508_6433.t1 VDD.t143 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X45 a_49938_914.t1 a_49721_894.t2 VDD.t729 VDD.t4 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X46 a_n2646_1728.t0 a_n2951_1728.t2 VSS.t2007 VSS.t1976 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X47 a_48254_27219.t1 X1.t0 VDD.t1262 VDD.t14 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p ps=1.52u
+ w=0.42u l=0.13u
X48 a_8767_20229.t0 VDD.t1323 VSS.t3754 VSS.t3753 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X49 VDD.t1179 a_n2044_4040.t12 a_27359_20514.t2 VDD.t9 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X50 a_18209_14690.t7 a_18119_14594# a_18043_14950.t8 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X51 VSS.t1339 a_16548_9233.t2 a_16226_9093.t1 VSS.t1338 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X52 VSS.t3281 a_37679_3394# a_37769_3490.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X53 a_49797_25052.t0 a_48860_25081.t2 a_49608_24814.t1 VDD.t813 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X54 a_16917_20494.t0 a_16320_20293.t2 VSS.t2922 VSS.t2921 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X55 VDD.t1392 VDD.t1389 a_47635_17639.t2 VDD.t905 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X56 a_20839_12114.t2 a_n2770_240.t14 VDD.t38 VDD.t34 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X57 a_36898_12114.t1 a_36681_12094.t2 VDD.t89 VDD.t66 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X58 a_49799_26830.t1 a_48949_26480.t2 a_48540_26473.t1 VDD.t13 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X59 a_40855_11816.t3 a_41652_12160.t3 a_41115_12039.t1 VDD.t91 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X60 a_44123_9350.t9 a_44199_8994# a_44289_9090.t7 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X61 VDD.t618 a_3508_833.t2 a_3469_931.t0 VDD.t462 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X62 VSS.t2627 a_41550_20473.t3 a_41652_20560.t0 VSS.t2626 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X63 6MSB_0.OUTN.t39 a_17338_6514.t2 a_18043_6550.t6 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X64 a_20738_617.t2 VDD.t1647 a_20839_914.t1 VSS.t3963 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X65 VDD.t599 a_n2951_1728.t2 a_n2646_1728.t1 VDD.t597 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X66 VDD.t775 VDD.t1273 a_8515_12039.t2 VDD.t17 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X67 a_10818_12114.t0 a_10601_12094.t2 VSS.t14 VSS.t13 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X68 VDD.t189 a_9800_9093.t2 a_10397_9294.t1 VDD.t162 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X69 VSS.t3288 a_50719_14594# a_50809_14690.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X70 a_3877_12094.t0 a_3280_11893.t2 VSS.t2430 VSS.t2429 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X71 VSS.t4141 a_24639_6194# a_24729_6290.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X72 a_33879_914.t0 a_33490_598.t2 VDD.t688 VDD.t454 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X73 VDD.t753 a_2430_17673.t3 a_2532_17760.t1 VDD.t752 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X74 a_4081_894.t1 a_3280_693.t2 VDD.t621 VDD.t462 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p ps=1.5u
+ w=1u l=0.13u
X75 VSS.t520 VSS.t519 a_50643_14950.t1 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X76 a_36477_12094.t1 a_35880_11893.t2 VDD.t85 VDD.t66 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X77 a_48070_3673.t0 CLK.t8 VSS.t1994 VSS.t3683 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X78 VDD.t877 a_21990_14873.t3 a_22092_14960.t1 VDD.t736 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X79 a_33185_3794.t0 a_3545_25331.t3 VSS.t2679 VSS.t2678 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X80 VDD.t40 VDD.t1265 a_21295_11816.t1 VDD.t34 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X81 a_21581_3734.t2 a_22092_3760.t2 a_22840_3493.t1 VSS.t1878 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X82 VSS.t1828 a_8950_3673.t3 a_9052_3760.t0 VSS.t1827 sg13_lv_nmos ad=3.46165p pd=22.395u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X83 VSS.t74 a_28510_12073.t3 a_28612_12160.t0 VSS.t73 sg13_lv_nmos ad=3.46165p pd=22.395u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X84 a_28101_9334.t2 a_28612_9360.t2 a_29360_9093.t1 VSS.t1392 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X85 VSS.t1748 a_n2342_4060.t2 a_n2044_4040.t0 VSS.t1747 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X86 VDD.t144 a_n2042_972.t9 a_679_6594.t0 VDD.t143 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X87 a_11523_950.t4 a_10397_894.t2 6MSB_0.OUTP.t110 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X88 VSS.t978 VSS.t976 VSS.t977 VSS.t415 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X89 a_18043_3750.t0 VSS.t916 VSS.t917 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u w=0.5u
+ l=0.13u
X90 a_21555_9239.t0 a_21990_9273.t3 a_21938_9407.t0 VDD.t156 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X91 a_18043_6550.t4 a_16917_6494.t2 6MSB_0.OUTP.t44 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X92 a_35030_6473.t0 CLK.t18 VSS.t1676 VSS.t3673 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X93 VSS.t2082 a_10601_894.t2 a_10818_914.t0 VSS.t2081 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X94 a_5003_950.t7 a_5079_594# a_5169_690.t4 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X95 a_18209_20290.t6 a_18119_20194# a_18043_20550.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X96 VSS.t31 a_n2044_1752.t6 a_20145_12194.t0 VSS.t2815 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X97 6MSB_0.OUTP.t64 a_36477_9294.t2 a_37603_9350.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X98 a_20145_6594.t0 a_521_25453.t4 VSS.t2303 VSS.t2302 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X99 a_18043_17750.t1 a_16917_17694.t2 6MSB_0.OUTP.t127 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X100 a_16320_14693.t0 a_15470_14873.t2 a_15061_14934.t3 VDD.t887 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X101 a_42819_616.t0 VDD.t1685 VSS.t2212 VSS.t3985 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X102 a_15350_20229.t1 a_15572_20560.t3 a_15035_20439.t0 VSS.t2613 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X103 a_15287_20229.t0 VDD.t1283 VSS.t3723 VSS.t3722 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X104 a_17121_6494.t0 a_16320_6293.t2 VSS.t1599 VSS.t1600 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X105 a_37769_6290.t3 a_37679_6194# VSS.t2780 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X106 a_49517_3694.t1 a_48920_3493.t2 VDD.t589 VDD.t293 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X107 a_10818_3714.t0 a_10601_3694.t2 VSS.t1835 VSS.t1834 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X108 a_17338_9314.t0 a_17121_9294.t2 VSS.t1331 VSS.t1330 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X109 a_47661_3734.t1 a_47635_3639.t3 VDD.t585 VDD.t293 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X110 VDD.t954 a_n2044_1752.t17 a_1279_14914.t1 VDD.t817 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X111 a_49721_6494.t1 a_48920_6293.t2 VDD.t430 VDD.t0 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X112 a_40855_14616.t2 a_40399_14914.t3 VDD.t1770 VDD.t810 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X113 VDD.t1125 VDD.t1441 a_15035_12039.t2 VDD.t25 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X114 6MSB_0.OUTN.t115 a_49938_3714.t2 a_50643_3750.t6 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X115 a_2310_11829.t0 a_2532_12160.t3 a_1995_12039.t0 VSS.t2693 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X116 a_2247_11829.t0 VDD.t1435 VSS.t3823 VSS.t3822 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X117 a_10397_12094.t0 a_9800_11893.t2 VSS.t10 VSS.t9 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X118 a_18043_9350.t9 a_18119_8994# a_18209_9090.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X119 a_24729_9090.t3 a_24639_8994# VSS.t4178 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X120 VSS.t568 VSS.t564 VSS.t567 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X121 6MSB_0.OUTP.t3 a_49517_6494.t2 a_50643_6550.t4 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X122 a_36477_6494.t1 a_35880_6293.t2 VDD.t398 VDD.t135 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X123 a_10818_914.t1 a_10601_894.t2 VDD.t639 VDD.t460 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X124 a_50809_3490.t4 a_50719_3394# a_50643_3750.t2 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X125 VDD.t90 a_36681_12094.t2 a_36898_12114.t1 VDD.t66 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X126 a_36681_9294.t1 a_35880_9093.t2 VDD.t245 VDD.t150 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X127 6MSB_0.OUTN.t73 a_49938_14914.t2 a_50643_14950.t9 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X128 a_47635_14839.t0 a_48070_14873.t3 a_48018_15007.t0 VDD.t3 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X129 a_24729_17490.t0 a_24639_17394# VSS.t392 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X130 a_47469_14616.t0 a_46919_14914.t3 a_47375_14616.t0 VSS.t2451 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X131 a_37603_6550.t8 a_37679_6194# a_37769_6290.t5 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X132 VDD.t60 a_29360_11893.t2 a_29588_12033.t1 VDD.t50 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X133 a_23437_9294.t1 a_22840_9093.t2 VDD.t214 VDD.t156 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X134 VDD.t866 a_42400_14693.t2 a_42997_14894.t1 VDD.t810 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X135 a_40399_914.t1 VDD.t1679 a_40298_617.t1 VSS.t3980 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X136 VSS.t3184 a_3280_20293.t2 a_3877_20494.t0 VSS.t3182 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X137 a_11689_11890.t6 a_11599_11794# a_11523_12150.t9 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X138 VSS.t957 VSS.t955 VSS.t956 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X139 a_50643_3750.t4 a_49517_3694.t2 6MSB_0.OUTP.t6 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X140 a_24563_9350.t8 a_24639_8994# a_24729_9090.t5 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X141 a_1995_20439.t1 a_2430_20473.t3 a_1735_20216.t3 VSS.t4206 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X142 a_20839_20514.t2 a_n2044_4040.t13 VDD.t1082 VDD.t11 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X143 a_36898_20514.t1 a_36681_20494.t2 VDD.t799 VDD.t793 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X144 a_23858_14914.t0 a_23641_14894.t2 VSS.t2703 VSS.t2702 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X145 a_51440_25469.t3 a_50626_25035.t2 6MSB_0.OUTP.t32 VSS.t2597 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X146 a_40855_20216.t0 a_41652_20560.t3 a_41115_20439.t0 VDD.t801 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X147 a_44123_950.t2 VSS.t1073 VSS.t1083 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X148 a_44123_20550.t5 a_43418_20514.t2 6MSB_0.OUTN.t132 VSS.t2860 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X149 VDD.t1012 VDD.t1323 a_8515_20439.t2 VDD.t762 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X150 a_7105_17794.t0 a_2713_24910.t8 VSS.t3001 VSS.t3000 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X151 VSS.t393 VSS.t389 VSS.t392 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X152 a_5003_3750.t3 a_5079_3394# a_5169_3490.t6 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X153 a_2430_3673.t1 CLK.t15 VDD.t480 VDD.t303 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X154 VSS.t4149 a_49799_27296.t2 a_50396_27497.t0 VSS.t2577 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X155 a_41141_20534.t0 a_41652_20560.t2 a_42400_20293.t1 VSS.t2624 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X156 a_50643_12150.t3 a_50719_11794# a_50809_11890.t4 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X157 a_36477_20494.t1 a_35880_20293.t2 VDD.t795 VDD.t793 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X158 a_50643_6550.t9 a_50719_6194# a_50809_6290.t7 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X159 VDD.t93 a_39705_12194.t2 a_40010_11798.t1 VDD.t91 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X160 VDD.t1073 VDD.t1335 a_21295_20216.t3 VDD.t11 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X161 VSS.t967 VSS.t884 a_31083_3750.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X162 a_28101_934.t2 a_28612_960.t2 a_29360_693.t1 VSS.t2151 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X163 VSS.t3586 a_37679_8994# a_37769_9090.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X164 VSS.t317 VSS.t300 VSS.t317 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X165 a_41430_11829.t1 a_41141_12134.t4 a_41367_11829.t0 VSS.t1143 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X166 VSS.t2028 X10.t0 a_n2966_249.t0 VSS.t2588 sg13_lv_nmos ad=0.1371p pd=1.12u as=0.2176p ps=1.96u
+ w=0.64u l=0.13u
X167 a_7410_3398.t1 a_7105_3794.t2 VDD.t302 VDD.t301 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X168 a_48349_25055.t3 a_48323_24960.t3 VDD.t1044 VDD.t813 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X169 VSS.t3332 a_20450_20198.t2 a_20738_20217.t0 VSS.t3331 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X170 VSS.t3013 a_5079_14594# a_5169_14690.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X171 a_7698_3417.t0 a_7410_3398.t2 VSS.t1815 VSS.t1816 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X172 a_46225_6594.t0 VSS.t867 VSS.t869 VSS.t868 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X173 a_10818_17714.t0 a_10601_17694.t2 VSS.t2324 VSS.t2323 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X174 VSS.t3555 a_24639_11794# a_24729_11890.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X175 a_18209_6290.t2 a_18119_6194# VSS.t2268 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X176 VSS.t3761 VDD.t1291 a_27909_20216.t0 VSS.t3760 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X177 a_34621_6534.t3 a_35132_6560.t2 a_35880_6293.t1 VSS.t1673 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X178 a_24563_950.t0 VSS.t1015 VSS.t1016 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X179 a_3877_17694.t0 a_3280_17493.t2 VSS.t2384 VSS.t2383 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X180 a_48070_9273.t0 CLK.t24 VSS.t1479 VSS.t3667 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X181 a_15035_839.t1 a_15470_873.t3 a_14775_616.t3 VSS.t2096 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X182 a_24563_3750.t4 a_23437_3694.t2 6MSB_0.OUTP.t8 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X183 a_49836_24166.t0 VDD.t1321 VDD.t1161 VDD.t760 sg13_lv_pmos ad=79.8f pd=0.8u as=1.4292p ps=9.04u
+ w=0.42u l=0.13u
X184 a_46225_12194.t0 VSS.t659 VSS.t661 VSS.t660 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X185 a_51440_25469.t0 VSS.t167 VSS.t169 VSS.t168 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X186 VSS.t1318 a_8950_9273.t3 a_9052_9360.t0 VSS.t1317 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X187 VDD.t697 a_35880_693.t2 a_36477_894.t1 VDD.t454 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X188 a_44123_20550.t0 VSS.t239 VSS.t241 VSS.t240 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X189 VDD.t844 VDD.t1283 a_15035_20439.t2 VDD.t7 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X190 VSS.t539 VSS.t536 a_18043_14950.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X191 VDD.t943 a_33490_14598.t2 a_33879_14914.t2 VDD.t846 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X192 a_21581_9334.t3 a_22092_9360.t2 a_22840_9093.t1 VSS.t1364 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X193 a_28327_6229.t0 VDD.t1545 VSS.t3897 VSS.t3896 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X194 a_1995_3639.t1 a_2430_3673.t3 a_2378_3807.t0 VDD.t303 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X195 a_11523_3750.t0 VSS.t914 VSS.t915 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X196 VSS.t2295 a_28510_17673.t3 a_28612_17760.t0 VSS.t2294 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X197 VDD.t306 a_n2646_2484.t11 a_46919_6514.t0 VDD.t0 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X198 VDD.t1162 a_1997_24701.t2 a_2033_24727.t1 VDD.t76 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X199 VSS.t744 VSS.t742 VSS.t743 VSS.t415 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X200 a_11523_6550.t4 a_10397_6494.t2 6MSB_0.OUTP.t56 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X201 a_48920_14693.t0 a_48070_14873.t2 a_47661_14934.t3 VDD.t3 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X202 VDD.t800 a_36681_20494.t2 a_36898_20514.t1 VDD.t793 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X203 VSS.t2873 a_n2044_4040.t6 a_20145_17794.t0 VSS.t3535 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X204 a_18043_6550.t7 a_18119_6194# a_18209_6290.t4 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X205 a_n2347_2880.t0 X8.t2 VSS.t2314 VSS.t2313 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X206 VDD.t1083 a_n2044_4040.t9 a_679_17794.t0 VDD.t752 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X207 VSS.t3293 a_50719_14594# a_50809_14690.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X208 a_10601_6494.t0 a_9800_6293.t2 VSS.t1571 VSS.t1572 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X209 VDD.t1717 a_29360_20293.t2 a_29588_20433.t0 VDD.t9 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X210 a_43201_894.t0 a_42400_693.t2 VSS.t2217 VSS.t2218 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X211 a_10818_9314.t0 a_10601_9294.t2 VSS.t1308 VSS.t1307 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X212 a_42997_3694.t1 a_42400_3493.t2 VDD.t572 VDD.t282 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X213 a_35880_20293.t0 a_35030_20473.t2 a_35786_20293.t1 VSS.t2551 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X214 a_47661_9334.t1 a_47635_9239.t3 VDD.t270 VDD.t2 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X215 a_49517_9294.t1 a_48920_9093.t2 VDD.t274 VDD.t2 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X216 a_11689_20290.t6 a_11599_20194# a_11523_20550.t9 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X217 VSS.t3029 a_11599_14594# a_11689_14690.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X218 VDD.t113 VDD.t1467 a_47635_12039.t2 VDD.t1 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X219 6MSB_0.OUTN.t93 a_4298_9314.t2 a_5003_9350.t6 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X220 VSS.t1241 a_n2770_240.t9 a_585_9394.t0 VSS.t3366 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X221 a_2310_17429.t1 a_2532_17760.t3 a_1995_17639.t1 VSS.t3354 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X222 a_2247_17429.t0 VDD.t1353 VSS.t3702 VSS.t3701 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X223 VDD.t1152 a_n2648_3264.t14 a_20839_17714.t2 VDD.t737 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X224 VDD.t1062 a_41550_17673.t3 a_41652_17760.t1 VDD.t812 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X225 a_18043_14950.t3 a_18119_14594# a_18209_14690.t6 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X226 6MSB_0.OUTP.t92 a_36477_12094.t2 a_37603_12150.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X227 a_5169_6290.t5 a_5079_6194# a_5003_6550.t7 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X228 a_50809_3490.t2 a_50719_3394# VSS.t3489 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X229 a_44123_3750.t8 a_44199_3394# a_44289_3490.t5 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X230 a_10397_17694.t0 a_9800_17493.t2 VSS.t2321 VSS.t2320 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X231 VDD.t890 a_16320_14693.t2 a_16917_14894.t1 VDD.t887 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X232 a_21870_14629.t0 a_22092_14960.t3 a_21555_14839.t1 VSS.t3178 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X233 a_33879_12114.t1 a_n2770_240.t12 a_33778_11817.t1 VSS.t3371 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X234 a_40298_617.t2 VDD.t1679 a_40399_914.t1 VSS.t3981 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X235 a_50809_9090.t4 a_50719_8994# a_50643_9350.t4 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X236 VSS.t2604 VDD.t1281 a_1829_14616.t0 VSS.t3793 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X237 VDD.t766 a_2430_12073.t3 a_2532_12160.t1 VDD.t765 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X238 VSS.t40 VDD.t1265 a_21389_11816.t0 VSS.t3829 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X239 a_50809_14690.t2 a_50719_14594# VSS.t3291 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X240 a_31083_6550.t8 a_31159_6194# a_31249_6290.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X241 VSS.t1054 VSS.t1052 VSS.t1054 VSS.t1053 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X242 VDD.t1031 a_39705_20594.t2 a_40010_20198.t1 VDD.t801 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X243 a_5003_9350.t4 a_3877_9294.t2 6MSB_0.OUTP.t48 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X244 a_11689_3490.t6 a_11599_3394# a_11523_3750.t9 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X245 a_10028_3633.t1 VDD.t1579 VDD.t495 VDD.t301 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X246 VSS.t718 VSS.t714 VSS.t717 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X247 6MSB_0.OUTP.t34 a_36477_3694.t2 a_37603_3750.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X248 6MSB_0.OUTN.t76 a_23858_12114.t2 a_24563_12150.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X249 VDD.t579 a_46225_3794.t2 a_46530_3398.t1 VDD.t293 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X250 a_9800_6293.t1 a_8950_6473.t2 a_9706_6293.t0 VSS.t1563 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X251 a_20450_20198.t0 a_20145_20594.t2 VSS.t266 VSS.t2844 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X252 VDD.t942 a_n2044_1752.t11 a_40399_14914.t1 VDD.t810 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X253 VSS.t1940 a_35880_3493.t2 a_36477_3694.t0 VSS.t1938 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X254 VDD.t1706 a_3280_14693.t2 a_3508_14833.t0 VDD.t817 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X255 a_41430_11829.t0 a_41652_12160.t3 a_41115_12039.t0 VSS.t1140 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X256 6MSB_0.OUTP.t128 a_23437_14894.t2 a_24563_14950.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X257 a_41367_11829.t0 VDD.t1461 VSS.t3843 VSS.t3842 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X258 a_5003_9350.t3 a_5079_8994# a_5169_9090.t6 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X259 a_2430_9273.t1 CLK.t31 VDD.t167 VDD.t122 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X260 a_18209_6290.t0 a_18119_6194# VSS.t816 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X261 VSS.t1626 a_22840_6293.t2 a_23437_6494.t0 VSS.t1624 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X262 6MSB_0.OUTP.t115 a_3877_894.t2 a_5003_950.t5 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X263 VSS.t4220 a_31159_20194# a_31249_20290.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X264 a_28510_873.t1 CLK.t3 VDD.t678 VDD.t456 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X265 a_49517_3694.t0 a_48920_3493.t2 VSS.t1997 VSS.t1996 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X266 VDD.t811 a_n2648_3264.t3 a_39799_14994.t0 VDD.t810 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X267 VSS.t685 VSS.t684 a_18043_9350.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X268 VSS.t736 VSS.t724 a_31083_9350.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X269 a_11689_20290.t1 a_11599_20194# VSS.t2665 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X270 6MSB_0.OUTP.t85 a_36477_14894.t2 a_37603_14950.t5 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X271 a_26970_14598.t1 a_26665_14994.t2 VDD.t885 VDD.t884 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X272 a_37769_14690.t1 a_37679_14594# VSS.t4247 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X273 VSS.t228 VSS.t226 a_31083_20550.t1 VSS.t227 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X274 a_41430_17429.t1 a_41141_17734.t4 a_41367_17429.t0 VSS.t3258 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X275 a_15350_629.t0 a_15572_960.t3 a_15035_839.t1 VSS.t2092 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X276 a_36108_3633.t0 a_35880_3493.t2 a_36299_3416.t0 VSS.t1937 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X277 VDD.t1790 a_49608_24814.t2 a_49836_24954.t0 VDD.t813 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X278 VSS.t2490 a_42400_20293.t2 a_42997_20494.t0 VSS.t2488 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X279 a_7410_8998.t1 a_7105_9394.t2 VDD.t175 VDD.t162 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X280 a_7698_9017.t0 a_7410_8998.t2 VSS.t1305 VSS.t1306 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X281 a_36477_6494.t0 a_35880_6293.t2 VSS.t1679 VSS.t1678 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X282 a_35880_693.t0 a_35030_873.t2 a_34621_934.t3 VDD.t454 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X283 a_34847_3429.t0 VDD.t1599 VSS.t3934 VSS.t3933 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X284 a_9800_3493.t0 a_8950_3673.t2 a_8541_3734.t3 VDD.t301 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X285 a_41115_20439.t1 a_41550_20473.t3 a_40855_20216.t3 VSS.t2625 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X286 VSS.t3299 a_24639_17394# a_24729_17490.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X287 a_31249_14690.t4 a_31159_14594# a_31083_14950.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X288 a_24563_6550.t0 VSS.t778 VSS.t779 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X289 a_21807_629.t0 VDD.t1651 VSS.t3966 VSS.t3965 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X290 a_3699_3416.t0 VDD.t1573 VSS.t1800 VSS.t3915 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X291 VSS.t862 VSS.t860 VSS.t861 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X292 a_11523_14950.t4 a_11599_14594# a_11689_14690.t6 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X293 VSS.t3564 a_18119_11794# a_18209_11890.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X294 VSS.t2166 a_30161_894.t2 a_30378_914.t0 VSS.t2165 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X295 a_46225_17794.t0 VSS.t492 VSS.t494 VSS.t493 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X296 a_29779_14616.t0 VDD.t1419 VSS.t2947 VSS.t3811 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X297 VDD.t557 a_35880_3493.t2 a_36108_3633.t1 VDD.t290 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X298 VDD.t913 a_9800_14693.t2 a_10028_14833.t1 VDD.t912 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X299 a_31249_3490.t1 a_31159_3394# VSS.t4255 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X300 VDD.t502 a_10601_3694.t2 a_10818_3714.t1 VDD.t301 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X301 VSS.t585 VSS.t584 a_18043_12150.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X302 a_1995_9239.t0 a_2430_9273.t3 a_2378_9407.t0 VDD.t122 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X303 VSS.t2143 a_26970_598.t2 a_27258_617.t0 VSS.t2142 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X304 a_30378_17714.t1 a_30161_17694.t2 VDD.t1032 VDD.t733 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X305 VDD.t1161 a_48758_23938.t3 a_48860_23938.t1 VDD.t760 sg13_lv_pmos ad=1.4292p pd=9.04u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X306 VSS.t3022 a_11599_3394# a_11689_3490.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X307 a_890_14598.t0 a_585_14994.t2 VSS.t2848 VSS.t2847 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X308 a_11523_6550.t7 a_11599_6194# a_11689_6290.t4 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X309 VDD.t368 a_22840_6293.t2 a_23068_6433.t1 VDD.t139 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X310 VDD.t1023 a_2430_20473.t3 a_2532_20560.t1 VDD.t5 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X311 VDD.t792 VDD.t1353 a_1995_17639.t2 VDD.t752 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X312 a_36681_12094.t0 a_35880_11893.t2 VSS.t1110 VSS.t1111 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X313 a_n2946_3612.t0 X9.t3 VDD.t1768 VDD.t286 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p ps=2.36u
+ w=0.84u l=0.13u
X314 a_42997_9294.t1 a_42400_9093.t2 VDD.t258 VDD.t147 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X315 a_41141_6534.t0 a_41115_6439.t3 VSS.t1696 VSS.t1695 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X316 a_30378_914.t1 a_30161_894.t2 VDD.t684 VDD.t456 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X317 a_5003_950.t3 a_5079_594# a_5169_690.t6 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X318 6MSB_0.OUTN.t56 a_36898_14914.t2 a_37603_14950.t4 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X319 VSS.t2415 a_44199_14594# a_44289_14690.t1 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X320 6MSB_0.OUTP.t69 a_50817_27517.t2 a_51442_27857.t4 VSS.t3076 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X321 a_18043_20550.t1 a_16917_20494.t2 6MSB_0.OUTP.t25 VSS.t2879 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X322 a_44123_9350.t8 a_44199_8994# a_44289_9090.t5 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X323 6MSB_0.OUTP.t132 a_36477_17694.t2 a_37603_17750.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X324 a_33879_17714.t1 a_n2648_3264.t12 a_33778_17417.t1 VSS.t3428 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X325 a_50809_9090.t2 a_50719_8994# VSS.t2895 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X326 VSS.t1047 VSS.t1041 a_11523_950.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X327 a_n2951_1728.t0 X9.t1 VSS.t4243 VSS.t4242 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X328 a_8950_12073.t0 CLK.t38 VSS.t2447 VSS.t3655 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X329 a_5169_14690.t3 a_5079_14594# VSS.t3014 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X330 a_11523_12150.t0 VSS.t594 VSS.t595 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X331 VSS.t3084 VDD.t1371 a_21389_17416.t0 VSS.t3783 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X332 a_5003_12150.t1 a_3877_12094.t2 6MSB_0.OUTP.t91 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X333 VSS.t1051 VSS.t1048 VSS.t1050 VSS.t1049 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u
+ l=0.45u
X334 a_50218_27219.t0 VDD.t1299 VSS.t3737 VSS.t3736 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X335 a_11689_9090.t6 a_11599_8994# a_11523_9350.t9 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X336 VSS.t1734 a_48920_6293.t2 a_49517_6494.t0 VSS.t1732 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X337 a_5003_14950.t9 a_4298_14914.t2 6MSB_0.OUTN.t59 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X338 VSS.t85 a_30161_12094.t2 a_30378_12114.t0 VSS.t84 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X339 a_10028_9233.t0 VDD.t1483 VDD.t186 VDD.t162 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X340 VDD.t627 a_7105_994.t2 a_7410_598.t1 VDD.t460 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X341 a_18043_950.t1 a_16917_894.t2 6MSB_0.OUTP.t105 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X342 a_10818_3714.t1 a_10601_3694.t2 VDD.t501 VDD.t301 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X343 a_24563_12150.t5 a_23858_12114.t2 6MSB_0.OUTN.t77 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X344 VSS.t176 VSS.t174 a_51440_26253.t1 VSS.t175 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X345 a_36108_12033.t0 a_35880_11893.t2 a_36299_11816.t0 VSS.t1107 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X346 a_14319_6514.t1 a_n2646_2484.t16 a_14218_6217.t0 VSS.t1528 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X347 a_24729_20290.t0 a_24639_20194# VSS.t124 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X348 6MSB_0.OUTN.t124 a_23858_17714.t2 a_24563_17750.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X349 VDD.t872 a_n2044_1752.t9 a_679_12194.t0 VDD.t765 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X350 VDD.t266 a_46225_9394.t2 a_46530_8998.t1 VDD.t2 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X351 a_11689_690.t4 a_11599_594# a_11523_950.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X352 a_24729_3490.t0 a_24639_3394# VSS.t877 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X353 VSS.t1425 a_35880_9093.t2 a_36477_9294.t0 VSS.t1423 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X354 a_24563_17750.t6 a_24639_17394# a_24729_17490.t5 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X355 VDD.t1033 a_30161_17694.t2 a_30378_17714.t1 VDD.t733 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X356 VDD.t1135 a_26665_17794.t2 a_26970_17398.t1 VDD.t733 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X357 a_41430_17429.t0 a_41652_17760.t3 a_41115_17639.t2 VSS.t3257 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X358 a_41367_17429.t0 VDD.t1307 VSS.t3795 VSS.t3794 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X359 VSS.t581 VSS.t576 VSS.t581 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X360 VDD.t307 a_40010_6198.t2 a_40399_6514.t2 VDD.t125 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X361 a_47661_934.t2 a_48172_960.t2 a_48920_693.t1 VSS.t2235 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X362 6MSB_0.OUTN.t89 a_50396_27497.t2 a_51442_27857.t0 VSS.t3440 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X363 VDD.t1128 a_22840_17493.t2 a_23068_17633.t1 VDD.t737 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X364 a_21581_14934.t3 a_22092_14960.t2 a_22840_14693.t0 VSS.t3454 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X365 VSS.t2105 a_16320_693.t2 a_16917_894.t0 VSS.t2104 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X366 6MSB_0.OUTN.t15 a_4298_3714.t2 a_5003_3750.t6 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X367 VSS.t3398 a_16548_12033.t2 a_16226_11893.t1 VSS.t3397 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X368 VSS.t1517 a_n2646_2484.t10 a_585_3794.t0 VSS.t1516 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X369 a_15470_12073.t0 CLK.t37 VSS.t3402 VSS.t3656 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X370 VDD.t1113 a_n2770_240.t14 a_20839_12114.t2 VDD.t34 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X371 VDD.t99 a_41550_12073.t3 a_41652_12160.t1 VDD.t91 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X372 6MSB_0.OUTP.t59 a_3877_6494.t2 a_5003_6550.t5 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X373 VDD.t689 a_33490_598.t2 a_33879_914.t0 VDD.t454 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X374 a_49148_6433.t0 a_48920_6293.t2 a_49339_6216.t0 VSS.t1731 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X375 a_8541_12134.t0 a_8515_12039.t3 VSS.t2471 VSS.t2470 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X376 a_40010_11798.t0 a_39705_12194.t2 VSS.t1125 VSS.t1124 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X377 a_20839_17714.t0 a_20450_17398.t2 VDD.t1005 VDD.t737 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X378 a_49517_9294.t0 a_48920_9093.t2 VSS.t1482 VSS.t1481 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X379 a_24563_950.t9 a_24639_594# a_24729_690.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X380 VSS.t689 VSS.t688 a_11523_9350.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X381 a_47887_6229.t0 VDD.t1563 VSS.t3910 VSS.t3909 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X382 a_7105_20594.t0 a_2713_24910.t9 VSS.t3003 VSS.t3002 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X383 a_44123_17750.t2 VSS.t414 VSS.t483 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X384 VSS.t125 VSS.t122 VSS.t124 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X385 a_5003_14950.t6 a_5079_14594# a_5169_14690.t5 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X386 a_36108_9233.t1 a_35880_9093.t2 a_36299_9016.t0 VSS.t1422 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X387 a_34595_839.t0 a_35030_873.t3 a_34335_616.t3 VSS.t2180 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X388 a_n2946_4060.t1 X8.t3 VDD.t738 VDD.t434 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p ps=2.36u
+ w=0.84u l=0.13u
X389 a_11523_14950.t8 a_10818_14914.t2 6MSB_0.OUTN.t53 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X390 a_13719_14994.t0 a_1253_24711.t7 a_13625_14994.t1 VDD.t887 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X391 a_5003_950.t0 VSS.t1005 VSS.t1006 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X392 VSS.t2015 X9.t0 a_n2852_1036.t0 VSS.t4245 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1216p ps=1.02u
+ w=0.64u l=0.13u
X393 VDD.t428 a_48920_6293.t2 a_49148_6433.t1 VDD.t0 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X394 a_48323_24960.t0 a_48758_24994.t3 a_48706_25128.t0 VDD.t813 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X395 a_5003_14950.t7 a_3877_14894.t2 6MSB_0.OUTP.t18 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X396 a_23068_14833.t0 a_22840_14693.t2 a_23259_14616.t0 VSS.t2697 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X397 a_9800_9093.t0 a_8950_9273.t2 a_8541_9334.t3 VDD.t162 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X398 a_34847_9029.t0 VDD.t1503 VSS.t3870 VSS.t3869 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X399 a_5003_3750.t4 a_3877_3694.t2 6MSB_0.OUTP.t16 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X400 a_46225_994.t0 VSS.t1086 VSS.t1088 VSS.t1087 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X401 VSS.t2960 a_18119_17394# a_18209_17490.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X402 a_3699_9016.t0 VDD.t1477 VSS.t1288 VSS.t3851 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X403 VSS.t4144 a_24639_6194# a_24729_6290.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X404 VDD.t864 a_42400_14693.t2 a_42628_14833.t1 VDD.t810 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X405 VDD.t243 a_35880_9093.t2 a_36108_9233.t0 VDD.t150 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X406 a_4081_3694.t0 a_3280_3493.t2 VSS.t1805 VSS.t1806 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X407 a_11523_9350.t5 a_10818_9314.t2 6MSB_0.OUTN.t51 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X408 VDD.t183 a_10601_9294.t2 a_10818_9314.t1 VDD.t162 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X409 a_31249_9090.t1 a_31159_8994# VSS.t2503 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X410 a_48949_27476.t0 CLK.t66 VSS.t2940 VSS.t3006 sg13_lv_nmos ad=0.2516p pd=2.16u as=1.51765p
+ ps=9.285u w=0.74u l=0.13u
X411 VSS.t352 VSS.t350 a_18043_17750.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X412 a_26970_8998.t0 a_26665_9394.t2 VSS.t1378 VSS.t1377 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X413 a_4298_6514.t0 a_4081_6494.t2 VSS.t1548 VSS.t1547 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X414 a_20839_914.t2 VDD.t1647 VDD.t659 VDD.t458 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X415 a_890_598.t0 a_585_994.t2 VSS.t1777 VSS.t2024 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X416 a_10818_20514.t0 a_10601_20494.t2 VSS.t4305 VSS.t4304 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X417 a_5169_14690.t5 a_5079_14594# a_5003_14950.t5 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X418 VSS.t4271 a_11599_8994# a_11689_9090.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X419 a_3877_20494.t0 a_3280_20293.t2 VSS.t3183 VSS.t3182 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X420 a_5003_6550.t9 a_5079_6194# a_5169_6290.t7 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X421 VSS.t3132 a_24639_594# a_24729_690.t1 VSS.t3131 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X422 a_15061_12134.t0 a_15035_12039.t3 VSS.t3394 VSS.t3393 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X423 a_n2042_2484.t0 a_n2347_2880.t2 VSS.t1498 VSS.t2004 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X424 a_n2648_4040.t1 a_n2946_4060.t2 VDD.t435 VDD.t434 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.1918p
+ ps=1.5u w=1.12u l=0.13u
X425 VDD.t815 a_4285_24701.t2 a_4321_24727.t1 VDD.t77 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X426 a_28075_17639.t1 a_28510_17673.t3 a_28458_17807.t0 VDD.t733 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X427 a_36681_17694.t0 a_35880_17493.t2 VSS.t2720 VSS.t2721 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X428 VDD.t539 VDD.t1593 a_28075_3639.t2 VDD.t295 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X429 a_11523_14950.t6 a_11599_14594# a_11689_14690.t5 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X430 VSS.t11 a_9800_11893.t2 a_10397_12094.t0 VSS.t9 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X431 a_27258_3417.t0 a_26970_3398.t2 VSS.t1897 VSS.t1896 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X432 VSS.t2958 a_28510_20473.t3 a_28612_20560.t0 VSS.t2957 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X433 VSS.t919 VSS.t918 a_18043_3750.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X434 6MSB_0.OUTN.t50 a_10818_9314.t2 a_11523_9350.t4 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X435 VDD.t128 a_n2042_972.t7 a_13719_6594.t0 VDD.t127 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X436 VSS.t266 VSS.t264 a_20145_20594.t0 VSS.t265 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X437 VDD.t350 VDD.t1533 a_15035_6439.t2 VDD.t127 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X438 VSS.t1072 VSS.t1067 VSS.t1072 VSS.t1071 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X439 VDD.t6 VSS.t236 a_679_20594.t0 VDD.t5 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X440 a_8950_17673.t0 CLK.t54 VSS.t3249 VSS.t3642 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X441 a_50809_14690.t4 a_50719_14594# a_50643_14950.t6 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X442 a_11523_17750.t0 VSS.t347 VSS.t349 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X443 a_5003_17750.t1 a_3877_17694.t2 6MSB_0.OUTP.t95 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X444 a_3280_14693.t0 a_2430_14873.t2 a_2021_14934.t2 VDD.t817 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X445 VSS.t634 a_37679_11794# a_37769_11890.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X446 a_1261_25305.t1 X6.t4 VDD.t839 VDD.t76 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.1918p ps=1.5u
+ w=0.84u l=0.13u
X447 a_2310_20229.t0 a_2532_20560.t3 a_1995_20439.t1 VSS.t3207 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X448 VDD.t1181 a_n2044_4040.t13 a_20839_20514.t2 VDD.t11 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X449 VDD.t802 a_41550_20473.t3 a_41652_20560.t1 VDD.t801 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X450 a_11689_14690.t5 a_11599_14594# a_11523_14950.t5 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X451 a_20450_598.t0 a_20145_994.t2 VSS.t1773 VSS.t2111 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X452 a_14775_3416.t0 a_14319_3714.t3 VDD.t507 VDD.t299 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X453 a_2713_25289.t1 X6.t2 a_3161_25540.t0 VDD.t71 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X454 a_2247_20229.t0 VDD.t1295 VSS.t3750 VSS.t3749 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X455 a_10397_20494.t0 a_9800_20293.t2 VSS.t4300 VSS.t4299 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X456 a_28458_17807.t0 a_28101_17734.t4 VDD.t734 VDD.t733 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X457 VDD.t1063 VDD.t1307 a_41115_17639.t0 VDD.t812 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X458 a_30378_12114.t1 a_30161_12094.t2 VDD.t64 VDD.t50 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X459 a_37769_6290.t0 a_37679_6194# VSS.t830 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X460 VSS.t2227 a_46530_598.t2 a_46818_617.t0 VSS.t2226 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X461 a_11523_950.t1 a_10397_894.t2 6MSB_0.OUTP.t111 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X462 a_37769_3490.t5 a_37679_3394# a_37603_3750.t7 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X463 VSS.t3196 a_30161_17694.t2 a_30378_17714.t0 VSS.t3195 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X464 VSS.t550 VSS.t547 VSS.t550 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X465 6MSB_0.OUTP.t65 a_36477_9294.t2 a_37603_9350.t5 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X466 a_18043_6550.t1 a_16917_6494.t2 6MSB_0.OUTP.t45 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X467 a_24563_17750.t5 a_23858_17714.t2 6MSB_0.OUTN.t125 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X468 a_26759_17794.t0 a_2033_24727.t8 a_26665_17794.t1 VDD.t733 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X469 a_10818_9314.t1 a_10601_9294.t2 VDD.t182 VDD.t162 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X470 VSS.t2184 a_36108_833.t2 a_35786_693.t1 VSS.t2183 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X471 a_8255_616.t1 a_7799_914.t3 VDD.t630 VDD.t460 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p ps=1.52u
+ w=0.42u l=0.13u
X472 a_36108_17633.t1 a_35880_17493.t2 a_36299_17416.t0 VSS.t2717 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X473 a_49148_17633.t1 VDD.t1303 VDD.t1051 VDD.t905 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X474 VDD.t876 VDD.t1435 a_1995_12039.t2 VDD.t765 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X475 6MSB_0.OUTN.t33 a_23858_9314.t2 a_24563_9350.t5 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X476 a_49938_3714.t1 a_49721_3694.t2 VDD.t593 VDD.t293 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X477 a_24729_9090.t0 a_24639_8994# VSS.t722 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X478 VSS.t1583 a_13930_6198.t2 a_14218_6217.t2 VSS.t1584 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X479 a_7698_14617.t0 a_7410_14598.t2 VSS.t4004 VSS.t4005 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X480 VSS.t3344 a_4285_25305.t2 a_4305_24905.t0 VSS.t3343 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X481 a_27815_14616.t2 a_27359_14914.t3 VDD.t1078 VDD.t884 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X482 a_27258_11817.t1 a_26970_11798.t2 VSS.t63 VSS.t62 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X483 a_18043_17750.t2 VSS.t295 VSS.t308 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X484 VSS.t2858 a_2430_14873.t3 a_2532_14960.t0 VSS.t2857 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X485 VSS.t1300 a_13625_9394.t2 a_13930_8998.t0 VSS.t1299 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X486 a_21295_6216.t2 a_22092_6560.t3 a_21555_6439.t0 VDD.t139 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X487 VSS.t2425 a_16548_17633.t2 a_16226_17493.t0 VSS.t2424 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X488 VSS.t46 a_21990_12073.t3 a_22092_12160.t0 VSS.t45 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X489 a_48070_12073.t0 CLK.t32 VSS.t1184 VSS.t3623 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X490 a_34910_629.t0 a_35132_960.t3 a_34595_839.t0 VSS.t2174 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X491 a_39799_3794.t0 a_4321_24727.t3 a_39705_3794.t1 VDD.t282 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X492 a_5169_3490.t2 a_5079_3394# VSS.t4236 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X493 a_42628_6433.t0 a_42400_6293.t2 a_42819_6216.t0 VSS.t1705 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X494 a_15470_17673.t0 CLK.t53 VSS.t3353 VSS.t3643 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X495 a_44289_14690.t3 a_44199_14594# VSS.t2411 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X496 a_44123_12150.t1 a_42997_12094.t2 6MSB_0.OUTP.t89 VSS.t1167 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X497 a_8541_17734.t2 a_8515_17639.t3 VSS.t3340 VSS.t3339 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X498 a_40010_17398.t0 a_39705_17794.t2 VSS.t3533 VSS.t4120 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X499 a_41367_629.t0 VDD.t1677 VSS.t3984 VSS.t3983 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X500 VSS.t2848 a_n2648_3264.t9 a_585_14994.t0 VSS.t3423 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X501 a_26759_6594.t0 a_2033_24727.t4 a_26665_6594.t1 VDD.t137 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X502 a_36681_894.t1 a_35880_693.t2 VDD.t697 VDD.t454 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X503 VSS.t4259 a_31159_3394# a_31249_3490.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X504 a_44123_14950.t7 a_43418_14914.t2 6MSB_0.OUTN.t75 VSS.t1131 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X505 a_50809_690.t0 a_50719_594# VSS.t1090 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X506 VSS.t2700 a_22840_14693.t2 a_23437_14894.t0 VSS.t2698 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X507 VDD.t414 a_42400_6293.t2 a_42628_6433.t1 VDD.t125 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X508 VSS.t2010 a_n2646_1728.t2 a_n2248_2100.t0 VSS.t2009 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X509 a_5003_6550.t0 VSS.t764 VSS.t765 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u w=0.5u
+ l=0.13u
X510 a_29360_6293.t1 a_28510_6473.t2 a_29266_6293.t0 VSS.t1644 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X511 a_8950_14873.t1 CLK.t46 VDD.t1220 VDD.t912 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X512 a_36681_14894.t1 a_35880_14693.t2 VDD.t849 VDD.t846 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X513 VDD.t1650 VDD.t1647 a_20839_914.t2 VDD.t458 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X514 a_5003_3750.t7 a_5079_3394# a_5169_3490.t4 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X515 a_37603_950.t7 a_37679_594# a_37769_690.t4 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X516 a_49608_24814.t0 a_48758_24994.t2 a_49514_24814.t0 VSS.t2971 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X517 VDD.t888 a_16548_14833.t2 a_16509_14931.t0 VDD.t887 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X518 a_41430_20229.t1 a_41141_20534.t4 a_41367_20229.t0 VSS.t2501 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X519 a_14218_14617.t1 a_13930_14598.t2 VSS.t2759 VSS.t2758 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X520 a_4081_9294.t0 a_3280_9093.t2 VSS.t1285 VSS.t1286 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X521 a_50809_11890.t0 a_50719_11794# VSS.t643 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X522 a_24563_12150.t7 a_24639_11794# a_24729_11890.t5 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X523 VDD.t65 a_30161_12094.t2 a_30378_12114.t1 VDD.t50 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X524 a_13930_598.t1 a_13625_994.t2 VDD.t445 VDD.t444 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X525 6MSB_0.OUTP.t113 a_23437_894.t2 a_24563_950.t5 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X526 VSS.t3149 a_24639_20194# a_24729_20290.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X527 VDD.t52 a_26665_12194.t2 a_26970_11798.t1 VDD.t50 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X528 VSS.t1994 a_48070_3673.t3 a_48172_3760.t0 VSS.t1993 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X529 VDD.t44 a_22840_11893.t2 a_23068_12033.t1 VDD.t34 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X530 a_47661_12134.t0 a_47635_12039.t3 VSS.t1179 VSS.t1178 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X531 a_42628_833.t0 a_42400_693.t2 a_42819_616.t0 VSS.t2213 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X532 a_15061_17734.t1 a_15035_17639.t3 VSS.t2558 VSS.t2557 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X533 a_24729_17490.t7 a_24639_17394# a_24563_17750.t7 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X534 a_47635_3639.t1 a_48070_3673.t3 a_48018_3807.t0 VDD.t293 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X535 VDD.t524 VDD.t1587 a_21555_3639.t2 VDD.t297 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X536 a_20450_3398.t1 a_20145_3794.t2 VDD.t298 VDD.t297 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X537 VDD.t226 VDD.t1497 a_28075_9239.t2 VDD.t153 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X538 a_20738_3417.t0 a_20450_3398.t2 VSS.t1870 VSS.t1871 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X539 a_20839_12114.t0 a_20450_11798.t2 VDD.t37 VDD.t34 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X540 a_28390_11829.t1 a_28101_12134.t4 a_28327_11829.t0 VSS.t69 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X541 a_27258_9017.t0 a_26970_8998.t2 VSS.t1382 VSS.t1383 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X542 VSS.t2319 a_9800_17493.t2 a_10397_17694.t0 VSS.t2320 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X543 a_33778_11817.t2 a_n2770_240.t12 a_33879_12114.t1 VSS.t3372 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X544 a_8541_934.t1 a_8515_839.t3 VDD.t631 VDD.t460 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X545 VSS.t911 VSS.t910 a_11523_3750.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X546 a_30378_20514.t1 a_30161_20494.t2 VDD.t1722 VDD.t9 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X547 a_44123_12150.t2 VSS.t635 VSS.t641 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X548 a_34595_6439.t0 a_35030_6473.t3 a_34978_6607.t0 VDD.t135 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X549 a_44123_14950.t8 a_42997_14894.t2 6MSB_0.OUTP.t80 VSS.t1165 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X550 a_23259_3416.t0 VDD.t1591 VSS.t1888 VSS.t3927 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X551 a_15470_14873.t1 CLK.t45 VDD.t888 VDD.t887 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X552 VSS.t644 VSS.t642 VSS.t643 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X553 VSS.t907 VSS.t904 VSS.t906 VSS.t905 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X554 VDD.t1040 VDD.t1295 a_1995_20439.t2 VDD.t5 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X555 a_5169_6290.t6 a_5079_6194# a_5003_6550.t9 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X556 VSS.t524 VSS.t429 a_5003_14950.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X557 VSS.t803 VSS.t782 VSS.t802 VSS.t801 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X558 a_2430_873.t1 CLK.t7 VDD.t618 VDD.t462 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X559 a_27815_6216.t1 a_27359_6514.t3 VDD.t378 VDD.t137 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X560 a_11523_950.t6 a_10818_914.t2 6MSB_0.OUTN.t108 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X561 VSS.t413 a_37679_17394# a_37769_17490.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X562 a_n2042_972.t0 a_n2347_1368.t2 VSS.t2019 VSS.t2020 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X563 a_51453_23453.t1 a_50205_23947.t2 6MSB_0.OUTN.t5 VSS.t3330 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X564 a_44289_14690.t5 a_44199_14594# a_44123_14950.t5 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X565 a_11523_3750.t5 a_10818_3714.t2 6MSB_0.OUTN.t7 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X566 VSS.t1125 a_n2044_1752.t3 a_39705_12194.t0 VSS.t2606 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X567 a_31249_690.t4 a_31159_594# a_31083_950.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X568 a_26970_3398.t0 a_26665_3794.t2 VSS.t1509 VSS.t1893 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X569 6MSB_0.OUTP.t26 a_36477_20494.t2 a_37603_20550.t0 VSS.t2570 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X570 a_14775_9016.t1 a_14319_9314.t3 VDD.t192 VDD.t159 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X571 VSS.t1298 a_n2770_240.t7 a_13625_9394.t0 VSS.t3364 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X572 a_11523_6550.t1 a_10397_6494.t2 6MSB_0.OUTP.t57 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X573 a_41430_3429.t1 a_41141_3734.t4 a_41367_3429.t0 VSS.t1956 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X574 a_8541_3734.t0 a_8515_3639.t3 VSS.t1820 VSS.t1819 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X575 a_33879_20514.t2 a_n2044_4040.t11 a_33778_20217.t1 VSS.t3540 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X576 a_37769_9090.t5 a_37679_8994# a_37603_9350.t7 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X577 a_31083_17750.t9 a_31159_17394# a_31249_17490.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X578 a_40399_914.t2 VDD.t1679 VDD.t704 VDD.t448 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X579 a_8515_14839.t0 a_8950_14873.t3 a_8898_15007.t0 VDD.t912 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X580 6MSB_0.OUTN.t69 a_30378_12114.t2 a_31083_12150.t6 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X581 VSS.t3606 a_44199_594# a_44289_690.t1 VSS.t3605 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X582 6MSB_0.OUTN.t98 a_23858_914.t2 a_24563_950.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X583 VSS.t3314 VDD.t1335 a_21389_20216.t0 VSS.t3757 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X584 a_5003_14950.t3 a_5079_14594# a_5169_14690.t4 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X585 a_28075_12039.t0 a_28510_12073.t3 a_28458_12207.t0 VDD.t50 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X586 a_49938_9314.t1 a_49721_9294.t2 VDD.t278 VDD.t2 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X587 a_13930_6198.t0 a_13625_6594.t2 VSS.t1238 VSS.t1579 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X588 a_3699_11816.t0 VDD.t1433 VSS.t2427 VSS.t3821 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X589 VDD.t1708 a_3280_14693.t2 a_3877_14894.t1 VDD.t817 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X590 VSS.t1696 VDD.t1557 a_40949_6216.t0 VSS.t3904 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X591 a_44123_950.t9 a_44199_594# a_44289_690.t7 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X592 a_27258_17417.t0 a_26970_17398.t2 VSS.t4313 VSS.t4312 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X593 VDD.t281 a_585_6594.t2 a_890_6198.t1 VDD.t143 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X594 VSS.t1574 a_10028_6433.t2 a_9706_6293.t1 VSS.t1573 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X595 a_15418_6607.t0 a_15061_6534.t4 VDD.t350 VDD.t127 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X596 6MSB_0.OUTN.t6 a_10818_3714.t2 a_11523_3750.t4 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X597 a_48323_24960.t1 a_48758_24994.t3 a_48063_24737.t1 VSS.t2975 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X598 a_48070_17673.t0 CLK.t48 VSS.t3237 VSS.t3647 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X599 a_9800_11893.t1 a_8950_12073.t2 a_9706_11893.t1 VSS.t2443 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X600 a_39799_9394.t0 a_4321_24727.t5 a_39705_9394.t1 VDD.t147 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X601 a_11689_690.t6 a_11599_594# a_11523_950.t9 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X602 VSS.t3645 a_21990_17673.t3 a_22092_17760.t0 VSS.t4172 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X603 a_5169_9090.t2 a_5079_8994# VSS.t4085 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X604 VDD.t647 VDD.t1641 a_15035_839.t2 VDD.t444 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X605 a_44123_3750.t3 a_44199_3394# a_44289_3490.t6 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X606 6MSB_0.OUTN.t24 a_23858_20514.t2 a_24563_20550.t4 VSS.t3463 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X607 a_41550_3673.t1 CLK.t9 VDD.t570 VDD.t282 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X608 a_44123_17750.t1 a_42997_17694.t2 6MSB_0.OUTP.t41 VSS.t2891 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X609 VSS.t3177 a_20145_14994.t2 a_20450_14598.t0 VSS.t3176 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X610 a_42400_14693.t1 a_41550_14873.t2 a_41141_14934.t0 VDD.t810 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X611 a_14319_914.t1 VDD.t1637 a_14218_617.t1 VSS.t3956 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X612 a_35880_3493.t1 a_35030_3673.t2 a_35786_3493.t0 VSS.t1930 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X613 a_11689_3490.t4 a_11599_3394# a_11523_3750.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X614 a_24563_20550.t6 a_24639_20194# a_24729_20290.t7 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X615 VDD.t1723 a_30161_20494.t2 a_30378_20514.t1 VDD.t9 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X616 a_41430_20229.t0 a_41652_20560.t3 a_41115_20439.t1 VSS.t2500 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X617 a_41367_20229.t0 VDD.t1277 VSS.t3768 VSS.t3767 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X618 VDD.t819 a_26665_20594.t2 a_26970_20198.t1 VDD.t9 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X619 a_47661_12134.t2 a_48172_12160.t2 a_48920_11893.t1 VSS.t1181 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X620 VSS.t2507 a_31159_8994# a_31249_9090.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X621 VDD.t328 a_4081_6494.t2 a_4298_6514.t1 VDD.t143 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X622 a_31083_6550.t3 a_31159_6194# a_31249_6290.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X623 a_27258_617.t1 a_26970_598.t2 VSS.t2143 VSS.t2144 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X624 VDD.t1764 a_22840_20293.t2 a_23068_20433.t0 VDD.t11 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X625 a_8898_15007.t0 a_8541_14934.t4 VDD.t1400 VDD.t912 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X626 a_46818_14617.t2 a_n2044_1752.t10 a_46919_14914.t1 VSS.t2820 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X627 a_22840_6293.t1 a_21990_6473.t2 a_22746_6293.t0 VSS.t1616 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X628 6MSB_0.OUTN.t111 a_36898_914.t2 a_37603_950.t6 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X629 VDD.t1402 VDD.t1399 a_8255_14616.t2 VDD.t912 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X630 a_28458_12207.t0 a_28101_12134.t4 VDD.t57 VDD.t50 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X631 VDD.t98 VDD.t1461 a_41115_12039.t2 VDD.t91 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X632 a_5003_9350.t1 a_3877_9294.t2 6MSB_0.OUTP.t49 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X633 VDD.t544 a_29360_3493.t2 a_29957_3694.t1 VDD.t295 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X634 a_20839_20514.t0 a_20450_20198.t2 VDD.t1081 VDD.t11 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X635 a_18043_17750.t7 a_18119_17394# a_18209_17490.t6 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X636 a_15035_14839.t1 a_15470_14873.t3 a_15418_15007.t0 VDD.t887 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X637 a_14869_14616.t0 a_14319_14914.t3 a_14775_14616.t0 VSS.t2761 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X638 VDD.t476 a_7410_3398.t2 a_7799_3714.t2 VDD.t301 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X639 6MSB_0.OUTP.t35 a_36477_3694.t2 a_37603_3750.t4 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X640 a_2021_14934.t1 a_1995_14839.t3 VDD.t841 VDD.t817 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X641 a_26759_12194.t0 a_2033_24727.t6 a_26665_12194.t1 VDD.t50 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X642 a_5003_9350.t7 a_5079_8994# a_5169_9090.t4 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X643 a_46818_3417.t0 a_46530_3398.t2 VSS.t1981 VSS.t1982 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X644 VSS.t1901 VDD.t1593 a_27909_3416.t0 VSS.t3928 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X645 a_46818_14617.t1 a_46530_14598.t2 VSS.t2449 VSS.t2448 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X646 6MSB_0.OUTP.t78 a_29957_12094.t2 a_31083_12150.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X647 a_10219_11816.t0 VDD.t1269 VSS.t7 VSS.t3695 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X648 a_49148_12033.t1 VDD.t1471 VDD.t114 VDD.t1 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X649 a_44123_20550.t2 VSS.t318 VSS.t325 VSS.t319 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X650 VDD.t915 a_9800_14693.t2 a_10397_14894.t1 VDD.t912 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X651 6MSB_0.OUTN.t29 a_23858_3714.t2 a_24563_3750.t6 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X652 a_26665_9394.t0 a_2033_24727.t5 VSS.t2530 VSS.t2529 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X653 a_11689_690.t2 a_11599_594# VSS.t3068 VSS.t3069 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X654 a_48349_23931.t2 a_48323_23895.t3 VSS.t3560 VSS.t3215 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X655 a_50809_17490.t0 a_50719_17394# VSS.t420 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X656 6MSB_0.OUTP.t121 a_23437_6494.t2 a_24563_6550.t5 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X657 a_33490_6198.t1 a_33185_6594.t2 VDD.t136 VDD.t135 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X658 VSS.t1963 a_41550_3673.t3 a_41652_3760.t0 VSS.t1962 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X659 a_16320_11893.t1 a_15470_12073.t2 a_16226_11893.t0 VSS.t3396 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X660 VSS.t1479 a_48070_9273.t3 a_48172_9360.t0 VSS.t1478 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X661 VSS.t1587 VDD.t1533 a_14869_6216.t0 VSS.t3888 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X662 a_33778_6217.t0 a_33490_6198.t2 VSS.t1664 VSS.t1663 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X663 a_47661_3734.t2 a_48172_3760.t2 a_48920_3493.t1 VSS.t1991 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X664 a_47661_17734.t2 a_47635_17639.t3 VSS.t3739 VSS.t4317 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X665 a_18043_12150.t2 VSS.t446 VSS.t609 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X666 a_21295_616.t3 a_22092_960.t3 a_21555_839.t0 VDD.t458 sg13_lv_pmos ad=0.1428p pd=1.52u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X667 a_41115_3639.t1 a_41550_3673.t3 a_41498_3807.t0 VDD.t282 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X668 VSS.t1840 a_13625_3794.t2 a_13930_3398.t0 VSS.t1839 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X669 VDD.t302 a_n2646_2484.t9 a_7199_3794.t0 VDD.t301 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X670 VSS.t3468 a_1997_24701.t2 a_2033_24727.t0 VSS.t4165 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X671 VSS.t2837 a_18119_20194# a_18209_20290.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X672 a_37603_14950.t6 a_36898_14914.t2 6MSB_0.OUTN.t56 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X673 a_47635_9239.t1 a_48070_9273.t3 a_48018_9407.t0 VDD.t2 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X674 a_7698_6217.t1 a_n2646_2484.t17 a_7799_6514.t0 VSS.t1531 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X675 a_37603_950.t4 a_36477_894.t2 6MSB_0.OUTP.t106 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X676 VDD.t211 VDD.t1491 a_21555_9239.t2 VDD.t156 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X677 a_36299_6216.t0 VDD.t1555 VSS.t1672 VSS.t3903 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X678 a_18209_17490.t6 a_18119_17394# a_18043_17750.t6 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X679 a_20450_8998.t1 a_20145_9394.t2 VDD.t205 VDD.t156 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X680 VSS.t216 VSS.t214 a_18043_20550.t1 VSS.t215 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X681 a_28390_17429.t1 a_28101_17734.t4 a_28327_17429.t0 VSS.t2290 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X682 a_20738_9017.t0 a_20450_8998.t2 VSS.t1354 VSS.t1353 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X683 a_33778_17417.t2 a_n2648_3264.t12 a_33879_17714.t1 VSS.t3429 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X684 a_15418_15007.t0 a_15061_14934.t4 VDD.t925 VDD.t887 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X685 VSS.t3522 a_5079_11794# a_5169_11890.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X686 a_48070_14873.t1 CLK.t40 VDD.t732 VDD.t3 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X687 a_23259_9016.t0 VDD.t1495 VSS.t1363 VSS.t3863 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X688 VSS.t421 VSS.t418 VSS.t420 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X689 VSS.t593 VSS.t592 a_5003_12150.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X690 a_37603_3750.t9 a_37679_3394# a_37769_3490.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X691 a_28075_20439.t0 a_28510_20473.t3 a_28458_20607.t0 VDD.t9 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X692 a_36681_20494.t0 a_35880_20293.t2 VSS.t2479 VSS.t2480 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X693 6MSB_0.OUTN.t129 a_43418_9314.t2 a_44123_9350.t5 VSS.t1130 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X694 VSS.t2182 a_35030_873.t3 a_35132_960.t0 VSS.t2181 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X695 VDD.t981 a_50027_26708.t2 a_49988_26592.t0 VDD.t13 sg13_lv_pmos ad=1.4292p pd=9.04u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X696 a_4298_6514.t1 a_4081_6494.t2 VDD.t327 VDD.t143 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X697 a_40010_6198.t0 a_39705_6594.t2 VSS.t1236 VSS.t1686 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X698 a_44289_6290.t5 a_44199_6194# a_44123_6550.t7 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X699 VDD.t1682 VDD.t1679 a_40399_914.t2 VDD.t448 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X700 a_1279_3714.t1 a_n2042_2484.t17 a_1178_3417.t1 VSS.t1792 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X701 a_11523_6550.t6 a_10818_6514.t2 6MSB_0.OUTN.t80 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X702 a_21295_17416.t2 a_22092_17760.t3 a_21555_17639.t0 VDD.t737 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X703 VSS.t1408 a_33185_9394.t2 a_33490_8998.t0 VSS.t1407 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X704 VSS.t3533 a_n2044_4040.t3 a_39705_17794.t0 VSS.t3532 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X705 6MSB_0.OUTP.t11 a_29957_14894.t2 a_31083_14950.t5 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X706 a_20450_14598.t1 a_20145_14994.t2 VDD.t1021 VDD.t736 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X707 VDD.t1076 a_n2648_3264.t4 a_33279_14994.t0 VDD.t846 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X708 a_17121_894.t0 a_16320_693.t2 VSS.t2105 VSS.t2106 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X709 a_13625_12194.t0 a_1253_24711.t6 VSS.t2541 VSS.t2540 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X710 a_8541_9334.t0 a_8515_9239.t3 VSS.t1312 VSS.t1311 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X711 a_41430_9029.t1 a_41141_9334.t4 a_41367_9029.t0 VSS.t1444 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X712 a_8950_20473.t0 CLK.t61 VSS.t2423 VSS.t3639 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X713 VSS.t3447 a_50719_11794# a_50809_11890.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X714 a_11523_20550.t0 VSS.t208 VSS.t210 VSS.t209 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X715 a_24729_11890.t7 a_24639_11794# a_24563_12150.t8 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X716 a_51442_27857.t3 a_50396_27497.t2 6MSB_0.OUTN.t89 VSS.t3441 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X717 6MSB_0.OUTN.t49 a_30378_17714.t2 a_31083_17750.t5 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X718 a_31249_11890.t2 a_31159_11794# VSS.t3579 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X719 a_44123_9350.t4 a_42997_9294.t2 6MSB_0.OUTP.t62 VSS.t1165 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X720 6MSB_0.OUTN.t122 a_23858_6514.t2 a_24563_6550.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X721 a_5003_20550.t1 a_3877_20494.t2 6MSB_0.OUTP.t77 VSS.t4126 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X722 a_3699_17416.t0 VDD.t1351 VSS.t2381 VSS.t3769 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X723 a_28458_20607.t0 a_28101_20534.t4 VDD.t988 VDD.t9 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X724 VDD.t1129 a_22840_17493.t2 a_23437_17694.t1 VDD.t737 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X725 a_23259_14616.t0 VDD.t1421 VSS.t2696 VSS.t3802 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X726 a_31083_9350.t0 VSS.t692 VSS.t693 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X727 a_48920_6293.t1 a_48070_6473.t2 a_48826_6293.t0 VSS.t1724 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X728 VSS.t4099 a_30161_20494.t2 a_30378_20514.t0 VSS.t4098 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X729 VDD.t807 VDD.t1277 a_41115_20439.t2 VDD.t801 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X730 VSS.t479 VSS.t478 a_44123_14950.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X731 a_34595_839.t1 a_35030_873.t3 a_34978_1007.t0 VDD.t454 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X732 a_26759_20594.t0 a_2033_24727.t9 a_26665_20594.t1 VDD.t9 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X733 VSS.t95 a_33490_11798.t2 a_33778_11817.t0 VSS.t94 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X734 a_24563_20550.t5 a_23858_20514.t2 6MSB_0.OUTN.t25 VSS.t3466 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X735 a_9800_17493.t0 a_8950_17673.t2 a_9706_17493.t0 VSS.t3243 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X736 VSS.t1743 a_n2946_4060.t2 a_n2648_4040.t0 VSS.t1742 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X737 VSS.t1726 a_49148_6433.t2 a_48826_6293.t1 VSS.t1725 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X738 a_36108_20433.t0 a_35880_20293.t2 a_36299_20216.t0 VSS.t2476 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X739 a_29360_14693.t0 a_28510_14873.t2 a_29266_14693.t0 VSS.t2941 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X740 a_41550_9273.t1 CLK.t25 VDD.t257 VDD.t147 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X741 a_44123_9350.t3 a_44199_8994# a_44289_9090.t6 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X742 VSS.t1764 a_n2042_2484.t2 a_46225_994.t0 VSS.t1763 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X743 a_11689_9090.t4 a_11599_8994# a_11523_9350.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X744 a_35880_9093.t1 a_35030_9273.t2 a_35786_9093.t0 VSS.t1417 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X745 6MSB_0.OUTP.t99 a_49517_12094.t2 a_50643_12150.t8 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X746 a_50809_11890.t1 a_50719_11794# VSS.t3445 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X747 VDD.t413 a_42400_6293.t2 a_42997_6494.t1 VDD.t125 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X748 a_48063_24737.t0 a_48860_25081.t3 a_48323_24960.t0 VDD.t813 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X749 a_30161_12094.t0 a_29360_11893.t2 VSS.t80 VSS.t81 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X750 VSS.t2225 a_46225_994.t2 a_46530_598.t0 VSS.t2224 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X751 a_47661_17734.t1 a_48172_17760.t2 a_48920_17493.t0 VSS.t3234 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X752 a_49517_894.t1 a_48920_693.t2 VDD.t726 VDD.t4 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X753 a_18043_20550.t2 VSS.t118 VSS.t150 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X754 VSS.t29 a_17121_12094.t2 a_17338_12114.t0 VSS.t28 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X755 6MSB_0.OUTN.t97 a_30378_914.t2 a_31083_950.t6 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X756 VSS.t2919 a_16548_20433.t2 a_16226_20293.t1 VSS.t2918 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X757 6MSB_0.OUTN.t11 a_36898_6514.t2 a_37603_6550.t6 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X758 a_24729_690.t5 a_24639_594# a_24563_950.t7 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X759 a_15470_20473.t0 CLK.t60 VSS.t2612 VSS.t3628 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X760 VDD.t229 a_29360_9093.t2 a_29957_9294.t1 VDD.t153 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X761 VSS.t1513 a_n2646_2484.t8 a_13625_3794.t0 VSS.t1512 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X762 a_8541_20534.t2 a_8515_20439.t3 VSS.t3108 VSS.t3107 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X763 a_40010_20198.t0 a_39705_20594.t2 VSS.t328 VSS.t3190 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X764 a_44123_14950.t3 a_44199_14594# a_44289_14690.t4 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X765 VDD.t163 a_7410_8998.t2 a_7799_9314.t2 VDD.t162 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X766 VDD.t605 a_n2648_1016.t2 a_n2253_1368.t0 VDD.t597 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X767 a_31083_12150.t9 a_31159_11794# a_31249_11890.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X768 a_42819_11816.t0 VDD.t1465 VSS.t1150 VSS.t3844 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X769 VSS.t1387 VDD.t1497 a_27909_9016.t0 VSS.t3864 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X770 a_46818_9017.t0 a_46530_8998.t2 VSS.t1466 VSS.t1467 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X771 a_50809_690.t3 a_50719_594# VSS.t3997 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X772 6MSB_0.OUTP.t130 a_29957_17694.t2 a_31083_17750.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X773 VSS.t1634 a_26665_6594.t2 a_26970_6198.t0 VSS.t1633 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X774 a_48920_3493.t0 a_48070_3673.t2 a_47661_3734.t3 VDD.t293 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X775 a_10219_17416.t0 VDD.t1361 VSS.t3245 VSS.t3773 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X776 a_21581_17734.t1 a_21555_17639.t3 VDD.t1008 VDD.t737 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X777 a_2430_12073.t0 CLK.t39 VSS.t3387 VSS.t3657 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X778 a_18043_3750.t8 a_18119_3394# a_18209_3490.t5 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X779 VSS.t400 VSS.t399 a_31083_17750.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X780 VDD.t604 a_n2946_1036.t2 a_n2648_1016.t1 VDD.t597 sg13_lv_pmos ad=0.4256p pd=3u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X781 a_42819_3416.t0 VDD.t1609 VSS.t1959 VSS.t3939 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X782 a_24729_3490.t2 a_24639_3394# VSS.t4037 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X783 a_48920_11893.t1 a_48070_12073.t2 a_48826_11893.t0 VSS.t1176 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X784 VSS.t1000 VSS.t999 a_5003_950.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u w=0.5u
+ l=0.13u
X785 VDD.t495 a_10028_3633.t2 a_9989_3731.t0 VDD.t301 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X786 VSS.t1449 a_41550_9273.t3 a_41652_9360.t0 VSS.t1448 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X787 a_47661_9334.t3 a_48172_9360.t2 a_48920_9093.t1 VSS.t1476 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X788 a_37603_950.t3 a_37679_594# a_37769_690.t6 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X789 a_50626_25035.t1 a_50409_25015.t2 VDD.t870 VDD.t813 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X790 a_16320_17493.t1 a_15470_17673.t2 a_16226_17493.t1 VSS.t3349 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X791 VDD.t175 a_n2770_240.t8 a_7199_9394.t0 VDD.t162 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X792 a_41115_9239.t1 a_41550_9273.t3 a_41498_9407.t0 VDD.t147 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X793 a_35880_6293.t0 a_35030_6473.t2 a_34621_6534.t2 VDD.t135 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X794 a_27359_914.t0 a_26970_598.t2 VDD.t673 VDD.t456 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X795 a_15418_1007.t0 a_15061_934.t4 VDD.t647 VDD.t444 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X796 a_31083_950.t4 a_29957_894.t2 6MSB_0.OUTP.t108 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X797 VDD.t450 VDD.t1569 a_1995_3639.t2 VDD.t303 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X798 a_37603_6550.t5 a_36477_6494.t2 6MSB_0.OUTP.t0 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X799 a_1178_6217.t2 a_n2646_2484.t18 a_1279_6514.t2 VSS.t1533 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X800 a_48254_26907.t0 a_49051_26480.t3 a_48514_26437.t1 VDD.t13 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X801 a_28510_873.t0 CLK.t3 VSS.t2154 VSS.t3688 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X802 a_26665_14994.t0 a_2033_24727.t7 VSS.t3516 VSS.t3515 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X803 6MSB_0.OUTN.t84 a_49938_12114.t2 a_50643_12150.t7 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X804 a_48018_15007.t0 a_47661_14934.t4 VDD.t731 VDD.t3 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X805 a_30378_3714.t0 a_30161_3694.t2 VSS.t1916 VSS.t1915 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X806 VSS.t2909 a_5079_17394# a_5169_17490.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X807 VDD.t780 VDD.t1271 a_47375_14616.t1 VDD.t3 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X808 VDD.t355 a_16320_6293.t2 a_16917_6494.t1 VDD.t127 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X809 a_24729_20290.t5 a_24639_20194# a_24563_20550.t7 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X810 6MSB_0.OUTP.t74 a_49517_14894.t2 a_50643_14950.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X811 a_46818_617.t1 a_46530_598.t2 VSS.t2227 VSS.t2228 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X812 a_21389_3416.t0 a_20839_3714.t3 a_21295_3416.t0 VSS.t1872 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X813 a_15061_20534.t2 a_15035_20439.t3 VSS.t3725 VSS.t4153 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X814 VSS.t343 VSS.t341 a_5003_17750.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X815 a_37603_9350.t9 a_37679_8994# a_37769_9090.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X816 a_8255_6216.t1 a_7799_6514.t3 VDD.t333 VDD.t141 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X817 a_23029_931.t0 a_22092_960.t2 a_22840_693.t0 VDD.t458 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X818 a_36299_616.t0 VDD.t1675 VSS.t2184 VSS.t3979 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X819 VDD.t631 VDD.t1627 a_8255_616.t1 VDD.t460 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X820 a_5003_3750.t1 a_3877_3694.t2 6MSB_0.OUTP.t17 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X821 a_18043_12150.t8 a_18119_11794# a_18209_11890.t5 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X822 VSS.t4301 a_9800_20293.t2 a_10397_20494.t0 VSS.t4299 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X823 a_33879_17714.t2 a_n2648_3264.t12 VDD.t1039 VDD.t893 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X824 VSS.t819 VSS.t818 a_18043_6550.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X825 a_1279_9314.t1 a_n2042_972.t17 a_1178_9017.t1 VSS.t1274 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X826 VSS.t1757 a_890_3398.t2 a_1178_3417.t0 VSS.t1758 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X827 a_18209_17490.t4 a_18119_17394# a_18043_17750.t8 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X828 a_34595_14839.t2 a_35030_14873.t3 a_34335_14616.t1 VSS.t4202 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X829 a_2021_12134.t2 a_1995_12039.t3 VSS.t3825 VSS.t4181 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X830 a_33490_11798.t0 a_33185_12194.t2 VSS.t87 VSS.t86 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X831 a_26665_3794.t0 a_2033_24727.t3 VSS.t2524 VSS.t2523 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X832 VSS.t2641 a_18119_594# a_18209_690.t2 VSS.t2644 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X833 a_13625_17794.t0 a_1253_24711.t8 VSS.t3096 VSS.t3095 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X834 a_49517_17694.t1 a_48920_17493.t2 VDD.t906 VDD.t905 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X835 VSS.t888 VSS.t886 VSS.t887 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X836 VSS.t2375 a_50719_17394# a_50809_17490.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X837 a_3877_894.t1 a_3280_693.t2 VDD.t619 VDD.t462 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X838 VDD.t336 a_8950_6473.t3 a_9052_6560.t1 VDD.t141 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X839 a_31249_690.t6 a_31159_594# a_31083_950.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X840 a_47661_934.t0 a_47635_839.t3 VSS.t2232 VSS.t2231 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X841 VSS.t103 X7.t2 a_1201_24685.t0 VSS.t102 sg13_lv_nmos ad=0.187p pd=1.78u as=0.1045p ps=0.93u
+ w=0.55u l=0.13u
X842 VSS.t317 a_37679_20194# a_37769_20290.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X843 a_31249_17490.t2 a_31159_17394# VSS.t2790 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X844 a_18209_11890.t5 a_18119_11794# a_18043_12150.t7 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X845 VSS.t3042 a_44199_11794# a_44289_11890.t0 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X846 a_50643_6550.t3 a_50719_6194# a_50809_6290.t6 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X847 a_14319_6514.t0 a_n2646_2484.t16 VDD.t315 VDD.t127 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X848 a_33879_914.t1 VDD.t1669 a_33778_617.t1 VSS.t3974 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X849 VDD.t871 a_50409_25015.t2 a_50626_25035.t1 VDD.t813 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X850 a_24729_11890.t1 a_24639_11794# VSS.t3553 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X851 VSS.t613 VSS.t612 a_44123_12150.t1 VSS.t517 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X852 a_31083_20550.t9 a_31159_20194# a_31249_20290.t6 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X853 VSS.t3205 a_33490_17398.t2 a_33778_17417.t0 VSS.t3204 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X854 a_15035_3639.t0 a_15470_3673.t3 a_14775_3416.t3 VSS.t1853 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X855 a_n2857_1728.t0 X9.t1 a_n2951_1728.t1 VDD.t597 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X856 a_51517_23976.t2 VSS.t186 VSS.t202 VSS.t187 sg13_hv_nmos ad=0.114p pd=0.98u as=0.204p ps=1.88u
+ w=0.6u l=0.45u
X857 a_37769_14690.t6 a_37679_14594# a_37603_14950.t9 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X858 a_43418_914.t0 a_43201_894.t2 VSS.t2220 VSS.t2219 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X859 6MSB_0.OUTN.t17 a_43418_3714.t2 a_44123_3750.t6 VSS.t1130 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X860 6MSB_0.OUTP.t5 a_49517_17694.t2 a_50643_17750.t9 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X861 a_50809_17490.t1 a_50719_17394# VSS.t2373 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X862 a_30161_17694.t0 a_29360_17493.t2 VSS.t3226 VSS.t3227 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X863 a_29957_6494.t1 a_29360_6293.t2 VDD.t382 VDD.t137 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X864 VSS.t986 VSS.t985 a_50643_3750.t3 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X865 a_27258_20217.t1 a_26970_20198.t2 VSS.t3359 VSS.t3358 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X866 VSS.t2871 a_17121_17694.t2 a_17338_17714.t0 VSS.t2870 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X867 VDD.t734 VDD.t1379 a_28075_17639.t2 VDD.t733 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X868 a_21295_11816.t2 a_22092_12160.t3 a_21555_12039.t0 VDD.t34 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X869 VSS.t1921 a_33185_3794.t2 a_33490_3398.t0 VSS.t1920 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X870 VSS.t4068 4LSB_weighted_0.VBIAS a_51517_23976.t4 VSS.t4076 sg13_hv_nmos ad=0.114p pd=0.98u
+ as=0.114p ps=0.98u w=0.6u l=0.48u
X871 VSS.t3118 a_21990_20473.t3 a_22092_20560.t0 VSS.t3117 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X872 6MSB_0.OUTN.t37 a_30378_6514.t2 a_31083_6550.t6 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X873 a_37769_6290.t2 a_37679_6194# VSS.t2778 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X874 a_44123_20550.t1 a_42997_20494.t2 6MSB_0.OUTP.t101 VSS.t2891 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X875 VSS.t1820 VDD.t1575 a_8349_3416.t0 VSS.t3916 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X876 a_42819_17416.t0 VDD.t1305 VSS.t3256 VSS.t3796 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X877 VDD.t366 a_23068_6433.t2 a_23029_6531.t0 VDD.t139 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X878 a_44123_950.t0 VSS.t1029 VSS.t1030 VSS.t514 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X879 a_5003_17750.t2 VSS.t369 VSS.t382 VSS.t381 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X880 a_48920_9093.t0 a_48070_9273.t2 a_47661_9334.t2 VDD.t2 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X881 VSS.t1607 a_20145_6594.t2 a_20450_6198.t0 VSS.t1606 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X882 VSS.t963 a_18119_3394# a_18209_3490.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X883 a_49608_24288.t1 a_48758_23938.t2 a_49514_24288.t0 VSS.t2401 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X884 a_44123_3750.t4 a_42997_3694.t2 6MSB_0.OUTP.t46 VSS.t1165 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X885 a_3161_24936.t0 a_2713_24910.t10 VDD.t997 VDD.t71 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2226p
+ ps=1.535u w=0.84u l=0.13u
X886 a_2430_17673.t0 CLK.t55 VSS.t2981 VSS.t3626 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X887 a_18043_9350.t8 a_18119_8994# a_18209_9090.t5 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X888 a_24729_9090.t2 a_24639_8994# VSS.t4176 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X889 a_42819_9016.t0 VDD.t1513 VSS.t1456 VSS.t3875 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X890 a_48920_17493.t0 a_48070_17673.t2 a_48826_17493.t0 VSS.t3231 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X891 VSS.t771 VSS.t770 a_5003_6550.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u w=0.5u
+ l=0.13u
X892 VDD.t46 a_22840_11893.t2 a_23437_12094.t1 VDD.t34 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X893 VSS.t458 a_31159_11794# a_31249_11890.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X894 VDD.t186 a_10028_9233.t2 a_9989_9331.t0 VDD.t162 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X895 a_43201_3694.t0 a_42400_3493.t2 VSS.t1967 VSS.t1968 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X896 a_31083_3750.t0 VSS.t930 VSS.t931 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X897 a_18043_20550.t5 a_18119_20194# a_18209_20290.t7 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X898 a_18209_14690.t0 a_18119_14594# VSS.t534 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X899 a_46530_14598.t0 a_46225_14994.t2 VSS.t2513 VSS.t2649 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X900 a_49109_14931.t0 a_48172_14960.t2 a_48920_14693.t0 VDD.t3 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X901 VDD.t129 VDD.t1473 a_1995_9239.t2 VDD.t122 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X902 a_31083_6550.t4 a_29957_6494.t2 6MSB_0.OUTP.t72 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X903 a_43418_6514.t0 a_43201_6494.t2 VSS.t1711 VSS.t1710 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X904 a_n2648_3264.t0 a_n2946_3612.t2 VSS.t1749 VSS.t1740 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.1331p
+ ps=1.12u w=0.74u l=0.13u
X905 a_4321_24727.t0 a_4285_24701.t2 VSS.t2533 VSS.t2531 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2812p
+ ps=2.24u w=0.74u l=0.13u
X906 a_20239_17794.t0 a_521_25453.t8 a_20145_17794.t1 VDD.t737 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X907 a_30161_6494.t0 a_29360_6293.t2 VSS.t1652 VSS.t1653 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X908 a_50809_6290.t3 a_50719_6194# VSS.t2799 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X909 6MSB_0.OUTN.t54 a_49938_17714.t2 a_50643_17750.t7 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X910 a_30378_9314.t0 a_30161_9294.t2 VSS.t1402 VSS.t1401 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X911 a_5169_690.t7 a_5079_594# a_5003_950.t8 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X912 VDD.t962 a_3508_14833.t2 a_3469_14931.t0 VDD.t817 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X913 VDD.t470 a_26970_3398.t2 a_27359_3714.t2 VDD.t295 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X914 VSS.t965 VSS.t879 a_24563_3750.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X915 a_1178_14617.t0 a_890_14598.t2 VSS.t2852 VSS.t2853 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X916 a_21389_9016.t0 a_20839_9314.t3 a_21295_9016.t0 VSS.t1357 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X917 a_1735_6216.t1 a_1279_6514.t3 VDD.t292 VDD.t143 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X918 a_21295_14616.t1 a_20839_14914.t3 VDD.t903 VDD.t736 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X919 a_11523_17750.t2 VSS.t292 VSS.t312 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X920 a_18209_20290.t7 a_18119_20194# a_18043_20550.t4 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X921 a_41550_12073.t0 CLK.t33 VSS.t1148 VSS.t3659 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X922 a_39705_6594.t0 a_4321_24727.t4 VSS.t2934 VSS.t2933 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X923 a_28390_20229.t1 a_28101_20534.t4 a_28327_20229.t0 VSS.t2953 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X924 a_50643_9350.t0 VSS.t702 VSS.t703 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X925 VSS.t4214 a_5079_6194# a_5169_6290.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X926 VSS.t810 VSS.t809 a_11523_6550.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X927 a_33778_20217.t2 a_n2044_4040.t11 a_33879_20514.t2 VSS.t3541 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X928 a_37769_11890.t0 a_37679_11794# VSS.t460 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X929 a_2021_17734.t0 a_1995_17639.t3 VSS.t2511 VSS.t2510 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X930 a_33490_17398.t0 a_33185_17794.t2 VSS.t3198 VSS.t3197 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X931 VSS.t2689 a_585_12194.t2 a_890_11798.t0 VSS.t2688 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X932 a_21581_12134.t1 a_21555_12039.t3 VDD.t40 VDD.t34 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X933 VSS.t1233 a_890_8998.t2 a_1178_9017.t0 VSS.t1232 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X934 a_15350_6229.t0 a_15572_6560.t3 a_15035_6439.t1 VSS.t1554 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X935 a_50643_6550.t8 a_50719_6194# a_50809_6290.t5 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X936 VSS.t3472 a_1963_25289.t2 a_1997_24905.t0 VSS.t3469 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X937 VSS.t477 VSS.t457 a_31083_12150.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X938 a_33778_617.t2 VDD.t1669 a_33879_914.t1 VSS.t3975 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X939 a_31249_3490.t6 a_31159_3394# a_31083_3750.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X940 a_2378_3807.t0 a_2021_3734.t4 VDD.t450 VDD.t303 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X941 a_34335_14616.t2 a_35132_14960.t3 a_34595_14839.t1 VDD.t846 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X942 VSS.t741 VSS.t739 VSS.t740 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X943 VDD.t321 a_2430_6473.t3 a_2532_6560.t1 VDD.t143 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X944 a_46919_914.t0 a_46530_598.t2 VDD.t718 VDD.t4 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X945 a_5169_690.t1 a_5079_594# VSS.t3594 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X946 VSS.t2493 a_44199_17394# a_44289_17490.t0 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X947 a_2430_14873.t1 CLK.t47 VDD.t962 VDD.t817 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X948 a_30161_14894.t1 a_29360_14693.t2 VDD.t986 VDD.t884 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X949 a_16509_6531.t0 a_15572_6560.t2 a_16320_6293.t0 VDD.t127 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X950 a_21295_20216.t1 a_22092_20560.t3 a_21555_20439.t0 VDD.t11 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X951 VSS.t328 VSS.t326 a_39705_20594.t0 VSS.t327 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X952 a_5169_6290.t4 a_5079_6194# a_5003_6550.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X953 a_18209_6290.t1 a_18119_6194# VSS.t2266 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X954 a_24729_17490.t1 a_24639_17394# VSS.t3296 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X955 VDD.t1220 a_10028_14833.t2 a_9989_14931.t0 VDD.t912 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X956 a_31083_14950.t2 VSS.t551 VSS.t559 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X957 a_14319_6514.t2 a_13930_6198.t2 VDD.t346 VDD.t127 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X958 VSS.t366 VSS.t365 a_44123_17750.t1 VSS.t243 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X959 VDD.t951 a_7410_14598.t2 a_7799_14914.t2 VDD.t912 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X960 a_15035_9239.t0 a_15470_9273.t3 a_14775_9016.t2 VSS.t1341 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X961 a_29588_14833.t1 VDD.t1419 VDD.t982 VDD.t884 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X962 a_20839_3714.t0 a_n2042_2484.t14 a_20738_3417.t0 VSS.t1786 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X963 6MSB_0.OUTN.t103 a_30378_20514.t2 a_31083_20550.t5 VSS.t2886 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X964 a_41141_12134.t0 a_41115_12039.t3 VSS.t1142 VSS.t1141 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X965 a_44289_690.t5 a_44199_594# a_44123_950.t7 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X966 a_3699_20216.t0 VDD.t1325 VSS.t3180 VSS.t3751 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X967 a_8830_6229.t1 a_8541_6534.t4 a_8767_6229.t0 VSS.t1562 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X968 a_42589_931.t0 a_41652_960.t2 a_42400_693.t0 VDD.t448 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X969 a_44289_3490.t2 a_44199_3394# VSS.t3307 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X970 a_33879_12114.t2 a_n2770_240.t12 VDD.t70 VDD.t66 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X971 VSS.t667 VSS.t666 a_50643_9350.t5 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X972 VDD.t1763 a_22840_20293.t2 a_23437_20494.t1 VDD.t11 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X973 a_2310_14629.t1 a_2021_14934.t4 a_2247_14629.t0 VSS.t2835 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X974 VSS.t3046 a_44199_11794# a_44289_11890.t2 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X975 a_18209_11890.t6 a_18119_11794# a_18043_12150.t9 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X976 a_9800_20293.t0 a_8950_20473.t2 a_9706_20293.t0 VSS.t2419 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X977 a_24729_11890.t3 a_24639_11794# VSS.t3558 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X978 a_31249_6290.t2 a_31159_6194# VSS.t2284 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X979 6MSB_0.OUTN.t83 a_17338_12114.t2 a_18043_12150.t6 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X980 VSS.t1312 VDD.t1479 a_8349_9016.t0 VSS.t3854 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X981 a_49517_12094.t1 a_48920_11893.t2 VDD.t116 VDD.t1 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X982 a_44123_6550.t0 VSS.t797 VSS.t798 VSS.t514 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X983 a_34335_17416.t3 a_33879_17714.t3 VDD.t1036 VDD.t893 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X984 VDD.t1222 a_35030_14873.t3 a_35132_14960.t1 VDD.t846 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X985 VSS.t954 a_11599_3394# a_11689_3490.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X986 VSS.t720 a_18119_8994# a_18209_9090.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X987 a_8950_6473.t1 CLK.t22 VDD.t336 VDD.t141 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X988 a_44123_3750.t7 a_44199_3394# a_44289_3490.t4 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X989 VDD.t547 a_30161_3694.t2 a_30378_3714.t1 VDD.t295 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X990 a_50809_3490.t1 a_50719_3394# VSS.t3487 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X991 a_16548_17633.t1 VDD.t1365 VDD.t764 VDD.t748 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X992 VDD.t922 a_13930_14598.t2 a_14319_14914.t0 VDD.t887 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X993 a_43201_9294.t0 a_42400_9093.t2 VSS.t1453 VSS.t1454 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X994 a_15287_629.t0 VDD.t1641 VSS.t3960 VSS.t3959 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X995 VSS.t404 a_31159_17394# a_31249_17490.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X996 a_29360_14693.t1 a_28510_14873.t2 a_28101_14934.t0 VDD.t884 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X997 VSS.t87 a_n2044_1752.t4 a_33185_12194.t0 VSS.t2813 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X998 VSS.t2138 a_23641_894.t2 a_23858_914.t0 VSS.t2137 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X999 a_31083_6550.t7 a_31159_6194# a_31249_6290.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1000 a_24729_690.t0 a_24639_594# VSS.t895 VSS.t3127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1001 6MSB_0.OUTP.t122 a_29957_20494.t2 a_31083_20550.t0 VSS.t3459 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1002 a_10219_20216.t0 VDD.t1329 VSS.t3732 VSS.t3731 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1003 a_21581_20534.t3 a_21555_20439.t3 VDD.t1073 VDD.t11 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1004 a_50027_27436.t0 VDD.t1299 VDD.t998 VDD.t14 sg13_lv_pmos ad=79.8f pd=0.8u as=1.4292p ps=9.04u
+ w=0.42u l=0.13u
X1005 VSS.t279 VSS.t277 a_31083_20550.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1006 a_1995_14839.t0 a_2430_14873.t3 a_2378_15007.t0 VDD.t817 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X1007 a_1829_14616.t0 a_1279_14914.t3 a_1735_14616.t0 VSS.t2812 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1008 a_35030_873.t1 CLK.t2 VDD.t693 VDD.t454 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X1009 a_11689_3490.t7 a_11599_3394# a_11523_3750.t8 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1010 a_11689_14690.t3 a_11599_14594# VSS.t3030 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1011 a_8830_629.t1 a_8541_934.t4 a_8767_629.t0 VSS.t2065 sg13_lv_nmos ad=0.1596p pd=1.6u as=38.85f
+ ps=0.605u w=0.42u l=0.13u
X1012 VDD.t472 a_20450_3398.t2 a_20839_3714.t2 VDD.t297 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1013 a_16320_20293.t1 a_15470_20473.t2 a_16226_20293.t0 VSS.t2608 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1014 VSS.t727 VSS.t726 a_24563_9350.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X1015 VDD.t154 a_26970_8998.t2 a_27359_9314.t2 VDD.t153 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1016 a_50409_25015.t1 a_49608_24814.t2 VDD.t1792 VDD.t813 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1017 a_11523_12150.t1 a_10397_12094.t2 6MSB_0.OUTP.t83 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1018 VDD.t57 VDD.t1449 a_28075_12039.t2 VDD.t50 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X1019 a_23437_12094.t0 a_22840_11893.t2 VSS.t51 VSS.t50 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1020 a_33778_3417.t1 a_n2042_2484.t12 a_33879_3714.t0 VSS.t1783 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1021 a_29588_3633.t0 a_29360_3493.t2 a_29779_3416.t0 VSS.t1910 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1022 6MSB_0.OUTP.t86 a_16917_12094.t2 a_18043_12150.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1023 VSS.t4109 a_37679_594# a_37769_690.t2 VSS.t4108 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1024 a_41550_17673.t0 CLK.t49 VSS.t3263 VSS.t3636 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1025 a_50809_690.t2 a_50719_594# VSS.t3995 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1026 a_50817_26469.t0 a_50600_26513.t2 VSS.t2580 VSS.t1 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1027 a_3280_11893.t0 a_2430_12073.t2 a_3186_11893.t1 VSS.t3383 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1028 a_8515_6439.t0 a_8950_6473.t3 a_8898_6607.t0 VDD.t141 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X1029 a_37769_17490.t0 a_37679_17394# VSS.t406 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1030 VSS.t581 a_50719_14594# a_50809_14690.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1031 a_5003_12150.t2 VSS.t440 VSS.t469 VSS.t468 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1032 a_16548_833.t0 a_16320_693.t2 a_16739_616.t0 VSS.t2101 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1033 VDD.t609 a_585_994.t2 a_890_598.t1 VDD.t462 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X1034 VDD.t298 a_n2646_2484.t7 a_20239_3794.t0 VDD.t297 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1035 a_44289_6290.t6 a_44199_6194# a_44123_6550.t9 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1036 VSS.t3140 a_5079_20194# a_5169_20290.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1037 a_20738_6217.t1 a_n2646_2484.t15 a_20839_6514.t0 VSS.t1527 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1038 6MSB_0.OUTP.t21 a_50817_26469.t2 a_51440_26253.t4 VSS.t2598 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1039 VSS.t3337 a_585_17794.t2 a_890_17398.t0 VSS.t3336 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X1040 VDD.t542 a_29360_3493.t2 a_29588_3633.t1 VDD.t295 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1041 a_5169_17490.t5 a_5079_17394# a_5003_17750.t7 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1042 a_679_994.t0 a_653_546.t2 a_585_994.t1 VDD.t462 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X1043 a_46919_3714.t0 a_n2042_2484.t10 a_46818_3417.t0 VSS.t1778 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1044 a_24729_3490.t1 a_24639_3394# VSS.t4035 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1045 VSS.t197 VSS.t195 a_5003_20550.t1 VSS.t196 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1046 a_2378_9407.t0 a_2021_9334.t4 VDD.t129 VDD.t122 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1047 a_23068_833.t1 VDD.t1655 VDD.t663 VDD.t458 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1048 a_31249_9090.t6 a_31159_8994# a_31083_9350.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1049 VDD.t603 X9.t0 a_n2946_1036.t1 VDD.t597 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X1050 a_33879_20514.t1 a_n2044_4040.t11 VDD.t930 VDD.t793 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1051 a_2378_15007.t0 a_2021_14934.t4 VDD.t955 VDD.t817 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1052 a_36898_14914.t0 a_36681_14894.t2 VSS.t2620 VSS.t2619 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1053 a_30378_3714.t1 a_30161_3694.t2 VDD.t546 VDD.t295 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1054 a_5169_14690.t6 a_5079_14594# a_5003_14950.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1055 a_21555_6439.t1 a_21990_6473.t3 a_21295_6216.t3 VSS.t1620 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1056 a_47661_3734.t0 a_47635_3639.t3 VSS.t1986 VSS.t1985 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1057 a_48254_26907.t3 X2.t0 VDD.t1194 VDD.t13 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p ps=1.52u
+ w=0.42u l=0.13u
X1058 a_18209_20290.t4 a_18119_20194# a_18043_20550.t6 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1059 a_11689_6290.t1 a_11599_6194# VSS.t3098 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1060 a_33879_6514.t0 a_n2646_2484.t13 a_33778_6217.t0 VSS.t1522 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1061 VDD.t862 a_42628_14833.t2 a_42589_14931.t0 VDD.t810 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1062 a_20239_12194.t0 a_521_25453.t6 a_20145_12194.t1 VDD.t34 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1063 VDD.t1051 a_48070_17673.t3 a_48172_17760.t1 VDD.t905 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X1064 a_40298_14617.t0 a_40010_14598.t2 VSS.t4190 VSS.t4189 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1065 VDD.t725 a_48920_693.t2 a_49517_894.t1 VDD.t4 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1066 a_13625_20594.t0 a_1253_24711.t9 VSS.t3090 VSS.t3089 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X1067 VSS.t3567 a_18119_11794# a_18209_11890.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1068 a_34621_6534.t0 a_34595_6439.t3 VSS.t1668 VSS.t1667 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1069 a_4298_17714.t1 a_4081_17694.t2 VDD.t758 VDD.t752 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1070 VSS.t3800 VDD.t1399 a_8349_14616.t0 VSS.t3799 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1071 a_20839_9314.t0 a_n2042_972.t14 a_20738_9017.t0 VSS.t1268 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1072 a_2430_873.t0 CLK.t7 VSS.t2042 VSS.t3684 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1073 a_n2646_1728.t1 a_n2951_1728.t2 VDD.t598 VDD.t597 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1074 a_24563_3750.t2 VSS.t876 VSS.t939 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1075 a_48514_26437.t1 a_48949_26480.t3 a_48897_26516.t0 VDD.t13 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X1076 a_48758_23938.t0 CLK.t63 VSS.t2977 VSS.t3458 sg13_lv_nmos ad=0.2516p pd=2.16u as=2.59765p
+ ps=9.435u w=0.74u l=0.13u
X1077 VDD.t1149 a_26970_17398.t2 a_27359_17714.t2 VDD.t733 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X1078 VSS.t1257 a_n2042_972.t8 a_7105_6594.t0 VSS.t1256 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1079 a_31249_20290.t2 a_31159_20194# VSS.t4223 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1080 a_11523_12150.t2 VSS.t618 VSS.t619 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X1081 a_41141_17734.t0 a_41115_17639.t3 VSS.t3741 VSS.t4139 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1082 a_11523_14950.t7 a_10397_14894.t2 6MSB_0.OUTP.t66 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1083 a_44289_9090.t2 a_44199_8994# VSS.t4283 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1084 a_50396_26489.t0 a_49799_26830.t2 VSS.t2576 VSS.t2575 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1085 VSS.t679 VSS.t678 a_31083_9350.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1086 a_50643_3750.t0 VSS.t944 VSS.t945 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1087 a_11523_6550.t2 VSS.t806 VSS.t812 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1088 VDD.t657 a_20145_994.t2 a_20450_598.t1 VDD.t458 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1089 a_14319_914.t2 VDD.t1637 VDD.t644 VDD.t444 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X1090 VSS.t2497 a_44199_17394# a_44289_17490.t2 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1091 a_16548_6433.t1 VDD.t1537 VDD.t351 VDD.t127 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1092 VSS.t2017 a_n2946_1036.t2 a_n2648_1016.t0 VSS.t2016 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1093 6MSB_0.OUTN.t86 a_50396_26489.t2 a_51440_26253.t0 VSS.t2592 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1094 VSS.t2784 a_33490_20198.t2 a_33778_20217.t0 VSS.t2783 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1095 a_20239_994.t0 a_521_25453.t2 a_20145_994.t1 VDD.t458 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1096 a_24729_17490.t3 a_24639_17394# VSS.t3301 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1097 a_31083_14950.t8 a_31159_14594# a_31249_14690.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1098 VSS.t3615 a_37679_11794# a_37769_11890.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1099 VDD.t674 a_26970_598.t2 a_27359_914.t0 VDD.t456 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1100 6MSB_0.OUTN.t21 a_17338_17714.t2 a_18043_17750.t9 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1101 a_24563_14950.t1 a_23437_14894.t2 6MSB_0.OUTP.t129 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1102 a_41550_14873.t1 CLK.t41 VDD.t862 VDD.t810 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X1103 VDD.t663 a_21990_873.t3 a_22092_960.t1 VDD.t458 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1104 VDD.t523 VDD.t1587 a_21295_3416.t1 VDD.t297 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1105 VDD.t418 a_43201_6494.t2 a_43418_6514.t1 VDD.t125 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1106 VDD.t940 a_n2044_1752.t10 a_46919_14914.t2 VDD.t3 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1107 a_18209_11890.t2 a_18119_11794# VSS.t3566 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1108 VDD.t78 X7.t0 a_4285_24701.t1 VDD.t77 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X1109 a_36477_14894.t0 a_35880_14693.t2 VSS.t2616 VSS.t2615 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1110 a_44123_9350.t1 a_42997_9294.t2 6MSB_0.OUTP.t63 VSS.t1167 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1111 VSS.t653 a_11599_8994# a_11689_9090.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1112 VSS.t163 VSS.t108 a_51442_27857.t2 VSS.t109 sg13_hv_nmos ad=0.102p pd=1.28u as=57f ps=0.68u
+ w=0.3u l=0.45u
X1113 a_30161_20494.t0 a_29360_20293.t2 VSS.t4093 VSS.t4094 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1114 VDD.t464 a_46530_3398.t2 a_46919_3714.t2 VDD.t293 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1115 VSS.t4047 a_44199_6194# a_44289_6290.t2 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1116 VSS.t3713 a_49836_24954.t2 a_49514_24814.t1 VSS.t3712 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1117 VDD.t988 VDD.t1291 a_28075_20439.t2 VDD.t9 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X1118 a_44123_9350.t7 a_44199_8994# a_44289_9090.t4 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1119 a_48829_26894.t0 a_49051_26480.t3 a_48514_26437.t0 VSS.t3186 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1120 VSS.t2928 a_17121_20494.t2 a_17338_20514.t0 VSS.t2927 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1121 VDD.t778 a_46530_14598.t2 a_46919_14914.t0 VDD.t3 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1122 VDD.t234 a_30161_9294.t2 a_30378_9314.t1 VDD.t153 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1123 a_50809_9090.t1 a_50719_8994# VSS.t2893 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1124 a_46530_8998.t0 a_46225_9394.t2 VSS.t1462 VSS.t1461 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X1125 VDD.t482 a_3280_3493.t2 a_3877_3694.t1 VDD.t303 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1126 a_48348_27219.t0 X1.t0 a_48254_27219.t0 VSS.t3692 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1127 a_50643_12150.t9 a_49938_12114.t2 6MSB_0.OUTN.t84 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1128 VSS.t3198 a_n2044_4040.t4 a_33185_17794.t0 VSS.t3346 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1129 VDD.t309 a_33490_6198.t2 a_33879_6514.t2 VDD.t135 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1130 VSS.t2133 a_22840_693.t2 a_23437_894.t0 VSS.t2132 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1131 a_5003_20550.t2 VSS.t111 VSS.t235 VSS.t234 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1132 a_42819_20216.t0 VDD.t1275 VSS.t2486 VSS.t3705 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1133 a_31249_14690.t5 a_31159_14594# a_31083_14950.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1134 VSS.t2437 a_4081_12094.t2 a_4298_12114.t0 VSS.t2436 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1135 a_890_17398.t1 a_585_17794.t2 VDD.t1083 VDD.t752 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1136 a_17121_12094.t0 a_16320_11893.t2 VSS.t24 VSS.t25 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X1137 VDD.t294 a_n2646_2484.t3 a_46319_3794.t0 VDD.t293 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1138 a_2430_20473.t0 CLK.t62 VSS.t3635 VSS.t3634 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1139 VDD.t318 a_n2646_2484.t17 a_7799_6514.t1 VDD.t141 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1140 a_11689_9090.t7 a_11599_8994# a_11523_9350.t8 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1141 VSS.t2064 VDD.t1627 a_8349_616.t0 VSS.t3952 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1142 VSS.t921 VSS.t874 a_5003_3750.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X1143 VDD.t157 a_20450_8998.t2 a_20839_9314.t2 VDD.t156 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1144 VDD.t759 a_4081_17694.t2 a_4298_17714.t1 VDD.t752 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1145 a_8830_3429.t0 a_9052_3760.t3 a_8515_3639.t0 VSS.t1818 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X1146 a_1253_24711.t0 a_1201_24685.t2 VSS.t3040 VSS.t3038 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X1147 a_11523_17750.t1 a_10397_17694.t2 6MSB_0.OUTP.t53 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1148 VDD.t1148 a_n2648_3264.t12 a_33879_17714.t2 VDD.t893 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X1149 VDD.t136 a_n2042_972.t4 a_33279_6594.t0 VDD.t135 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1150 a_23437_17694.t0 a_22840_17493.t2 VSS.t3405 VSS.t3404 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1151 a_46919_12114.t1 a_n2770_240.t10 a_46818_11817.t1 VSS.t3367 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1152 a_29588_9233.t0 a_29360_9093.t2 a_29779_9016.t0 VSS.t1396 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1153 6MSB_0.OUTP.t126 a_16917_17694.t2 a_18043_17750.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1154 a_34910_14629.t0 a_35132_14960.t3 a_34595_14839.t2 VSS.t4197 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1155 a_33778_9017.t1 a_n2042_972.t12 a_33879_9314.t0 VSS.t1265 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1156 a_15061_12134.t2 a_15572_12160.t2 a_16320_11893.t1 VSS.t3399 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X1157 VDD.t621 a_3280_693.t2 a_3877_894.t1 VDD.t462 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1158 a_2021_3734.t1 a_1995_3639.t3 VDD.t452 VDD.t303 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1159 a_51517_23976.t4 4LSB_weighted_0.VBIAS VSS.t4074 VSS.t4075 sg13_hv_nmos ad=0.114p pd=0.98u
+ as=0.114p ps=0.98u w=0.6u l=0.48u
X1160 a_20239_20594.t0 a_521_25453.t9 a_20145_20594.t1 VDD.t11 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1161 a_3280_17493.t1 a_2430_17673.t2 a_3186_17493.t1 VSS.t2473 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1162 a_14218_14617.t2 a_n2044_1752.t15 a_14319_14914.t1 VSS.t2830 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1163 a_34335_11816.t1 a_33879_12114.t3 VDD.t80 VDD.t66 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1164 VSS.t1099 VDD.t1455 a_34429_11816.t0 VSS.t3837 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1165 VDD.t205 a_n2770_240.t6 a_20239_9394.t0 VDD.t156 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1166 VSS.t2269 a_18119_6194# a_18209_6290.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1167 a_43418_6514.t1 a_43201_6494.t2 VDD.t417 VDD.t125 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1168 a_1279_3714.t2 a_n2042_2484.t17 VDD.t447 VDD.t303 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1169 a_24729_9090.t1 a_24639_8994# VSS.t4174 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1170 VDD.t230 a_29360_9093.t2 a_29588_9233.t1 VDD.t153 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1171 a_40399_3714.t0 a_n2042_2484.t11 a_40298_3417.t0 VSS.t1780 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1172 VSS.t4113 X6.t3 a_1963_25289.t0 VSS.t4112 sg13_lv_nmos ad=0.187p pd=1.78u as=0.1045p ps=0.93u
+ w=0.55u l=0.13u
X1173 a_16548_12033.t1 VDD.t1263 VDD.t1126 VDD.t25 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X1174 a_46919_9314.t0 a_n2042_972.t10 a_46818_9017.t0 VSS.t1260 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1175 a_34335_3416.t1 a_33879_3714.t3 VDD.t552 VDD.t290 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1176 VDD.t1161 a_49836_24166.t2 a_49797_24050.t0 VDD.t760 sg13_lv_pmos ad=1.4292p pd=9.04u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1177 a_11523_20550.t2 VSS.t248 VSS.t250 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X1178 a_48920_693.t0 a_48070_873.t2 a_47661_934.t3 VDD.t4 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X1179 a_31083_950.t1 a_29957_894.t2 6MSB_0.OUTP.t109 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1180 a_30378_9314.t1 a_30161_9294.t2 VDD.t233 VDD.t153 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1181 a_41115_14839.t0 a_41550_14873.t3 a_41498_15007.t0 VDD.t810 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X1182 a_40949_14616.t0 a_40399_14914.t3 a_40855_14616.t3 VSS.t4262 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1183 a_47661_9334.t0 a_47635_9239.t3 VSS.t1471 VSS.t1470 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1184 VSS.t2222 a_43201_894.t2 a_43418_914.t0 VSS.t2221 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1185 VSS.t3283 a_37679_3394# a_37769_3490.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1186 a_2021_20534.t1 a_1995_20439.t3 VSS.t3530 VSS.t3529 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1187 a_33490_20198.t0 a_33185_20594.t2 VSS.t315 VSS.t4077 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X1188 VSS.t4143 a_24639_6194# a_24729_6290.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1189 VSS.t2964 a_18119_17394# a_18209_17490.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1190 a_42400_11893.t1 a_41550_12073.t2 a_42306_11893.t0 VSS.t1144 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1191 a_24563_9350.t2 VSS.t721 VSS.t729 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1192 VSS.t3164 a_44199_20194# a_44289_20290.t0 VSS.t3155 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1193 VDD.t555 a_35030_3673.t3 a_35132_3760.t1 VDD.t290 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1194 a_49799_27296.t0 a_48949_27476.t2 a_48540_27537.t3 VDD.t14 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X1195 VSS.t178 VSS.t177 a_51440_25469.t1 VSS.t175 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1196 a_44289_17490.t7 a_44199_17394# a_44123_17750.t4 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1197 a_40010_14598.t1 a_39705_14994.t2 VDD.t811 VDD.t810 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1198 a_8515_839.t1 a_8950_873.t3 a_8898_1007.t0 VDD.t460 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X1199 VSS.t244 VSS.t242 a_44123_20550.t1 VSS.t243 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1200 a_24729_20290.t1 a_24639_20194# VSS.t3147 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1201 a_20145_14994.t0 a_521_25453.t7 VSS.t2307 VSS.t2306 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X1202 a_21295_616.t0 a_20839_914.t3 VDD.t660 VDD.t458 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1203 a_43418_914.t1 a_43201_894.t2 VDD.t714 VDD.t448 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1204 a_17121_3694.t1 a_16320_3493.t2 VDD.t514 VDD.t299 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1205 VSS.t3491 a_50719_3394# a_50809_3490.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1206 a_679_14994.t0 a_653_546.t7 a_585_14994.t1 VDD.t817 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1207 a_41498_15007.t0 a_41141_14934.t4 VDD.t1430 VDD.t810 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1208 VDD.t366 a_21990_6473.t3 a_22092_6560.t1 VDD.t139 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1209 a_50643_6550.t7 a_50719_6194# a_50809_6290.t4 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1210 VSS.t4053 a_37679_17394# a_37769_17490.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1211 VDD.t1428 VDD.t1427 a_40855_14616.t2 VDD.t810 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1212 a_44289_14690.t6 a_44199_14594# a_44123_14950.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1213 a_5169_11890.t6 a_5079_11794# a_5003_12150.t7 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1214 a_18209_17490.t2 a_18119_17394# VSS.t2962 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1215 VDD.t210 VDD.t1491 a_21295_9016.t1 VDD.t156 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1216 VSS.t1060 VSS.t1059 a_24563_950.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1217 a_42628_833.t1 VDD.t1685 VDD.t708 VDD.t448 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1218 VDD.t145 a_46530_8998.t2 a_46919_9314.t2 VDD.t2 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1219 VSS.t2940 a_48949_26480.t3 a_49051_26480.t0 VSS.t2939 sg13_lv_nmos ad=2.02352p pd=12.38u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1220 a_51516_24785.t5 4LSB_weighted_0.VBIAS a_51440_25469.t5 VSS.t4064 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X1221 a_43418_17714.t1 a_43201_17694.t2 VDD.t1777 VDD.t812 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X1222 VSS.t2453 VDD.t1271 a_47469_14616.t0 VSS.t3698 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1223 VDD.t114 a_48070_12073.t3 a_48172_12160.t1 VDD.t1 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1224 VDD.t170 a_3280_9093.t2 a_3877_9294.t1 VDD.t122 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1225 VSS.t3065 a_11599_594# a_11689_690.t0 VSS.t3064 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1226 a_50643_17750.t8 a_49938_17714.t2 6MSB_0.OUTN.t54 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1227 VSS.t1026 VSS.t1025 a_44123_950.t1 VSS.t517 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1228 a_34335_20216.t1 a_33879_20514.t3 VDD.t931 VDD.t793 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1229 a_4298_12114.t1 a_4081_12094.t2 VDD.t771 VDD.t765 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1230 a_49721_12094.t0 a_48920_11893.t2 VSS.t1190 VSS.t1191 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1231 a_14775_6216.t2 a_15572_6560.t3 a_15035_6439.t0 VDD.t127 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1232 VSS.t2391 a_4081_17694.t2 a_4298_17714.t0 VSS.t2390 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1233 VDD.t54 a_26970_11798.t2 a_27359_12114.t0 VDD.t50 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1234 VDD.t265 a_n2770_240.t2 a_46319_9394.t0 VDD.t2 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1235 a_17121_17694.t0 a_16320_17493.t2 VSS.t2866 VSS.t2867 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1236 VSS.t2705 a_23641_14894.t2 a_23858_14914.t0 VSS.t2704 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1237 VSS.t628 VSS.t606 VSS.t628 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1238 VDD.t320 a_n2646_2484.t18 a_1279_6514.t1 VDD.t143 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1239 a_40298_6217.t1 a_n2646_2484.t12 a_40399_6514.t0 VSS.t1521 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1240 VDD.t569 VDD.t1605 a_41115_3639.t2 VDD.t282 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X1241 VSS.t530 VSS.t529 a_11523_14950.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1242 VSS.t663 VSS.t662 a_5003_9350.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X1243 a_16548_20433.t1 VDD.t1333 VDD.t845 VDD.t7 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1244 a_2310_3429.t0 a_2532_3760.t3 a_1995_3639.t0 VSS.t1759 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X1245 VSS.t929 VSS.t928 a_31083_3750.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1246 VSS.t284 a_31159_20194# a_31249_20290.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1247 a_8830_9029.t0 a_9052_9360.t3 a_8515_9239.t1 VSS.t1303 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X1248 a_24729_690.t3 a_24639_594# VSS.t3135 VSS.t3136 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1249 a_36108_833.t0 a_35880_693.t2 a_36299_616.t0 VSS.t2185 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1250 VSS.t2393 a_18119_3394# a_18209_3490.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1251 a_51440_25469.t5 4LSB_weighted_0.VBIAS a_51516_24785.t0 VSS.t4063 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X1252 a_51453_23453.t3 a_50626_23927.t2 6MSB_0.OUTP.t38 VSS.t2297 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1253 a_46919_17714.t0 a_n2648_3264.t10 a_46818_17417.t0 VSS.t3424 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1254 a_18043_9350.t6 a_17338_9314.t2 6MSB_0.OUTN.t90 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1255 a_15061_17734.t0 a_15572_17760.t2 a_16320_17493.t1 VSS.t3350 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X1256 a_2021_9334.t1 a_1995_9239.t3 VDD.t132 VDD.t122 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1257 VDD.t719 a_46530_598.t2 a_46919_914.t0 VDD.t4 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1258 a_24563_12150.t0 VSS.t598 VSS.t599 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1259 VDD.t287 a_n2646_2484.t2 a_n2253_2880.t0 VDD.t286 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1260 VSS.t3203 VDD.t1375 a_34429_17416.t0 VSS.t3774 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1261 a_31249_14690.t6 a_31159_14594# a_31083_14950.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1262 VDD.t708 a_41550_873.t3 a_41652_960.t1 VDD.t448 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1263 a_44123_3750.t1 a_42997_3694.t2 6MSB_0.OUTP.t47 VSS.t1167 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1264 a_47375_6216.t1 a_46919_6514.t3 VDD.t423 VDD.t0 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1265 a_3469_3731.t0 a_2532_3760.t2 a_3280_3493.t0 VDD.t303 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1266 a_11523_14950.t3 a_11599_14594# a_11689_14690.t4 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1267 VSS.t628 a_18119_11794# a_18209_11890.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1268 a_1279_9314.t2 a_n2042_972.t17 VDD.t124 VDD.t122 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1269 a_47635_839.t0 a_48070_873.t3 a_47375_616.t3 VSS.t2236 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X1270 a_28510_3673.t0 CLK.t11 VSS.t1909 VSS.t3680 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1271 a_5169_3490.t1 a_5079_3394# VSS.t4234 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1272 a_40399_9314.t1 a_n2042_972.t11 a_40298_9017.t0 VSS.t1262 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1273 a_1279_3714.t0 a_890_3398.t2 VDD.t446 VDD.t303 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X1274 VSS.t1159 a_43201_12094.t2 a_43418_12114.t0 VSS.t1158 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1275 VSS.t1406 a_n2770_240.t4 a_33185_9394.t0 VSS.t3361 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1276 a_46530_3398.t0 a_46225_3794.t2 VSS.t1507 VSS.t1973 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X1277 VSS.t1950 a_40010_3398.t2 a_40298_3417.t2 VSS.t1951 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1278 a_50809_6290.t0 a_50719_6194# VSS.t861 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1279 a_37603_12150.t5 a_36898_12114.t2 6MSB_0.OUTN.t65 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1280 a_34335_9016.t1 a_33879_9314.t3 VDD.t239 VDD.t150 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1281 a_31083_6550.t1 a_29957_6494.t2 6MSB_0.OUTP.t73 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1282 a_1995_6439.t0 a_2430_6473.t3 a_1735_6216.t3 VSS.t1536 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X1283 a_21581_934.t1 a_21555_839.t3 VDD.t661 VDD.t458 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1284 a_41550_20473.t0 CLK.t56 VSS.t2627 VSS.t3627 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1285 a_49148_12033.t0 a_48920_11893.t2 a_49339_11816.t0 VSS.t1187 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1286 a_48540_26473.t3 a_48514_26437.t3 VDD.t1050 VDD.t13 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1287 a_37769_20290.t0 a_37679_20194# VSS.t287 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1288 6MSB_0.OUTP.t36 a_16917_9294.t2 a_18043_9350.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1289 VSS.t705 VSS.t704 a_50643_9350.t3 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1290 a_15470_6473.t0 CLK.t21 VSS.t1595 VSS.t3670 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1291 VSS.t4257 a_31159_3394# a_31249_3490.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1292 a_890_11798.t1 a_585_12194.t2 VDD.t872 VDD.t765 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1293 VSS.t3588 a_37679_8994# a_37769_9090.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1294 a_31083_6550.t2 VSS.t845 VSS.t846 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1295 VSS.t2565 a_585_20594.t2 a_890_20198.t0 VSS.t2564 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X1296 a_37603_17750.t7 a_37679_17394# a_37769_17490.t4 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1297 VDD.t1778 a_43201_17694.t2 a_43418_17714.t1 VDD.t812 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X1298 a_5169_20290.t7 a_5079_20194# a_5003_20550.t4 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1299 a_13930_3398.t1 a_13625_3794.t2 VDD.t300 VDD.t299 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1300 VDD.t894 a_35880_17493.t2 a_36108_17633.t0 VDD.t893 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1301 a_34621_14934.t1 a_35132_14960.t2 a_35880_14693.t1 VSS.t4201 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X1302 VDD.t772 a_4081_12094.t2 a_4298_12114.t1 VDD.t765 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1303 VSS.t76 a_29588_12033.t2 a_29266_11893.t1 VSS.t75 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1304 a_33879_914.t2 VDD.t1669 VDD.t689 VDD.t454 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X1305 VDD.t702 a_39705_994.t2 a_40010_598.t1 VDD.t448 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1306 a_28101_3734.t1 a_28075_3639.t3 VDD.t538 VDD.t295 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1307 a_29957_14894.t1 a_29360_14693.t2 VDD.t984 VDD.t884 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1308 a_28510_12073.t0 CLK.t35 VSS.t74 VSS.t3658 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1309 VDD.t1109 a_n2770_240.t12 a_33879_12114.t2 VDD.t66 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1310 a_28075_6439.t1 a_28510_6473.t3 a_28458_6607.t0 VDD.t137 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X1311 a_51453_23453.t0 VSS.t189 VSS.t191 VSS.t190 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1312 a_42400_17493.t1 a_41550_17673.t2 a_42306_17493.t1 VSS.t3259 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1313 VSS.t4105 a_37679_594# a_37769_690.t1 VSS.t4104 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1314 a_16739_3416.t0 VDD.t1585 VSS.t1851 VSS.t3923 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1315 a_33879_17714.t0 a_33490_17398.t2 VDD.t1038 VDD.t893 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.4032p ps=2.96u w=1.12u l=0.13u
X1316 VDD.t924 VDD.t1393 a_14775_14616.t1 VDD.t887 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1317 VDD.t242 a_35030_9273.t3 a_35132_9360.t1 VDD.t150 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1318 a_50643_9350.t2 a_49938_9314.t2 6MSB_0.OUTN.t95 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1319 VSS.t805 a_5079_6194# a_5169_6290.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1320 a_15061_6534.t1 a_15035_6439.t3 VDD.t349 VDD.t127 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1321 a_18043_950.t5 a_17338_914.t2 6MSB_0.OUTN.t107 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1322 a_31249_3490.t4 a_31159_3394# a_31083_3750.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1323 a_10601_3694.t1 a_9800_3493.t2 VDD.t499 VDD.t301 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1324 a_17121_9294.t1 a_16320_9093.t2 VDD.t203 VDD.t159 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1325 VDD.t814 VDD.t1293 a_48323_24960.t2 VDD.t813 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X1326 a_4298_20514.t1 a_4081_20494.t2 VDD.t1065 VDD.t5 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1327 a_7698_11817.t2 a_n2770_240.t16 a_7799_12114.t1 VSS.t3380 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1328 VSS.t2897 a_50719_8994# a_50809_9090.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1329 VDD.t1097 a_26970_20198.t2 a_27359_20514.t0 VDD.t9 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1330 a_41141_20534.t1 a_41115_20439.t3 VSS.t2633 VSS.t2632 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1331 a_37603_12150.t4 a_36477_12094.t2 6MSB_0.OUTP.t92 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1332 VSS.t828 VSS.t827 VSS.t828 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1333 a_17121_14894.t1 a_16320_14693.t2 VDD.t890 VDD.t887 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1334 VSS.t1986 VDD.t1611 a_47469_3416.t0 VSS.t3940 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1335 VSS.t3167 a_44199_20194# a_44289_20290.t2 VSS.t3159 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1336 a_37603_14950.t0 VSS.t509 VSS.t510 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1337 VSS.t3649 a_8950_14873.t3 a_9052_14960.t0 VSS.t4014 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1338 a_50817_27517.t1 a_50600_27497.t2 VDD.t15 VDD.t14 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1339 a_16917_17694.t1 a_16320_17493.t2 VDD.t963 VDD.t748 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1340 6MSB_0.OUTN.t94 a_49938_9314.t2 a_50643_9350.t1 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1341 6MSB_0.OUTN.t106 a_17338_914.t2 a_18043_950.t4 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1342 a_24729_20290.t3 a_24639_20194# VSS.t3150 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1343 VSS.t2441 a_7105_12194.t2 a_7410_11798.t0 VSS.t2440 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1344 a_31249_11890.t0 a_31159_11794# VSS.t455 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1345 a_17338_914.t0 a_17121_894.t2 VSS.t2108 VSS.t2107 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1346 a_33490_598.t0 a_33185_994.t2 VSS.t1769 VSS.t2167 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X1347 6MSB_0.OUTN.t119 a_17338_20514.t2 a_18043_20550.t9 VSS.t2882 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1348 a_24563_17750.t3 a_24639_17394# a_24729_17490.t4 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1349 VSS.t3479 a_11599_11794# a_11689_11890.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1350 a_49721_17694.t0 a_48920_17493.t2 VSS.t2736 VSS.t2735 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1351 a_28101_12134.t0 a_28075_12039.t3 VSS.t68 VSS.t67 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X1352 VSS.t794 VSS.t793 a_44123_6550.t1 VSS.t517 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1353 a_1995_839.t1 a_2430_873.t3 a_1735_616.t3 VSS.t2040 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X1354 VSS.t1864 a_17121_3694.t2 a_17338_3714.t0 VSS.t1863 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1355 a_50396_27497.t1 a_49799_27296.t2 VDD.t1733 VDD.t14 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1356 VSS.t591 VSS.t590 a_11523_12150.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1357 VDD.t256 VDD.t1509 a_41115_9239.t2 VDD.t147 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X1358 VSS.t299 VSS.t298 VSS.t299 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1359 a_24563_14950.t9 a_24639_14594# a_24729_14690.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1360 6MSB_0.OUTN.t79 a_4298_12114.t2 a_5003_12150.t5 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1361 a_37603_3750.t3 a_37679_3394# a_37769_3490.t6 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1362 a_35030_3673.t1 CLK.t10 VDD.t555 VDD.t290 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X1363 a_44289_11890.t4 a_44199_11794# a_44123_12150.t6 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1364 a_9989_14931.t0 a_9052_14960.t2 a_9800_14693.t1 VDD.t912 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1365 a_21555_12039.t1 a_21990_12073.t3 a_21295_11816.t3 VSS.t44 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1366 a_2310_9029.t1 a_2532_9360.t3 a_1995_9239.t1 VSS.t1248 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X1367 VSS.t3019 a_11599_3394# a_11689_3490.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1368 VSS.t3506 a_18119_8994# a_18209_9090.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1369 VDD.t463 a_n2042_2484.t9 a_679_994.t0 VDD.t462 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1370 a_50643_950.t1 a_49517_894.t2 6MSB_0.OUTP.t117 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1371 VSS.t315 VSS.t313 a_33185_20594.t0 VSS.t314 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X1372 VDD.t665 a_22840_693.t2 a_23068_833.t1 VDD.t458 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1373 a_890_20198.t1 a_585_20594.t2 VDD.t6 VDD.t5 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1374 a_24563_6550.t3 a_24639_6194# a_24729_6290.t6 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1375 a_47950_629.t0 a_48172_960.t3 a_47635_839.t0 VSS.t2230 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X1376 a_3508_17633.t1 VDD.t1351 VDD.t753 VDD.t752 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1377 VDD.t953 a_890_14598.t2 a_1279_14914.t2 VDD.t817 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1378 a_24563_17750.t0 VSS.t353 VSS.t355 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1379 6MSB_0.OUTN.t66 a_30378_14914.t2 a_31083_14950.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1380 a_40855_6216.t1 a_40399_6514.t3 VDD.t408 VDD.t125 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1381 VDD.t528 a_22840_3493.t2 a_23437_3694.t1 VDD.t297 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1382 a_23068_14833.t1 VDD.t1421 VDD.t877 VDD.t736 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X1383 a_40010_3398.t1 a_39705_3794.t2 VDD.t283 VDD.t282 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1384 a_3469_9331.t0 a_2532_9360.t2 a_3280_9093.t0 VDD.t122 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1385 a_21990_3673.t0 CLK.t12 VSS.t1881 VSS.t3679 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1386 a_11523_20550.t1 a_10397_20494.t2 6MSB_0.OUTP.t61 VSS.t4130 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1387 VDD.t1066 a_4081_20494.t2 a_4298_20514.t1 VDD.t5 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1388 VSS.t299 a_18119_17394# a_18209_17490.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1389 VSS.t20 a_13625_12194.t2 a_13930_11798.t0 VSS.t19 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X1390 a_5169_9090.t1 a_5079_8994# VSS.t4083 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1391 a_28510_9273.t0 CLK.t27 VSS.t1395 VSS.t3664 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1392 a_49721_894.t1 a_48920_693.t2 VDD.t725 VDD.t4 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1393 VSS.t4045 a_44199_6194# a_44289_6290.t1 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1394 VDD.t1177 a_n2044_4040.t11 a_33879_20514.t1 VDD.t793 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X1395 a_23437_20494.t0 a_22840_20293.t2 VSS.t4230 VSS.t4229 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1396 VSS.t4291 a_43201_17694.t2 a_43418_17714.t0 VSS.t4290 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1397 a_43418_12114.t1 a_43201_12094.t2 VDD.t105 VDD.t91 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X1398 a_1279_9314.t0 a_890_8998.t2 VDD.t123 VDD.t122 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X1399 VSS.t1438 a_40010_8998.t2 a_40298_9017.t2 VSS.t1437 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1400 6MSB_0.OUTP.t24 a_16917_20494.t2 a_18043_20550.t0 VSS.t2876 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1401 a_39799_17794.t0 a_4321_24727.t8 a_39705_17794.t1 VDD.t812 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1402 a_26970_6198.t1 a_26665_6594.t2 VDD.t138 VDD.t137 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1403 a_n2857_2880.t0 X9.t2 a_n2951_2880.t1 VDD.t286 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X1404 a_3280_20293.t0 a_2430_20473.t2 a_3186_20293.t1 VSS.t4204 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1405 a_37603_17750.t5 a_36898_17714.t2 6MSB_0.OUTN.t47 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1406 6MSB_0.OUTP.t102 a_10397_9294.t2 a_11523_9350.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1407 VDD.t1672 VDD.t1669 a_33879_914.t2 VDD.t454 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X1408 VSS.t181 VSS.t179 a_51516_24785.t1 VSS.t180 sg13_hv_nmos ad=0.102p pd=1.28u as=57f ps=0.68u
+ w=0.3u l=0.45u
X1409 a_49148_17633.t0 a_48920_17493.t2 a_49339_17416.t0 VSS.t2734 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1410 VSS.t2505 a_31159_8994# a_31249_9090.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1411 a_14775_616.t2 a_15572_960.t3 a_15035_839.t0 VDD.t444 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1412 a_41498_3807.t0 a_41141_3734.t4 VDD.t569 VDD.t282 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1413 VDD.t16 a_50600_27497.t2 a_50817_27517.t1 VDD.t14 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1414 6MSB_0.OUTN.t63 a_10818_12114.t2 a_11523_12150.t5 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1415 a_13930_14598.t0 a_13625_14994.t2 VSS.t2755 VSS.t2754 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X1416 VDD.t411 a_41550_6473.t3 a_41652_6560.t1 VDD.t125 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1417 a_31083_950.t8 a_31159_594# a_31249_690.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1418 VSS.t1036 VSS.t1011 VSS.t1036 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X1419 a_16509_14931.t0 a_15572_14960.t2 a_16320_14693.t0 VDD.t887 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1420 6MSB_0.OUTP.t90 a_3877_12094.t2 a_5003_12150.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1421 a_13930_8998.t1 a_13625_9394.t2 VDD.t177 VDD.t159 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1422 a_11689_6290.t3 a_11599_6194# VSS.t3102 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1423 a_29779_6216.t0 VDD.t1549 VSS.t1655 VSS.t3899 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1424 a_n2852_4060.t0 X8.t3 a_n2946_4060.t0 VSS.t2312 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.2176p
+ ps=1.96u w=0.64u l=0.13u
X1425 a_26970_598.t1 a_26665_994.t2 VDD.t457 VDD.t456 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1426 VDD.t459 a_n2042_2484.t6 a_20239_994.t0 VDD.t458 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1427 a_21581_3734.t1 a_21555_3639.t3 VDD.t523 VDD.t297 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1428 a_3508_3633.t1 VDD.t1573 VDD.t480 VDD.t303 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1429 a_44289_6290.t4 a_44199_6194# a_44123_6550.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1430 VSS.t2578 a_49799_26830.t2 a_50396_26489.t0 VSS.t2577 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1431 VSS.t3229 a_29588_17633.t2 a_29266_17493.t1 VSS.t3228 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1432 VSS.t1104 a_35030_12073.t3 a_35132_12160.t0 VSS.t1103 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1433 a_28101_9334.t1 a_28075_9239.t3 VDD.t225 VDD.t153 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1434 a_10028_17633.t1 VDD.t1361 VDD.t1056 VDD.t741 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X1435 a_28510_17673.t0 CLK.t51 VSS.t2295 VSS.t3625 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1436 a_16739_9016.t0 VDD.t1489 VSS.t1339 VSS.t3859 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1437 a_18043_3750.t6 a_17338_3714.t2 6MSB_0.OUTN.t126 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1438 VSS.t4156 a_24639_14594# a_24729_14690.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1439 a_10397_6494.t1 a_9800_6293.t2 VDD.t337 VDD.t141 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1440 a_20839_3714.t1 a_n2042_2484.t14 VDD.t472 VDD.t297 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1441 a_51516_24785.t1 4LSB_weighted_0.VBIAS a_51440_25469.t6 VSS.t4066 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X1442 a_31249_9090.t4 a_31159_8994# a_31083_9350.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1443 a_18043_6550.t5 a_17338_6514.t2 6MSB_0.OUTN.t39 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1444 VSS.t2210 a_41550_873.t3 a_41652_960.t0 VSS.t2209 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1445 VSS.t1081 VSS.t1077 a_44123_950.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1446 VDD.t970 a_20145_17794.t2 a_20450_17398.t1 VDD.t737 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1447 a_10601_9294.t1 a_9800_9093.t2 VDD.t189 VDD.t162 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1448 VDD.t640 a_10601_894.t2 a_10818_914.t1 VDD.t460 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1449 VSS.t3009 a_50027_26708.t2 a_49705_26830.t1 VSS.t3008 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1450 VSS.t471 VSS.t470 a_24563_14950.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1451 VDD.t612 a_n2966_249.t2 a_n2770_240.t1 VDD.t610 sg13_lv_pmos ad=0.7336p pd=3.55u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1452 a_47950_6229.t1 a_47661_6534.t4 a_47887_6229.t0 VSS.t1723 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X1453 VSS.t4074 4LSB_weighted_0.VBIAS a_51517_23976.t0 VSS.t4073 sg13_hv_nmos ad=0.114p pd=0.98u
+ as=0.114p ps=0.98u w=0.6u l=0.48u
X1454 VSS.t2841 a_18119_20194# a_18209_20290.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1455 a_7698_17417.t1 a_n2648_3264.t16 a_7799_17714.t0 VSS.t3437 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1456 a_37603_17750.t9 a_37679_17394# a_37769_17490.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1457 VSS.t2617 a_35880_14693.t2 a_36477_14894.t0 VSS.t2615 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1458 a_11523_6550.t8 a_11599_6194# a_11689_6290.t5 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1459 VSS.t2050 a_3508_833.t2 a_3186_693.t1 VSS.t2049 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1460 a_51442_27857.t5 a_50817_27517.t2 6MSB_0.OUTP.t69 VSS.t3077 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1461 a_5169_690.t0 a_5079_594# VSS.t891 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1462 a_49721_14894.t1 a_48920_14693.t2 VDD.t783 VDD.t3 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1463 a_23641_894.t0 a_22840_693.t2 VSS.t2133 VSS.t2134 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X1464 VSS.t1504 a_n2646_2484.t5 a_33185_3794.t0 VSS.t1503 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1465 a_37603_17750.t4 a_36477_17694.t2 6MSB_0.OUTP.t132 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1466 VSS.t3496 a_31159_594# a_31249_690.t0 VSS.t3495 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1467 VDD.t982 a_29588_14833.t2 a_29549_14931.t0 VDD.t884 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1468 VSS.t436 VSS.t434 VSS.t435 VSS.t415 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X1469 a_679_3794.t0 a_653_546.t3 a_585_3794.t1 VDD.t303 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X1470 a_44289_20290.t5 a_44199_20194# a_44123_20550.t7 VSS.t3156 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1471 VSS.t3526 a_5079_11794# a_5169_11890.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1472 VSS.t1471 VDD.t1515 a_47469_9016.t0 VSS.t3876 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1473 a_8255_3416.t2 a_9052_3760.t3 a_8515_3639.t1 VDD.t301 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1474 VSS.t943 VSS.t942 a_50643_3750.t1 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1475 6MSB_0.OUTP.t42 a_16917_3694.t2 a_18043_3750.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1476 a_1201_24685.t1 X7.t2 a_1649_24936.t0 VDD.t76 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1477 a_37603_12150.t6 a_37679_11794# a_37769_11890.t5 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1478 VDD.t106 a_43201_12094.t2 a_43418_12114.t1 VDD.t91 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1479 6MSB_0.OUTN.t38 a_17338_6514.t2 a_18043_6550.t4 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1480 VSS.t1255 a_n2042_972.t6 a_20145_6594.t0 VSS.t1254 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1481 a_2310_629.t0 a_2532_960.t3 a_1995_839.t1 VSS.t2023 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X1482 VDD.t534 a_26665_3794.t2 a_26970_3398.t1 VDD.t295 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1483 VSS.t2341 a_37679_20194# a_37769_20290.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1484 a_31249_17490.t0 a_31159_17394# VSS.t397 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1485 a_18209_690.t5 a_18119_594# a_18043_950.t7 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1486 VSS.t1859 a_16320_3493.t2 a_16917_3694.t0 VSS.t1857 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1487 VSS.t2970 a_7105_17794.t2 a_7410_17398.t0 VSS.t2969 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1488 a_44289_690.t4 a_44199_594# a_44123_950.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1489 a_16509_931.t0 a_15572_960.t2 a_16320_693.t0 VDD.t444 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1490 a_48070_6473.t1 CLK.t16 VDD.t426 VDD.t0 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X1491 VSS.t2357 a_11599_17394# a_11689_17490.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1492 a_37769_17490.t7 a_37679_17394# a_37603_17750.t8 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1493 VDD.t1141 a_n2648_3264.t8 a_7199_14994.t0 VDD.t912 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X1494 VDD.t85 a_35880_11893.t2 a_36108_12033.t1 VDD.t66 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1495 a_1963_25289.t1 X6.t3 a_2009_25540.t0 VDD.t76 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1496 a_18209_20290.t2 a_18119_20194# VSS.t2839 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1497 a_28101_17734.t2 a_28075_17639.t3 VSS.t3780 VSS.t4316 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1498 a_28075_839.t1 a_28510_873.t3 a_28458_1007.t0 VDD.t456 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X1499 a_9800_693.t1 a_8950_873.t2 a_9706_693.t0 VSS.t2066 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1500 VSS.t1837 a_10601_3694.t2 a_10818_3714.t0 VSS.t1836 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1501 VSS.t1333 a_17121_9294.t2 a_17338_9314.t0 VSS.t1332 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1502 VDD.t345 a_13625_6594.t2 a_13930_6198.t1 VDD.t127 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1503 VDD.t591 a_48920_3493.t2 a_49517_3694.t1 VDD.t293 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1504 VSS.t340 VSS.t338 a_11523_17750.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1505 a_33879_12114.t0 a_33490_11798.t2 VDD.t69 VDD.t66 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X1506 a_50643_950.t6 a_49938_914.t2 6MSB_0.OUTN.t112 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1507 a_35030_9273.t1 CLK.t26 VDD.t242 VDD.t150 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X1508 a_37603_9350.t3 a_37679_8994# a_37769_9090.t6 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1509 VSS.t1043 a_11599_594# a_11689_690.t3 VSS.t3073 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1510 a_50396_26489.t1 a_49799_26830.t2 VDD.t826 VDD.t13 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1511 a_4305_24905.t1 a_4285_25305.t2 VDD.t1090 VDD.t77 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X1512 a_43418_20514.t1 a_43201_20494.t2 VDD.t868 VDD.t801 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X1513 6MSB_0.OUTN.t131 a_4298_17714.t2 a_5003_17750.t5 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1514 a_30378_14914.t0 a_30161_14894.t2 VSS.t3316 VSS.t3315 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1515 a_5169_11890.t2 a_5079_11794# VSS.t3524 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1516 a_50643_3750.t5 a_49938_3714.t2 6MSB_0.OUTN.t115 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1517 a_21555_17639.t1 a_21990_17673.t3 a_21295_17416.t3 VSS.t4171 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1518 6MSB_0.OUTN.t71 a_23858_14914.t2 a_24563_14950.t6 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1519 VSS.t4267 a_11599_8994# a_11689_9090.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1520 VSS.t4237 a_5079_3394# a_5169_3490.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1521 a_1201_24910.t1 a_1261_25305.t2 VDD.t840 VDD.t76 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X1522 a_50643_6550.t1 a_49517_6494.t2 6MSB_0.OUTP.t3 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1523 VDD.t400 a_35880_6293.t2 a_36477_6494.t1 VDD.t135 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1524 a_29549_17731.t0 a_28612_17760.t2 a_29360_17493.t0 VDD.t733 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1525 a_8541_14934.t3 a_8515_14839.t3 VDD.t1402 VDD.t912 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1526 a_28510_14873.t1 CLK.t43 VDD.t982 VDD.t884 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X1527 VDD.t633 a_10028_833.t2 a_9989_931.t0 VDD.t460 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1528 VSS.t3267 a_4081_20494.t2 a_4298_20514.t0 VSS.t3266 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1529 a_17121_20494.t0 a_16320_20293.t2 VSS.t2923 VSS.t2924 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1530 VSS.t2467 a_7410_11798.t2 a_7698_11817.t0 VSS.t2466 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1531 VSS.t3484 a_11599_11794# a_11689_11890.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1532 VSS.t2256 a_48070_14873.t3 a_48172_14960.t0 VSS.t2255 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1533 VDD.t469 a_n2042_2484.t12 a_33879_3714.t1 VDD.t290 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1534 a_15287_3429.t0 VDD.t1581 VSS.t3922 VSS.t3921 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X1535 VDD.t216 a_22840_9093.t2 a_23437_9294.t1 VDD.t156 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1536 a_40010_8998.t1 a_39705_9394.t2 VDD.t250 VDD.t147 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1537 a_41141_934.t1 a_41115_839.t3 VDD.t706 VDD.t448 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1538 VSS.t1163 a_46225_12194.t2 a_46530_11798.t0 VSS.t1162 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1539 a_21990_9273.t0 CLK.t28 VSS.t1367 VSS.t3663 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1540 VSS.t851 VSS.t832 a_37603_6550.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X1541 VSS.t2330 a_13625_17794.t2 a_13930_17398.t0 VSS.t2329 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1542 a_4081_12094.t0 a_3280_11893.t2 VSS.t2432 VSS.t2433 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1543 a_16917_12094.t1 a_16320_11893.t2 VDD.t28 VDD.t25 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1544 6MSB_0.OUTN.t114 a_49938_3714.t2 a_50643_3750.t4 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1545 VSS.t4 a_50600_27497.t2 a_50817_27517.t0 VSS.t3 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1546 VDD.t314 a_n2646_2484.t15 a_20839_6514.t1 VDD.t139 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1547 a_585_12194.t0 a_653_546.t6 VSS.t3218 VSS.t3217 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X1548 a_50809_11890.t3 a_50719_11794# VSS.t3449 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1549 a_15061_20534.t0 a_15572_20560.t2 a_16320_20293.t1 VSS.t2609 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X1550 a_24563_12150.t3 a_24639_11794# a_24729_11890.t4 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1551 a_46919_3714.t1 a_n2042_2484.t10 VDD.t464 VDD.t293 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1552 6MSB_0.OUTN.t61 a_43418_12114.t2 a_44123_12150.t9 VSS.t1130 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1553 a_34621_6534.t1 a_34595_6439.t3 VDD.t394 VDD.t135 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1554 a_21870_3429.t0 a_22092_3760.t3 a_21555_3639.t0 VSS.t1873 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1555 VSS.t2917 VDD.t1287 a_34429_20216.t0 VSS.t3764 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1556 6MSB_0.OUTN.t27 a_10818_17714.t2 a_11523_17750.t9 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1557 a_41498_9407.t0 a_41141_9334.t4 VDD.t256 VDD.t147 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1558 VSS.t1739 a_49721_6494.t2 a_49938_6514.t0 VSS.t1738 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1559 a_11689_11890.t2 a_11599_11794# VSS.t3481 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1560 a_35030_873.t0 CLK.t2 VSS.t2182 VSS.t3689 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1561 6MSB_0.OUTP.t94 a_3877_17694.t2 a_5003_17750.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1562 a_21938_17807.t0 a_21581_17734.t4 VDD.t1374 VDD.t737 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1563 a_29957_14894.t0 a_29360_14693.t2 VSS.t2950 VSS.t2949 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1564 VDD.t661 VDD.t1651 a_21295_616.t0 VDD.t458 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1565 VSS.t892 VSS.t889 VSS.t891 VSS.t890 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X1566 a_2310_3429.t1 a_2021_3734.t4 a_2247_3429.t0 VSS.t1762 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X1567 a_33879_6514.t1 a_n2646_2484.t13 VDD.t309 VDD.t135 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1568 VDD.t72 a_3509_25305.t2 a_3545_25331.t1 VDD.t71 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1569 a_15061_14934.t1 a_15035_14839.t3 VDD.t924 VDD.t887 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1570 a_3508_9233.t0 VDD.t1477 VDD.t167 VDD.t122 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1571 a_21581_9334.t1 a_21555_9239.t3 VDD.t210 VDD.t156 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1572 VSS.t3279 a_35030_17673.t3 a_35132_17760.t0 VSS.t3278 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1573 a_42628_17633.t0 VDD.t1305 VDD.t1062 VDD.t812 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X1574 VDD.t941 a_40010_14598.t2 a_40399_14914.t2 VDD.t810 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X1575 a_23858_3714.t0 a_23641_3694.t2 VSS.t1890 VSS.t1889 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1576 VSS.t3389 a_13930_11798.t2 a_14218_11817.t2 VSS.t3388 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1577 a_34595_3639.t0 a_35030_3673.t3 a_34335_3416.t3 VSS.t1934 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1578 VSS.t3322 a_33185_14994.t2 a_33490_14598.t0 VSS.t3321 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1579 a_7799_6514.t0 a_n2646_2484.t17 a_7698_6217.t0 VSS.t1530 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1580 a_23029_3731.t0 a_22092_3760.t2 a_22840_3493.t0 VDD.t297 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1581 a_14869_3416.t0 a_14319_3714.t3 a_14775_3416.t1 VSS.t1844 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1582 VDD.t869 a_43201_20494.t2 a_43418_20514.t1 VDD.t801 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X1583 a_3508_12033.t1 VDD.t1433 VDD.t766 VDD.t765 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1584 a_20839_9314.t1 a_n2042_972.t14 VDD.t157 VDD.t156 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1585 VDD.t710 a_42400_693.t2 a_42628_833.t1 VDD.t448 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1586 a_37603_20550.t4 a_37679_20194# a_37769_20290.t6 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1587 a_8349_616.t0 a_7799_914.t3 a_8255_616.t0 VSS.t2061 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1588 VSS.t535 VSS.t533 VSS.t534 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X1589 a_20738_11817.t1 a_20450_11798.t2 VSS.t35 VSS.t34 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X1590 VSS.t1247 a_n2042_972.t2 a_46225_6594.t0 VSS.t1246 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1591 VDD.t795 a_35880_20293.t2 a_36108_20433.t1 VDD.t793 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1592 6MSB_0.OUTP.t112 a_23437_894.t2 a_24563_950.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1593 VSS.t2047 a_3280_693.t2 a_3877_894.t0 VSS.t2046 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1594 a_50409_23971.t1 a_49608_24288.t2 VDD.t1775 VDD.t760 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1595 a_42400_20293.t1 a_41550_20473.t2 a_42306_20293.t1 VSS.t2623 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1596 a_27909_14616.t0 a_27359_14914.t3 a_27815_14616.t1 VSS.t3323 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1597 a_33879_20514.t0 a_33490_20198.t2 VDD.t929 VDD.t793 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X1598 a_39799_12194.t0 a_4321_24727.t6 a_39705_12194.t1 VDD.t91 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1599 6MSB_0.OUTP.t88 a_42997_12094.t2 a_44123_12150.t0 VSS.t1164 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1600 a_679_9394.t0 a_653_546.t5 a_585_9394.t1 VDD.t122 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X1601 a_1735_3416.t3 a_2532_3760.t3 a_1995_3639.t1 VDD.t303 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1602 6MSB_0.OUTP.t30 a_10397_3694.t2 a_11523_3750.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1603 VSS.t2913 a_5079_17394# a_5169_17490.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1604 a_8255_9016.t2 a_9052_9360.t3 a_8515_9239.t0 VDD.t162 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1605 VSS.t1688 a_39705_6594.t2 a_40010_6198.t0 VSS.t1687 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1606 VDD.t519 a_20145_3794.t2 a_20450_3398.t1 VDD.t297 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1607 VDD.t221 a_26665_9394.t2 a_26970_8998.t1 VDD.t153 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1608 VSS.t1832 a_9800_3493.t2 a_10397_3694.t0 VSS.t1830 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1609 a_7410_11798.t0 a_7105_12194.t2 VSS.t2439 VSS.t2438 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X1610 VSS.t1347 a_16320_9093.t2 a_16917_9294.t0 VSS.t1345 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1611 a_18209_6290.t6 a_18119_6194# a_18043_6550.t9 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1612 VSS.t1310 a_10601_9294.t2 a_10818_9314.t0 VSS.t1309 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1613 VDD.t764 a_15470_17673.t3 a_15572_17760.t1 VDD.t748 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X1614 a_10028_12033.t1 VDD.t1269 VDD.t18 VDD.t17 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1615 VDD.t276 a_48920_9093.t2 a_49517_9294.t1 VDD.t2 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1616 a_50643_6550.t6 a_49938_6514.t2 6MSB_0.OUTN.t0 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1617 a_5003_9350.t5 a_4298_9314.t2 6MSB_0.OUTN.t93 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1618 a_23437_3694.t0 a_22840_3493.t2 VSS.t1884 VSS.t1883 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1619 VSS.t1798 a_2430_3673.t3 a_2532_3760.t0 VSS.t1797 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1620 a_16917_20494.t1 a_16320_20293.t2 VDD.t974 VDD.t7 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1621 a_5169_17490.t2 a_5079_17394# VSS.t2911 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1622 VDD.t36 a_20145_12194.t2 a_20450_11798.t1 VDD.t34 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1623 a_24563_20550.t3 a_24639_20194# a_24729_20290.t6 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1624 a_24729_14690.t2 a_24639_14594# VSS.t4158 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1625 VSS.t4087 a_5079_8994# a_5169_9090.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1626 VSS.t982 VSS.t979 a_44123_3750.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X1627 a_10028_3633.t0 a_9800_3493.t2 a_10219_3416.t0 VSS.t1829 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1628 a_37603_12150.t8 a_37679_11794# a_37769_11890.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1629 a_49339_11816.t0 VDD.t1471 VSS.t1186 VSS.t3847 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1630 VDD.t540 a_29588_3633.t2 a_29549_3731.t0 VDD.t295 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1631 a_48758_24994.t0 CLK.t64 VSS.t2977 VSS.t2976 sg13_lv_nmos ad=0.2516p pd=2.16u as=2.59765p
+ ps=9.435u w=0.74u l=0.13u
X1632 a_10397_6494.t0 a_9800_6293.t2 VSS.t1570 VSS.t1569 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1633 a_47950_3429.t0 a_48172_3760.t3 a_47635_3639.t0 VSS.t1984 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1634 VSS.t4209 a_7410_17398.t2 a_7698_17417.t2 VSS.t4208 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1635 a_21870_11829.t1 a_21581_12134.t4 a_21807_11829.t0 VSS.t41 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X1636 VSS.t263 VSS.t146 VSS.t263 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1637 VSS.t2358 a_11599_17394# a_11689_17490.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1638 VSS.t409 VSS.t408 a_37603_17750.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1639 VSS.t2773 a_26970_14598.t2 a_27258_14617.t0 VSS.t2772 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1640 a_15287_9029.t0 VDD.t1485 VSS.t3858 VSS.t3857 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X1641 a_2430_3673.t0 CLK.t15 VSS.t1798 VSS.t3676 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1642 VDD.t152 a_n2042_972.t12 a_33879_9314.t1 VDD.t150 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1643 VSS.t3993 a_50719_594# a_50809_690.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1644 VSS.t4294 a_46225_17794.t2 a_46530_17398.t0 VSS.t4293 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1645 VDD.t351 a_16548_6433.t2 a_16509_6531.t0 VDD.t127 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1646 a_37603_950.t0 VSS.t1023 VSS.t1024 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1647 a_51517_23976.t3 4LSB_weighted_0.VBIAS a_51453_23453.t6 VSS.t4067 sg13_hv_nmos ad=0.114p
+ pd=0.98u as=0.114p ps=0.98u w=0.6u l=0.48u
X1648 6MSB_0.OUTN.t92 a_4298_9314.t2 a_5003_9350.t4 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1649 a_34910_6229.t0 a_35132_6560.t3 a_34595_6439.t1 VSS.t1635 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1650 VDD.t497 a_9800_3493.t2 a_10028_3633.t1 VDD.t301 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1651 a_4081_17694.t0 a_3280_17493.t2 VSS.t2386 VSS.t2387 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1652 6MSB_0.OUTP.t81 a_42997_14894.t2 a_44123_14950.t7 VSS.t1166 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1653 VDD.t950 a_n2044_1752.t15 a_14319_14914.t2 VDD.t887 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1654 a_33490_14598.t1 a_33185_14994.t2 VDD.t1076 VDD.t846 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X1655 VDD.t809 a_n2648_3264.t2 a_46319_14994.t0 VDD.t3 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1656 a_7799_12114.t1 a_n2770_240.t16 a_7698_11817.t1 VSS.t3379 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1657 VDD.t335 VDD.t1527 a_8515_6439.t2 VDD.t141 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X1658 a_49938_3714.t0 a_49721_3694.t2 VSS.t2001 VSS.t2000 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1659 a_5169_3490.t3 a_5079_3394# VSS.t4237 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1660 VSS.t445 VSS.t444 VSS.t445 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1661 a_50643_950.t8 a_50719_594# a_50809_690.t5 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1662 a_585_17794.t0 a_653_546.t8 VSS.t2528 VSS.t2527 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X1663 a_49109_3731.t0 a_48172_3760.t2 a_48920_3493.t0 VDD.t293 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1664 a_40399_3714.t1 a_n2042_2484.t11 VDD.t466 VDD.t282 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1665 a_24563_20550.t0 VSS.t220 VSS.t222 VSS.t221 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1666 a_3508_20433.t1 VDD.t1325 VDD.t1023 VDD.t5 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1667 a_50809_17490.t3 a_50719_17394# VSS.t2377 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1668 a_37769_11890.t7 a_37679_11794# a_37603_12150.t7 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1669 a_46919_9314.t1 a_n2042_972.t10 VDD.t145 VDD.t2 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1670 a_46530_598.t1 a_46225_994.t2 VDD.t451 VDD.t4 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1671 a_36681_3694.t0 a_35880_3493.t2 VSS.t1940 VSS.t1941 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1672 6MSB_0.OUTN.t23 a_43418_17714.t2 a_44123_17750.t8 VSS.t2861 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1673 a_21870_9029.t0 a_22092_9360.t3 a_21555_9239.t1 VSS.t1356 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1674 a_44289_11890.t2 a_44199_11794# VSS.t3044 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1675 a_36898_6514.t0 a_36681_6494.t2 VSS.t1683 VSS.t1682 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1676 a_11689_17490.t2 a_11599_17394# VSS.t2360 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1677 a_890_6198.t0 a_585_6594.t2 VSS.t1259 VSS.t1489 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X1678 a_47635_6439.t1 a_48070_6473.t3 a_47375_6216.t2 VSS.t1728 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1679 VSS.t263 a_18119_20194# a_18209_20290.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1680 a_36299_14616.t0 VDD.t1405 VSS.t3817 VSS.t3816 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1681 a_2310_9029.t0 a_2021_9334.t4 a_2247_9029.t0 VSS.t1239 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X1682 VDD.t358 a_17121_6494.t2 a_17338_6514.t1 VDD.t127 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1683 a_27909_6216.t0 a_27359_6514.t3 a_27815_6216.t0 VSS.t1639 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1684 a_36069_6531.t0 a_35132_6560.t2 a_35880_6293.t0 VDD.t135 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1685 VDD.t896 a_35880_17493.t2 a_36477_17694.t1 VDD.t893 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1686 a_47661_14934.t1 a_47635_14839.t3 VDD.t780 VDD.t3 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1687 a_23641_6494.t0 a_22840_6293.t2 VSS.t1626 VSS.t1627 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1688 a_37769_6290.t1 a_37679_6194# VSS.t2776 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1689 VSS.t2675 a_43201_20494.t2 a_43418_20514.t0 VSS.t2674 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1690 VSS.t4030 a_31159_14594# a_31249_14690.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1691 VSS.t1174 a_46530_11798.t2 a_46818_11817.t0 VSS.t1173 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1692 a_4081_6494.t1 a_3280_6293.t2 VDD.t325 VDD.t143 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1693 VDD.t685 a_30161_894.t2 a_30378_914.t1 VDD.t456 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1694 VSS.t2042 a_2430_873.t3 a_2532_960.t0 VSS.t2041 sg13_lv_nmos ad=3.46165p pd=22.395u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1695 a_37603_20550.t8 a_36898_20514.t2 6MSB_0.OUTN.t9 VSS.t4119 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1696 a_39799_20594.t0 a_4321_24727.t9 a_39705_20594.t1 VDD.t801 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1697 a_23858_9314.t0 a_23641_9294.t2 VSS.t1374 VSS.t1373 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1698 a_26665_994.t0 a_2033_24727.t2 VSS.t4164 VSS.t4163 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X1699 a_48349_25055.t2 a_48323_24960.t3 VSS.t3216 VSS.t3215 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1700 VSS.t2590 a_13930_17398.t2 a_14218_17417.t0 VSS.t2591 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1701 VSS.t3815 VDD.t1427 a_40949_14616.t0 VSS.t3814 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1702 VSS.t445 a_5079_11794# a_5169_11890.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1703 a_29549_12131.t0 a_28612_12160.t2 a_29360_11893.t0 VDD.t50 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1704 a_34595_9239.t0 a_35030_9273.t3 a_34335_9016.t2 VSS.t1419 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1705 a_14869_9016.t0 a_14319_9314.t3 a_14775_9016.t0 VSS.t1326 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1706 a_23029_9331.t0 a_22092_9360.t2 a_22840_9093.t0 VDD.t156 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1707 VSS.t1556 a_7410_6198.t2 a_7698_6217.t2 VSS.t1555 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1708 a_43201_12094.t0 a_42400_11893.t2 VSS.t1154 VSS.t1155 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1709 a_20738_17417.t1 a_20450_17398.t2 VSS.t3079 VSS.t3080 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1710 a_14319_12114.t0 a_n2770_240.t15 a_14218_11817.t0 VSS.t3377 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1711 VSS.t1296 a_7105_9394.t2 a_7410_8998.t0 VSS.t1295 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X1712 VSS.t3730 a_29588_20433.t2 a_29266_20293.t1 VSS.t4095 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1713 6MSB_0.OUTP.t120 a_23437_6494.t2 a_24563_6550.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1714 VSS.t2110 a_17121_894.t2 a_17338_914.t0 VSS.t2109 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1715 a_28510_20473.t0 CLK.t58 VSS.t2958 VSS.t3640 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1716 VDD.t390 a_33185_6594.t2 a_33490_6198.t1 VDD.t135 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1717 a_10028_20433.t0 VDD.t1329 VDD.t763 VDD.t762 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X1718 a_37769_690.t5 a_37679_594# a_37603_950.t7 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1719 a_48949_27476.t1 CLK.t66 VDD.t998 VDD.t14 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.4292p ps=9.04u
+ w=1.12u l=0.13u
X1720 VDD.t787 a_49721_14894.t2 a_49938_14914.t1 VDD.t3 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1721 a_n2044_4040.t1 a_n2342_4060.t2 VDD.t437 VDD.t434 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.1918p
+ ps=1.5u w=1.12u l=0.13u
X1722 6MSB_0.OUTP.t40 a_42997_17694.t2 a_44123_17750.t0 VSS.t2888 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1723 a_1735_9016.t2 a_2532_9360.t3 a_1995_9239.t0 VDD.t122 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1724 a_36069_931.t0 a_35132_960.t2 a_35880_693.t0 VDD.t454 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1725 VDD.t957 a_20145_20594.t2 a_20450_20198.t1 VDD.t11 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1726 a_34621_17734.t3 a_34595_17639.t3 VDD.t1037 VDD.t893 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X1727 VSS.t885 a_31159_3394# a_31249_3490.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1728 a_24729_3490.t6 a_24639_3394# a_24563_3750.t9 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1729 a_23068_3633.t0 VDD.t1591 VDD.t525 VDD.t297 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1730 VDD.t206 a_20145_9394.t2 a_20450_8998.t1 VDD.t156 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1731 a_16917_894.t0 a_16320_693.t2 VSS.t2103 VSS.t2102 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1732 a_5169_690.t3 a_5079_594# VSS.t3598 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1733 a_7698_20217.t2 a_n2044_4040.t15 a_7799_20514.t1 VSS.t3549 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1734 a_37603_20550.t6 a_37679_20194# a_37769_20290.t5 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1735 VDD.t841 VDD.t1281 a_1735_14616.t1 VDD.t817 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1736 a_21938_12207.t0 a_21581_12134.t4 VDD.t41 VDD.t34 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1737 VSS.t1322 a_9800_9093.t2 a_10397_9294.t0 VSS.t1320 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1738 VSS.t903 a_31159_594# a_31249_690.t3 VSS.t3502 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1739 VDD.t594 a_49721_3694.t2 a_49938_3714.t1 VDD.t293 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1740 a_7410_17398.t0 a_7105_17794.t2 VSS.t2968 VSS.t2967 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X1741 VSS.t3051 a_18119_14594# a_18209_14690.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1742 a_37603_20550.t7 a_36477_20494.t2 6MSB_0.OUTP.t26 VSS.t2571 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1743 VSS.t4212 a_5079_6194# a_5169_6290.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1744 a_46530_17398.t1 a_46225_17794.t2 VDD.t1054 VDD.t905 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X1745 a_42628_12033.t1 VDD.t1465 VDD.t99 VDD.t91 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1746 a_21807_11829.t0 VDD.t1265 VSS.t3831 VSS.t3830 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X1747 a_17338_6514.t1 a_17121_6494.t2 VDD.t357 VDD.t127 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1748 a_8255_14616.t0 a_9052_14960.t3 a_8515_14839.t0 VDD.t912 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1749 a_39705_14994.t0 a_4321_24727.t7 VSS.t2519 VSS.t2518 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X1750 a_23068_6433.t0 a_22840_6293.t2 a_23259_6216.t0 VSS.t1623 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1751 VSS.t1280 a_2430_9273.t3 a_2532_9360.t0 VSS.t1279 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1752 a_44289_690.t6 a_44199_594# a_44123_950.t9 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1753 a_2021_3734.t3 a_2532_3760.t2 a_3280_3493.t1 VSS.t1795 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X1754 a_23858_14914.t1 a_23641_14894.t2 VDD.t882 VDD.t736 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X1755 a_23437_9294.t0 a_22840_9093.t2 VSS.t1370 VSS.t1369 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1756 a_21807_6229.t0 VDD.t1539 VSS.t3894 VSS.t3893 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X1757 VSS.t3270 a_7105_20594.t2 a_7410_20198.t0 VSS.t3269 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1758 a_31249_20290.t0 a_31159_20194# VSS.t281 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1759 a_4081_14894.t1 a_3280_14693.t2 VDD.t1708 VDD.t817 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1760 VDD.t308 a_n2646_2484.t12 a_40399_6514.t1 VDD.t125 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1761 a_46919_914.t1 VDD.t1687 a_46818_617.t1 VSS.t3986 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X1762 a_31083_17750.t7 a_31159_17394# a_31249_17490.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1763 a_31083_14950.t6 a_30378_14914.t2 6MSB_0.OUTN.t66 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1764 a_16548_833.t1 VDD.t1645 VDD.t648 VDD.t444 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1765 VSS.t2665 a_11599_20194# a_11689_20290.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1766 a_28101_20534.t2 a_28075_20439.t3 VSS.t3761 VSS.t4081 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X1767 a_37769_20290.t5 a_37679_20194# a_37603_20550.t5 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1768 a_49339_17416.t0 VDD.t1303 VSS.t3233 VSS.t3728 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1769 a_10028_9233.t1 a_9800_9093.t2 a_10219_9016.t0 VSS.t1319 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1770 VDD.t227 a_29588_9233.t2 a_29549_9331.t0 VDD.t153 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1771 VSS.t754 VSS.t745 a_44123_9350.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X1772 VSS.t2100 a_16548_833.t2 a_16226_693.t1 VSS.t2099 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1773 6MSB_0.OUTP.t13 a_16917_14894.t2 a_18043_14950.t6 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1774 VSS.t3792 a_3508_14833.t2 a_3186_14693.t1 VSS.t4021 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1775 a_18209_14690.t1 a_18119_14594# VSS.t3054 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1776 a_18209_690.t0 a_18119_594# VSS.t1050 VSS.t2634 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1777 a_41430_3429.t0 a_41652_3760.t3 a_41115_3639.t0 VSS.t1953 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1778 VDD.t437 a_n2648_4040.t2 a_n2342_4060.t0 VDD.t434 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1779 a_3877_17694.t1 a_3280_17493.t2 VDD.t754 VDD.t752 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1780 a_11689_17490.t7 a_11599_17394# a_11523_17750.t4 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1781 a_47950_9029.t0 a_48172_9360.t3 a_47635_9239.t0 VSS.t1469 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1782 VDD.t581 a_n2951_2880.t2 a_n2646_2484.t1 VDD.t286 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1783 VSS.t194 VSS.t192 a_11523_20550.t1 VSS.t193 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1784 a_21870_17429.t1 a_21581_17734.t4 a_21807_17429.t0 VSS.t4168 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X1785 a_46919_17714.t1 a_n2648_3264.t10 VDD.t1143 VDD.t905 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2184p ps=1.51u w=1.12u l=0.13u
X1786 a_23437_14894.t1 a_22840_14693.t2 VDD.t878 VDD.t736 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1787 VSS.t48 a_23068_12033.t2 a_22746_11893.t1 VSS.t47 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1788 6MSB_0.OUTN.t19 a_4298_20514.t2 a_5003_20550.t9 VSS.t4133 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1789 a_2430_9273.t0 CLK.t31 VSS.t1280 VSS.t3660 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X1790 a_47635_14839.t1 a_48070_14873.t3 a_47375_14616.t3 VSS.t2254 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1791 a_37603_6550.t0 VSS.t791 VSS.t792 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1792 a_21555_20439.t1 a_21990_20473.t3 a_21295_20216.t0 VSS.t3116 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1793 a_11689_14690.t6 a_11599_14594# a_11523_14950.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1794 VDD.t187 a_9800_9093.t2 a_10028_9233.t0 VDD.t162 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1795 a_49721_6494.t0 a_48920_6293.t2 VSS.t1734 VSS.t1735 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1796 a_29549_20531.t0 a_28612_20560.t2 a_29360_20293.t1 VDD.t9 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1797 a_7799_17714.t0 a_n2648_3264.t16 a_7698_17417.t0 VSS.t3436 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1798 a_49938_9314.t0 a_49721_9294.t2 VSS.t1486 VSS.t1485 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1799 VSS.t384 VSS.t379 VSS.t384 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1800 VDD.t959 a_585_14994.t2 a_890_14598.t1 VDD.t817 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1801 a_27359_14914.t2 a_n2044_1752.t13 a_27258_14617.t1 VSS.t2825 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1802 a_5169_9090.t3 a_5079_8994# VSS.t4087 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1803 VDD.t706 VDD.t1677 a_40855_616.t1 VDD.t448 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1804 a_42589_3731.t0 a_41652_3760.t2 a_42400_3493.t0 VDD.t282 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1805 a_37603_3750.t7 a_37679_3394# a_37769_3490.t4 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1806 a_44289_3490.t1 a_44199_3394# VSS.t3305 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1807 VDD.t532 a_23641_3694.t2 a_23858_3714.t1 VDD.t297 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1808 a_40399_9314.t0 a_n2042_972.t11 VDD.t148 VDD.t147 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1809 a_49109_9331.t0 a_48172_9360.t2 a_48920_9093.t0 VDD.t2 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1810 a_21870_629.t1 a_21581_934.t4 a_21807_629.t0 VSS.t2121 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X1811 VDD.t1725 X6.t1 a_3509_25305.t0 VDD.t71 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X1812 a_36681_9294.t0 a_35880_9093.t2 VSS.t1425 VSS.t1426 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1813 a_40399_3714.t2 a_40010_3398.t2 VDD.t565 VDD.t282 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X1814 a_10818_17714.t1 a_10601_17694.t2 VDD.t746 VDD.t741 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X1815 a_44289_17490.t2 a_44199_17394# VSS.t2495 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1816 VSS.t2764 VDD.t1393 a_14869_14616.t0 VSS.t3714 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1817 a_50643_14950.t4 a_50719_14594# a_50809_14690.t6 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1818 VDD.t1126 a_15470_12073.t3 a_15572_12160.t1 VDD.t25 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X1819 a_41115_6439.t0 a_41550_6473.t3 a_40855_6216.t2 VSS.t1702 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X1820 a_5003_950.t6 a_4298_914.t2 6MSB_0.OUTN.t100 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1821 a_24563_6550.t7 a_24639_6194# a_24729_6290.t4 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1822 VSS.t4297 a_13625_20594.t2 a_13930_20198.t0 VSS.t4296 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1823 a_8255_17416.t3 a_7799_17714.t3 VDD.t1085 VDD.t741 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1824 VDD.t1220 a_8950_14873.t3 a_9052_14960.t1 VDD.t912 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X1825 a_13719_994.t0 a_1253_24711.t2 a_13625_994.t1 VDD.t444 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1826 a_5003_3750.t5 a_4298_3714.t2 6MSB_0.OUTN.t15 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1827 a_n2770_240.t1 a_n2966_249.t2 VDD.t611 VDD.t610 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2086p
+ ps=1.5u w=1.12u l=0.13u
X1828 a_3699_616.t0 VDD.t1625 VSS.t2050 VSS.t3949 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X1829 VSS.t4321 a_46530_17398.t2 a_46818_17417.t2 VSS.t4320 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1830 a_31083_14950.t0 VSS.t507 VSS.t508 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1831 VSS.t3720 a_10028_14833.t2 a_9706_14693.t1 VSS.t4011 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1832 a_10397_17694.t1 a_9800_17493.t2 VDD.t742 VDD.t741 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1833 VSS.t384 a_5079_17394# a_5169_17490.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1834 6MSB_0.OUTN.t34 a_17338_14914.t2 a_18043_14950.t4 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1835 a_44123_3750.t2 VSS.t976 VSS.t984 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1836 6MSB_0.OUTN.t121 a_10818_20514.t2 a_11523_20550.t5 VSS.t2561 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1837 VSS.t2439 a_n2044_1752.t8 a_7105_12194.t0 VSS.t2817 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1838 a_49148_3633.t1 VDD.t1615 VDD.t587 VDD.t293 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1839 6MSB_0.OUTN.t88 a_50396_27497.t2 a_51442_27857.t5 VSS.t3442 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1840 6MSB_0.OUTP.t76 a_3877_20494.t2 a_5003_20550.t0 VSS.t4123 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1841 a_21938_20607.t0 a_21581_20534.t4 VDD.t1069 VDD.t11 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1842 VDD.t883 a_23641_14894.t2 a_23858_14914.t1 VDD.t736 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X1843 VSS.t463 VSS.t462 a_37603_12150.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1844 a_27258_3417.t1 a_n2042_2484.t13 a_27359_3714.t1 VSS.t1785 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1845 a_34595_17639.t1 a_35030_17673.t3 a_34978_17807.t0 VDD.t893 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X1846 a_43201_17694.t0 a_42400_17493.t2 VSS.t3253 VSS.t3254 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1847 a_34847_14629.t0 VDD.t1415 VSS.t3710 VSS.t3709 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X1848 VSS.t131 VSS.t129 VSS.t131 VSS.t130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1849 6MSB_0.OUTP.t114 a_3877_894.t2 a_5003_950.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1850 a_n2852_1036.t0 X8.t0 a_n2946_1036.t0 VSS.t2316 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.2176p
+ ps=1.96u w=0.64u l=0.13u
X1851 a_14319_17714.t1 a_n2648_3264.t15 a_14218_17417.t1 VSS.t3434 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1852 VSS.t1540 a_3508_6433.t2 a_3186_6293.t1 VSS.t1539 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1853 a_42628_20433.t1 VDD.t1275 VDD.t802 VDD.t801 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X1854 a_8898_6607.t0 a_8541_6534.t4 VDD.t335 VDD.t141 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X1855 a_37769_6290.t6 a_37679_6194# a_37603_6550.t9 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1856 6MSB_0.OUTN.t14 a_4298_3714.t2 a_5003_3750.t4 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1857 VSS.t2555 a_35030_20473.t3 a_35132_20560.t0 VSS.t2554 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1858 a_22840_14693.t0 a_21990_14873.t2 a_22746_14693.t1 VSS.t3453 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X1859 a_36108_6433.t1 VDD.t1555 VDD.t396 VDD.t135 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1860 VDD.t632 VDD.t1627 a_8515_839.t2 VDD.t460 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X1861 VSS.t859 a_44199_6194# a_44289_6290.t3 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1862 VDD.t1014 VDD.t1301 a_48254_27219.t1 VDD.t14 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1863 a_3469_14931.t0 a_2532_14960.t2 a_3280_14693.t0 VDD.t817 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1864 a_11689_6290.t0 a_11599_6194# VSS.t807 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1865 a_14218_6217.t1 a_n2646_2484.t16 a_14319_6514.t1 VSS.t1529 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1866 6MSB_0.OUTP.t103 a_10397_9294.t2 a_11523_9350.t5 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1867 a_1279_914.t1 VDD.t1617 a_1178_617.t1 VSS.t3944 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X1868 VDD.t568 VDD.t1605 a_40855_3416.t1 VDD.t282 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1869 a_37603_14950.t2 VSS.t564 VSS.t565 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X1870 a_24729_9090.t6 a_24639_8994# a_24563_9350.t9 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1871 VSS.t1550 a_4081_6494.t2 a_4298_6514.t0 VSS.t1549 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1872 VDD.t642 a_13625_994.t2 a_13930_598.t1 VDD.t444 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X1873 a_50643_12150.t0 VSS.t614 VSS.t615 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1874 VSS.t16 a_10601_12094.t2 a_10818_12114.t0 VSS.t15 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1875 a_23068_9233.t1 VDD.t1495 VDD.t212 VDD.t156 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1876 VSS.t725 a_31159_8994# a_31249_9090.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1877 a_23858_3714.t1 a_23641_3694.t2 VDD.t531 VDD.t297 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1878 VDD.t441 a_n2946_3612.t2 a_n2648_3264.t1 VDD.t286 sg13_lv_pmos ad=0.4256p pd=3u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1879 a_24729_17490.t5 a_24639_17394# a_24563_17750.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1880 a_16548_12033.t0 a_16320_11893.t2 a_16739_11816.t0 VSS.t21 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1881 VDD.t87 a_35880_11893.t2 a_36477_12094.t1 VDD.t66 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1882 VSS.t131 a_44199_11794# a_44289_11890.t3 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1883 VDD.t279 a_49721_9294.t2 a_49938_9314.t1 VDD.t2 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1884 a_27359_6514.t1 a_n2646_2484.t14 a_27258_6217.t0 VSS.t1524 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X1885 VDD.t747 a_10601_17694.t2 a_10818_17714.t1 VDD.t741 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X1886 VSS.t3138 a_5079_20194# a_5169_20290.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1887 a_13719_3794.t0 a_1253_24711.t3 a_13625_3794.t1 VDD.t299 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1888 a_21807_17429.t0 VDD.t1371 VSS.t3785 VSS.t3784 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X1889 VSS.t561 VSS.t556 VSS.t561 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1890 a_33279_17794.t0 a_3545_25331.t8 a_33185_17794.t1 VDD.t893 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X1891 a_2021_9334.t2 a_2532_9360.t2 a_3280_9093.t1 VSS.t1277 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X1892 a_18043_3750.t2 VSS.t955 VSS.t961 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1893 a_16320_3493.t1 a_15470_3673.t2 a_16226_3493.t0 VSS.t1849 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1894 VSS.t1813 a_7105_3794.t2 a_7410_3398.t0 VSS.t1812 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X1895 VSS.t681 VSS.t680 a_24563_9350.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X1896 VDD.t845 a_15470_20473.t3 a_15572_20560.t1 VDD.t7 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X1897 a_41430_9029.t0 a_41652_9360.t3 a_41115_9239.t0 VSS.t1441 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1898 a_24563_17750.t2 VSS.t389 VSS.t390 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X1899 VSS.t3782 a_23068_17633.t2 a_22746_17493.t1 VSS.t4227 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1900 VDD.t403 a_36681_6494.t2 a_36898_6514.t1 VDD.t135 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1901 a_5169_20290.t2 a_5079_20194# VSS.t3142 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1902 a_34621_12134.t1 a_34595_12039.t3 VDD.t81 VDD.t66 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X1903 VDD.t508 VDD.t1581 a_14775_3416.t0 VDD.t299 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1904 a_7410_598.t1 a_7105_994.t2 VDD.t461 VDD.t460 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1905 a_37603_9350.t1 a_36477_9294.t2 6MSB_0.OUTP.t65 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1906 VSS.t2780 a_37679_6194# a_37769_6290.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1907 VSS.t3212 a_7410_20198.t2 a_7698_20217.t0 VSS.t3211 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1908 a_50643_14950.t8 a_49938_14914.t2 6MSB_0.OUTN.t73 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1909 VDD.t219 a_23641_9294.t2 a_23858_9314.t1 VDD.t156 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1910 a_37603_9350.t7 a_37679_8994# a_37769_9090.t4 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1911 a_42589_9331.t0 a_41652_9360.t2 a_42400_9093.t0 VDD.t147 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1912 a_44289_9090.t1 a_44199_8994# VSS.t4281 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1913 VSS.t2119 VDD.t1651 a_21389_616.t0 VSS.t3964 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X1914 VSS.t1095 a_50719_594# a_50809_690.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1915 VSS.t2669 a_11599_20194# a_11689_20290.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1916 VSS.t302 VSS.t300 a_37603_20550.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1917 VSS.t2951 a_29360_14693.t2 a_29957_14894.t0 VSS.t2949 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1918 a_47375_14616.t2 a_48172_14960.t3 a_47635_14839.t0 VDD.t3 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1919 a_24563_9350.t6 a_23858_9314.t2 6MSB_0.OUTN.t33 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1920 a_14218_6217.t0 a_13930_6198.t2 VSS.t1583 VSS.t1582 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1921 VSS.t1881 a_21990_3673.t3 a_22092_3760.t0 VSS.t1880 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1922 VSS.t963 VSS.t958 VSS.t963 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1923 a_5003_14950.t5 a_5079_14594# a_5169_14690.t7 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1924 a_46530_11798.t1 a_46225_12194.t2 VDD.t107 VDD.t1 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X1925 a_40399_9314.t2 a_40010_8998.t2 VDD.t252 VDD.t147 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X1926 a_18209_6290.t7 a_18119_6194# a_18043_6550.t8 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1927 VDD.t730 a_49721_894.t2 a_49938_914.t1 VDD.t4 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X1928 a_17338_14914.t0 a_17121_14894.t2 VSS.t3171 VSS.t3170 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X1929 a_18209_14690.t3 a_18119_14594# VSS.t3052 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1930 a_5003_6550.t6 a_4298_6514.t2 6MSB_0.OUTN.t40 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1931 a_43201_14894.t1 a_42400_14693.t2 VDD.t866 VDD.t810 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X1932 a_585_6594.t0 a_653_546.t4 VSS.t3222 VSS.t3221 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X1933 a_8349_6216.t0 a_7799_6514.t3 a_8255_6216.t0 VSS.t1559 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1934 a_4285_25305.t1 X6.t0 VDD.t1089 VDD.t77 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.1918p ps=1.5u
+ w=0.84u l=0.13u
X1935 VDD.t283 a_n2646_2484.t4 a_39799_3794.t0 VDD.t282 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1936 a_4081_20494.t0 a_3280_20293.t2 VSS.t3184 VSS.t3185 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1937 VDD.t877 a_23068_14833.t2 a_23029_14931.t0 VDD.t736 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X1938 a_42997_17694.t1 a_42400_17493.t2 VDD.t1059 VDD.t812 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2014p ps=1.53u w=1.12u l=0.13u
X1939 VSS.t2654 a_42628_14833.t2 a_42306_14693.t1 VSS.t2653 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1940 a_4081_894.t0 a_3280_693.t2 VSS.t2047 VSS.t2048 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X1941 6MSB_0.OUTP.t33 a_50626_25035.t2 a_51440_25469.t3 VSS.t2598 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1942 a_585_20594.t0 a_653_546.t9 VSS.t2537 VSS.t2536 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X1943 a_31083_12150.t7 a_31159_11794# a_31249_11890.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1944 a_29588_14833.t0 a_29360_14693.t2 a_29779_14616.t0 VSS.t2948 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1945 6MSB_0.OUTN.t133 a_43418_20514.t2 a_44123_20550.t5 VSS.t2861 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X1946 a_44123_9350.t2 VSS.t742 VSS.t756 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X1947 VDD.t138 a_n2042_972.t5 a_26759_6594.t0 VDD.t137 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X1948 VSS.t2194 a_36681_894.t2 a_36898_914.t0 VSS.t2193 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1949 VSS.t996 a_50719_3394# a_50809_3490.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1950 a_42628_3633.t1 VDD.t1609 VDD.t570 VDD.t282 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1951 VSS.t4115 X6.t2 a_2713_25289.t0 VSS.t4112 sg13_lv_nmos ad=0.187p pd=1.78u as=0.1045p ps=0.93u
+ w=0.55u l=0.13u
X1952 VSS.t2968 a_n2044_4040.t8 a_7105_17794.t0 VSS.t3536 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1953 a_3877_12094.t1 a_3280_11893.t2 VDD.t768 VDD.t765 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X1954 a_11689_11890.t5 a_11599_11794# a_11523_12150.t7 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1955 a_49148_9233.t1 VDD.t1519 VDD.t272 VDD.t2 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X1956 a_37769_690.t0 a_37679_594# VSS.t906 VSS.t4100 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1957 a_50600_27497.t0 a_49799_27296.t2 VSS.t4149 VSS.t2579 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X1958 a_11689_20290.t2 a_11599_20194# VSS.t2667 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1959 a_46919_12114.t2 a_n2770_240.t10 VDD.t111 VDD.t1 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X1960 a_27258_9017.t1 a_n2042_972.t13 a_27359_9314.t0 VSS.t1267 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1961 VDD.t797 a_35880_20293.t2 a_36477_20494.t1 VDD.t793 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1962 6MSB_0.OUTP.t58 a_3877_6494.t2 a_5003_6550.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1963 a_1178_617.t2 VDD.t1617 a_1279_914.t1 VSS.t3945 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X1964 a_n2248_2100.t0 X10.t2 a_n2342_2100.t1 VSS.t2585 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.2176p
+ ps=1.96u w=0.64u l=0.13u
X1965 VSS.t485 VSS.t480 VSS.t485 VSS.t130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X1966 a_50643_14950.t6 a_50719_14594# a_50809_14690.t5 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1967 a_48070_873.t1 CLK.t0 VDD.t723 VDD.t4 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X1968 VSS.t3112 a_13930_20198.t2 a_14218_20217.t0 VSS.t3111 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1969 a_37769_11890.t3 a_37679_11794# VSS.t3618 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1970 VSS.t1545 a_3280_6293.t2 a_3877_6494.t0 VSS.t1544 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X1971 a_36477_894.t0 a_35880_693.t2 VSS.t2187 VSS.t2186 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X1972 a_50643_14950.t7 a_49517_14894.t2 6MSB_0.OUTP.t74 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1973 a_36898_6514.t1 a_36681_6494.t2 VDD.t402 VDD.t135 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1974 VDD.t1156 a_n2648_3264.t16 a_7799_17714.t1 VDD.t741 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X1975 a_11523_14950.t5 a_11599_14594# a_11689_14690.t7 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1976 a_23029_17731.t0 a_22092_17760.t2 a_22840_17493.t1 VDD.t737 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X1977 a_47375_17416.t1 a_46919_17714.t3 VDD.t1803 VDD.t905 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1978 a_8830_14629.t0 a_9052_14960.t3 a_8515_14839.t1 VSS.t4008 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X1979 a_20738_20217.t1 a_20450_20198.t2 VSS.t3332 VSS.t3333 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X1980 VDD.t255 VDD.t1509 a_40855_9016.t1 VDD.t147 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X1981 a_24563_950.t1 a_23437_894.t2 6MSB_0.OUTP.t113 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X1982 a_50809_3490.t7 a_50719_3394# a_50643_3750.t8 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1983 a_50643_17750.t0 VSS.t376 VSS.t378 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X1984 VDD.t1374 VDD.t1371 a_21555_17639.t2 VDD.t737 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X1985 VSS.t2691 a_890_11798.t2 a_1178_11817.t0 VSS.t2690 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1986 a_10818_12114.t1 a_10601_12094.t2 VDD.t23 VDD.t17 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1987 VSS.t2326 a_10601_17694.t2 a_10818_17714.t0 VSS.t2325 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X1988 a_23858_9314.t1 a_23641_9294.t2 VDD.t218 VDD.t156 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X1989 a_8255_11816.t1 a_7799_12114.t3 VDD.t790 VDD.t17 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X1990 a_47375_3416.t2 a_48172_3760.t3 a_47635_3639.t1 VDD.t293 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X1991 a_48157_24365.t0 X4.t0 a_48063_24365.t3 VSS.t4324 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X1992 a_16548_17633.t0 a_16320_17493.t2 a_16739_17416.t0 VSS.t2863 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X1993 VSS.t485 a_44199_17394# a_44289_17490.t3 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1994 a_50809_14690.t5 a_50719_14594# a_50643_14950.t5 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X1995 VSS.t1127 a_39705_12194.t2 a_40010_11798.t0 VSS.t1126 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X1996 VSS.t1161 a_n2044_1752.t2 a_46225_12194.t0 VSS.t2605 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X1997 VSS.t1637 a_26970_6198.t2 a_27258_6217.t2 VSS.t1636 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X1998 VSS.t1056 VSS.t1052 a_18043_950.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X1999 VSS.t2098 a_15470_873.t3 a_15572_960.t0 VSS.t2097 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2000 6MSB_0.OUTN.t2 a_50205_25015.t2 a_51440_25469.t0 VSS.t2592 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2001 VSS.t428 VSS.t425 VSS.t427 VSS.t426 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2002 a_36108_833.t1 VDD.t1675 VDD.t693 VDD.t454 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X2003 6MSB_0.OUTP.t100 a_42997_20494.t2 a_44123_20550.t0 VSS.t2888 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2004 a_10397_12094.t1 a_9800_11893.t2 VDD.t19 VDD.t17 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2005 a_13719_9394.t0 a_1253_24711.t5 a_13625_9394.t1 VDD.t159 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2006 a_34621_20534.t2 a_34595_20439.t3 VDD.t971 VDD.t793 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2007 VSS.t2268 a_18119_6194# a_18209_6290.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2008 a_34335_6216.t3 a_35132_6560.t3 a_34595_6439.t0 VDD.t135 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2009 a_18043_9350.t2 VSS.t714 VSS.t715 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X2010 a_2247_6229.t0 VDD.t1521 VSS.t3882 VSS.t3881 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2011 a_50027_27436.t1 a_49799_27296.t2 a_50218_27219.t0 VSS.t2574 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2012 a_16320_9093.t1 a_15470_9273.t2 a_16226_9093.t0 VSS.t1301 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2013 VDD.t540 a_28510_3673.t3 a_28612_3760.t1 VDD.t295 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2014 a_7410_20198.t0 a_7105_20594.t2 VSS.t253 VSS.t3268 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X2015 a_34595_12039.t1 a_35030_12073.t3 a_34978_12207.t0 VDD.t66 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2016 a_34429_11816.t0 a_33879_12114.t3 a_34335_11816.t0 VSS.t1096 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X2017 VDD.t480 a_3508_3633.t2 a_3469_3731.t0 VDD.t303 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2018 a_42589_14931.t0 a_41652_14960.t2 a_42400_14693.t1 VDD.t810 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2019 VDD.t898 a_36108_17633.t2 a_36069_17731.t0 VDD.t893 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2020 VDD.t379 VDD.t1545 a_27815_6216.t1 VDD.t137 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2021 a_8898_1007.t0 a_8541_934.t4 VDD.t632 VDD.t460 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2022 VSS.t134 VSS.t132 a_51517_23976.t1 VSS.t133 sg13_hv_nmos ad=0.204p pd=1.88u as=0.114p ps=0.98u
+ w=0.6u l=0.45u
X2023 VDD.t351 a_15470_6473.t3 a_15572_6560.t1 VDD.t127 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2024 6MSB_0.OUTN.t109 a_10818_914.t2 a_11523_950.t6 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2025 a_37603_9350.t6 a_36898_9314.t2 6MSB_0.OUTN.t44 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2026 a_41430_629.t1 a_41141_934.t4 a_41367_629.t0 VSS.t2205 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2027 6MSB_0.OUTP.t31 a_10397_3694.t2 a_11523_3750.t5 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2028 VDD.t197 VDD.t1485 a_14775_9016.t1 VDD.t159 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2029 a_18209_6290.t4 a_18119_6194# a_18043_6550.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2030 VSS.t1676 a_35030_6473.t3 a_35132_6560.t0 VSS.t1675 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2031 a_50409_23971.t0 a_49608_24288.t2 VSS.t4276 VSS.t4275 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2032 a_18209_690.t3 a_18119_594# VSS.t2641 VSS.t2640 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2033 VDD.t687 a_33185_994.t2 a_33490_598.t1 VDD.t454 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2034 a_29360_3493.t0 a_28510_3673.t2 a_28101_3734.t3 VDD.t295 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2035 a_31083_20550.t7 a_31159_20194# a_31249_20290.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2036 VSS.t433 VSS.t431 VSS.t432 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2037 a_37769_14690.t5 a_37679_14594# a_37603_14950.t7 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2038 a_3877_20494.t1 a_3280_20293.t2 VDD.t1024 VDD.t5 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2039 a_11689_20290.t5 a_11599_20194# a_11523_20550.t7 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2040 a_24729_11890.t5 a_24639_11794# a_24563_12150.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2041 VSS.t1771 a_n2042_2484.t5 a_26665_994.t0 VSS.t1770 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2042 a_33279_994.t0 a_3545_25331.t2 a_33185_994.t1 VDD.t454 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2043 a_21870_20229.t1 a_21581_20534.t4 a_21807_20229.t0 VSS.t3272 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2044 VSS.t1367 a_21990_9273.t3 a_22092_9360.t0 VSS.t1366 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2045 VSS.t954 VSS.t951 VSS.t954 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2046 a_49938_14914.t0 a_49721_14894.t2 VSS.t2463 VSS.t2462 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2047 VDD.t24 a_10601_12094.t2 a_10818_12114.t1 VDD.t17 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X2048 VSS.t720 VSS.t712 VSS.t720 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2049 a_16320_6293.t0 a_15470_6473.t2 a_15061_6534.t3 VDD.t127 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2050 VDD.t693 a_35030_873.t3 a_35132_960.t1 VDD.t454 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2051 a_24563_17750.t7 a_24639_17394# a_24729_17490.t6 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2052 a_1829_6216.t0 a_1279_6514.t3 a_1735_6216.t0 VSS.t1505 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2053 VSS.t3489 a_50719_3394# a_50809_3490.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2054 a_21389_14616.t0 a_20839_14914.t3 a_21295_14616.t0 VSS.t2731 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X2055 a_10219_6216.t0 VDD.t1531 VSS.t1574 VSS.t3887 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2056 a_29957_894.t1 a_29360_693.t2 VDD.t680 VDD.t456 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2057 VSS.t1020 VSS.t1019 a_37603_950.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2058 a_7799_20514.t1 a_n2044_4040.t15 a_7698_20217.t1 VSS.t3548 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2059 a_33279_12194.t0 a_3545_25331.t6 a_33185_12194.t1 VDD.t66 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2060 a_50643_6550.t2 VSS.t860 VSS.t866 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X2061 VSS.t117 VSS.t115 VSS.t117 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2062 VDD.t250 a_n2770_240.t3 a_39799_9394.t0 VDD.t147 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2063 VDD.t554 VDD.t1599 a_34595_3639.t2 VDD.t290 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2064 VSS.t3598 a_5079_594# a_5169_690.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2065 a_15061_934.t1 a_15035_839.t3 VDD.t646 VDD.t444 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2066 a_31249_3490.t5 a_31159_3394# a_31083_3750.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2067 VDD.t1015 VDD.t1311 a_48514_26437.t2 VDD.t13 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2068 VSS.t99 a_3509_25305.t2 a_3545_25331.t0 VSS.t3341 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X2069 VSS.t927 VSS.t926 a_24563_3750.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2070 a_10818_20514.t1 a_10601_20494.t2 VDD.t1788 VDD.t762 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X2071 a_42628_9233.t0 VDD.t1513 VDD.t257 VDD.t147 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X2072 VSS.t763 a_50719_8994# a_50809_9090.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2073 VSS.t2189 a_35880_693.t2 a_36477_894.t0 VSS.t2188 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X2074 a_8541_934.t2 a_9052_960.t2 a_9800_693.t1 VSS.t2067 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2075 a_44289_20290.t2 a_44199_20194# VSS.t3166 VSS.t3158 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2076 a_24563_14950.t4 a_23437_14894.t2 6MSB_0.OUTP.t128 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2077 a_24563_12150.t2 VSS.t449 VSS.t475 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X2078 a_11523_3750.t9 a_11599_3394# a_11689_3490.t7 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2079 a_5169_3490.t0 a_5079_3394# VSS.t872 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2080 a_8255_20216.t3 a_7799_20514.t3 VDD.t1043 VDD.t762 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2081 VSS.t456 VSS.t454 VSS.t455 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2082 a_7799_6514.t1 a_n2646_2484.t17 VDD.t317 VDD.t141 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2083 a_37603_950.t5 a_36898_914.t2 6MSB_0.OUTN.t111 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2084 a_30161_3694.t1 a_29360_3493.t2 VDD.t544 VDD.t295 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2085 a_8515_3639.t0 a_8950_3673.t3 a_8255_3416.t3 VSS.t1826 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X2086 a_49608_24288.t0 a_48758_23938.t2 a_48349_23931.t1 VDD.t760 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2087 a_10397_20494.t1 a_9800_20293.t2 VDD.t1783 VDD.t762 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2088 a_37769_17490.t3 a_37679_17394# VSS.t4055 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2089 VSS.t2770 a_15470_14873.t3 a_15572_14960.t0 VSS.t2769 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2090 a_44123_14950.t5 a_44199_14594# a_44289_14690.t7 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2091 a_37603_3750.t1 a_36477_3694.t2 6MSB_0.OUTP.t35 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2092 VSS.t117 a_5079_20194# a_5169_20290.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2093 a_24563_950.t6 a_23858_914.t2 6MSB_0.OUTN.t98 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2094 VDD.t602 a_n2342_2100.t2 a_n2044_1752.t1 VDD.t597 sg13_lv_pmos ad=0.4256p pd=3u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2095 a_37603_14950.t1 a_36477_14894.t2 6MSB_0.OUTP.t85 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2096 VSS.t110 VSS.t108 VSS.t110 VSS.t109 sg13_hv_nmos ad=57f pd=0.68u as=0 ps=0 w=0.3u l=0.45u
X2097 a_49517_14894.t0 a_48920_14693.t2 VSS.t2460 VSS.t2459 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2098 VSS.t1923 a_33490_3398.t2 a_33778_3417.t2 VSS.t1922 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2099 a_24563_3750.t5 a_23858_3714.t2 6MSB_0.OUTN.t29 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2100 VSS.t658 VSS.t657 VSS.t658 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2101 a_34595_20439.t1 a_35030_20473.t3 a_34978_20607.t0 VDD.t793 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2102 a_43201_20494.t0 a_42400_20293.t2 VSS.t2490 VSS.t2491 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2103 VSS.t1378 a_n2770_240.t5 a_26665_9394.t0 VSS.t3362 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2104 a_14319_20514.t1 a_n2044_4040.t14 a_14218_20217.t1 VSS.t3546 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2105 VSS.t3356 a_890_17398.t2 a_1178_17417.t0 VSS.t3355 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2106 a_50809_9090.t7 a_50719_8994# a_50643_9350.t8 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2107 a_24563_6550.t1 a_23437_6494.t2 6MSB_0.OUTP.t121 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2108 a_40855_3416.t2 a_41652_3760.t3 a_41115_3639.t1 VDD.t282 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2109 a_5169_14690.t4 a_5079_14594# a_5003_14950.t6 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2110 a_47375_9016.t3 a_48172_9360.t3 a_47635_9239.t1 VDD.t2 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2111 6MSB_0.OUTN.t110 a_36898_914.t2 a_37603_950.t4 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2112 VSS.t1932 a_36108_3633.t2 a_35786_3493.t1 VSS.t1931 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2113 a_48638_24352.t1 a_48349_23931.t4 a_48575_24352.t0 VSS.t2402 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2114 VSS.t4122 a_39705_17794.t2 a_40010_17398.t0 VSS.t4121 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X2115 VSS.t1609 a_20450_6198.t2 a_20738_6217.t2 VSS.t1608 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2116 a_16739_616.t0 VDD.t1645 VSS.t2100 VSS.t3961 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2117 VDD.t650 a_16320_693.t2 a_16548_833.t1 VDD.t444 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2118 VSS.t3005 a_2713_24685.t2 a_653_546.t0 VSS.t3086 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X2119 a_42997_12094.t1 a_42400_11893.t2 VDD.t101 VDD.t91 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2120 a_18043_950.t2 VSS.t1048 VSS.t1058 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X2121 VSS.t3240 a_n2044_4040.t2 a_46225_17794.t0 VSS.t3239 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2122 a_1279_12114.t1 a_n2770_240.t17 a_1178_11817.t1 VSS.t3381 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2123 a_49797_24050.t0 a_48860_23938.t2 a_49608_24288.t0 VDD.t760 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2124 VSS.t1618 a_23068_6433.t2 a_22746_6293.t1 VSS.t1617 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2125 a_28458_6607.t0 a_28101_6534.t4 VDD.t380 VDD.t137 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2126 VSS.t1945 a_36681_3694.t2 a_36898_3714.t0 VSS.t1944 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2127 a_7410_8998.t0 a_7105_9394.t2 VSS.t1294 VSS.t1293 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X2128 VDD.t227 a_28510_9273.t3 a_28612_9360.t1 VDD.t153 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2129 a_1997_24905.t1 a_1963_25289.t2 VDD.t1166 VDD.t76 sg13_lv_pmos ad=0.252p pd=1.57u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X2130 a_34429_17416.t0 a_33879_17714.t3 a_34335_17416.t2 VSS.t3201 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X2131 VDD.t167 a_3508_9233.t2 a_3469_9331.t0 VDD.t122 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2132 a_24729_20290.t7 a_24639_20194# a_24563_20550.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2133 a_44123_9350.t6 a_43418_9314.t2 6MSB_0.OUTN.t129 VSS.t1131 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2134 a_24729_3490.t4 a_24639_3394# a_24563_3750.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2135 a_22840_14693.t1 a_21990_14873.t2 a_21581_14934.t2 VDD.t736 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2136 VSS.t4255 a_31159_3394# a_31249_3490.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2137 VDD.t1789 a_10601_20494.t2 a_10818_20514.t1 VDD.t762 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X2138 VDD.t1046 a_29360_17493.t2 a_29957_17694.t1 VDD.t733 sg13_lv_pmos ad=0.2083p pd=1.5u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X2139 a_8541_14934.t0 a_9052_14960.t2 a_9800_14693.t0 VSS.t4012 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2140 a_41141_14934.t3 a_41115_14839.t3 VDD.t1428 VDD.t810 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X2141 a_47950_14629.t1 a_48172_14960.t3 a_47635_14839.t1 VSS.t4188 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2142 VSS.t1631 a_23641_6494.t2 a_23858_6514.t0 VSS.t1630 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2143 a_21807_20229.t0 VDD.t1335 VSS.t3759 VSS.t3758 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2144 VSS.t577 VSS.t576 a_50643_14950.t3 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2145 a_28101_12134.t2 a_28612_12160.t2 a_29360_11893.t1 VSS.t71 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2146 a_31083_9350.t5 a_30378_9314.t2 6MSB_0.OUTN.t30 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2147 6MSB_0.OUTN.t81 a_10818_6514.t2 a_11523_6550.t6 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2148 a_33279_20594.t0 a_3545_25331.t9 a_33185_20594.t1 VDD.t793 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2149 VDD.t1117 a_n2770_240.t16 a_7799_12114.t2 VDD.t17 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2150 VSS.t1138 a_40010_11798.t2 a_40298_11817.t0 VSS.t1139 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2151 a_27258_14617.t2 a_n2044_1752.t13 a_27359_14914.t2 VSS.t2826 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2152 a_23029_12131.t0 a_22092_12160.t2 a_22840_11893.t0 VDD.t34 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2153 a_47375_11816.t1 a_46919_12114.t3 VDD.t109 VDD.t1 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2154 VSS.t2204 VDD.t1677 a_40949_616.t0 VSS.t3982 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2155 VSS.t2019 a_n2648_1016.t2 a_n2347_1368.t0 VSS.t2018 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2156 a_7799_17714.t2 a_7410_17398.t2 VDD.t1760 VDD.t741 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2157 VSS.t842 VSS.t837 VSS.t842 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2158 a_22840_3493.t0 a_21990_3673.t2 a_21581_3734.t3 VDD.t297 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2159 a_27359_14914.t0 a_26970_14598.t2 VDD.t927 VDD.t884 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2160 VDD.t41 VDD.t1265 a_21555_12039.t2 VDD.t34 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X2161 a_29360_9093.t0 a_28510_9273.t2 a_28101_9334.t3 VDD.t153 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2162 VDD.t445 a_n2042_2484.t7 a_13719_994.t0 VDD.t444 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2163 a_7105_994.t0 a_2713_24910.t2 VSS.t2804 VSS.t2803 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2164 a_41550_3673.t0 CLK.t9 VSS.t1963 VSS.t3682 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2165 6MSB_0.OUTP.t82 a_10397_12094.t2 a_11523_12150.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2166 a_24563_20550.t2 VSS.t122 VSS.t270 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X2167 6MSB_0.OUTN.t128 a_43418_9314.t2 a_44123_9350.t4 VSS.t1128 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2168 VSS.t2983 a_23068_20433.t2 a_22746_20293.t0 VSS.t2982 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2169 VSS.t653 VSS.t652 VSS.t653 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2170 a_23858_914.t0 a_23641_894.t2 VSS.t2136 VSS.t2135 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2171 VDD.t425 VDD.t1563 a_47635_6439.t2 VDD.t0 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X2172 VDD.t997 a_2713_24685.t2 a_653_546.t1 VDD.t71 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2173 a_44289_3490.t3 a_44199_3394# VSS.t3308 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2174 a_46530_6198.t1 a_46225_6594.t2 VDD.t133 VDD.t0 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2175 6MSB_0.OUTP.t28 a_29957_9294.t2 a_31083_9350.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2176 VSS.t2895 a_50719_8994# a_50809_9090.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2177 VSS.t788 VSS.t787 a_37603_6550.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2178 a_34335_616.t2 a_35132_960.t3 a_34595_839.t1 VDD.t454 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2179 6MSB_0.OUTP.t19 a_3877_14894.t2 a_5003_14950.t9 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2180 a_5169_14690.t1 a_5079_14594# VSS.t3011 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2181 a_18043_17750.t6 a_18119_17394# a_18209_17490.t5 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2182 a_18043_14950.t5 a_17338_14914.t2 6MSB_0.OUTN.t34 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2183 6MSB_0.OUTP.t97 a_23437_12094.t2 a_24563_12150.t5 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2184 VDD.t241 VDD.t1503 a_34595_9239.t2 VDD.t150 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2185 a_24563_6550.t9 a_24639_6194# a_24729_6290.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2186 a_n2648_4040.t0 a_n2946_4060.t2 VSS.t1741 VSS.t1740 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.1331p ps=1.12u w=0.74u l=0.13u
X2187 a_49339_6216.t0 VDD.t1567 VSS.t1726 VSS.t3911 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2188 a_31249_6290.t3 a_31159_6194# VSS.t2285 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2189 a_31249_9090.t5 a_31159_8994# a_31083_9350.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2190 a_41141_3734.t1 a_41115_3639.t3 VDD.t568 VDD.t282 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2191 a_5169_11890.t0 a_5079_11794# VSS.t442 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2192 VDD.t83 a_36108_12033.t2 a_36069_12131.t0 VDD.t66 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2193 a_48540_26473.t0 a_49051_26480.t2 a_49799_26830.t0 VSS.t5 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2194 a_43201_6494.t1 a_42400_6293.t2 VDD.t413 VDD.t125 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2195 a_5169_9090.t0 a_5079_8994# VSS.t647 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2196 a_11523_9350.t9 a_11599_8994# a_11689_9090.t7 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2197 a_14319_17714.t0 a_13930_17398.t2 VDD.t837 VDD.t748 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2198 a_9989_6531.t0 a_9052_6560.t2 a_9800_6293.t0 VDD.t141 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2199 a_24563_950.t8 a_24639_594# a_24729_690.t5 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2200 a_37603_3750.t6 a_36898_3714.t2 6MSB_0.OUTN.t116 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2201 VSS.t398 VSS.t396 VSS.t397 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2202 a_16739_11816.t0 VDD.t1263 VSS.t3398 VSS.t3828 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2203 a_31083_950.t5 a_30378_914.t2 6MSB_0.OUTN.t97 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2204 a_1201_24910.t0 a_1261_25305.t2 VSS.t2602 VSS.t2600 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X2205 a_33185_14994.t0 a_3545_25331.t7 VSS.t2995 VSS.t2994 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X2206 a_37603_6550.t4 a_36898_6514.t2 6MSB_0.OUTN.t11 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2207 a_7799_6514.t2 a_7410_6198.t2 VDD.t331 VDD.t141 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2208 VSS.t1718 a_46530_6198.t2 a_46818_6217.t2 VSS.t1719 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2209 a_42997_20494.t1 a_42400_20293.t2 VDD.t803 VDD.t801 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2210 a_30161_9294.t1 a_29360_9093.t2 VDD.t229 VDD.t153 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2211 a_n2253_1368.t0 X10.t1 a_n2347_1368.t1 VDD.t597 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X2212 VDD.t1006 a_20450_17398.t2 a_20839_17714.t0 VDD.t737 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X2213 a_8515_9239.t1 a_8950_9273.t3 a_8255_9016.t3 VSS.t1316 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X2214 a_37769_690.t3 a_37679_594# VSS.t4109 VSS.t4110 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2215 a_24563_6550.t6 a_23858_6514.t2 6MSB_0.OUTN.t122 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2216 a_49148_833.t0 a_48920_693.t2 a_49339_616.t0 VSS.t2241 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2217 VSS.t253 VSS.t251 a_7105_20594.t0 VSS.t252 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X2218 VSS.t1464 a_46225_9394.t2 a_46530_8998.t0 VSS.t1463 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X2219 a_35880_17493.t0 a_35030_17673.t2 a_34621_17734.t1 VDD.t893 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2220 VSS.t1410 a_33490_8998.t2 a_33778_9017.t2 VSS.t1409 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2221 VDD.t919 a_n2648_3264.t7 a_13719_14994.t0 VDD.t887 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X2222 a_7199_6594.t0 a_2713_24910.t4 a_7105_6594.t1 VDD.t141 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2223 VSS.t1068 VSS.t1067 a_37603_950.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2224 a_n2648_1016.t1 a_n2946_1036.t2 VDD.t603 VDD.t597 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.1918p
+ ps=1.5u w=1.12u l=0.13u
X2225 VSS.t950 VSS.t946 VSS.t949 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2226 VSS.t291 VSS.t289 VSS.t291 VSS.t290 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2227 6MSB_0.OUTP.t67 a_10397_14894.t2 a_11523_14950.t8 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2228 a_24563_12150.t8 a_24639_11794# a_24729_11890.t6 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2229 VSS.t2059 a_7410_598.t2 a_7698_617.t0 VSS.t2058 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2230 6MSB_0.OUTN.t58 a_4298_14914.t2 a_5003_14950.t7 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2231 a_18043_14950.t0 VSS.t503 VSS.t504 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2232 VSS.t3579 a_31159_11794# a_31249_11890.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2233 VSS.t1428 a_36108_9233.t2 a_35786_9093.t1 VSS.t1427 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2234 a_40855_9016.t2 a_41652_9360.t3 a_41115_9239.t1 VDD.t147 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2235 6MSB_0.OUTN.t96 a_30378_914.t2 a_31083_950.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2236 a_34978_3807.t0 a_34621_3734.t4 VDD.t554 VDD.t290 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2237 6MSB_0.OUTN.t10 a_36898_6514.t2 a_37603_6550.t5 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2238 a_51440_26253.t3 a_50817_26469.t2 6MSB_0.OUTP.t21 VSS.t2599 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2239 VDD.t1185 a_n2044_4040.t15 a_7799_20514.t2 VDD.t762 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2240 VDD.t1416 VDD.t1415 a_34595_14839.t0 VDD.t846 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2241 a_23029_20531.t0 a_22092_20560.t2 a_22840_20293.t1 VDD.t11 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2242 a_1279_17714.t2 a_n2648_3264.t17 a_1178_17417.t1 VSS.t3438 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2243 VDD.t1698 a_7105_14994.t2 a_7410_14598.t1 VDD.t912 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2244 a_16917_3694.t1 a_16320_3493.t2 VDD.t512 VDD.t299 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2245 a_51516_24785.t2 VSS.t140 VSS.t183 VSS.t141 sg13_hv_nmos ad=57f pd=0.68u as=0.102p ps=1.28u
+ w=0.3u l=0.45u
X2246 a_20839_14914.t2 a_n2044_1752.t14 a_20738_14617.t1 VSS.t2827 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2247 a_37769_6290.t4 a_37679_6194# a_37603_6550.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2248 a_34621_934.t1 a_34595_839.t3 VDD.t691 VDD.t454 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2249 VDD.t1069 VDD.t1335 a_21555_20439.t2 VDD.t11 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2250 VSS.t2622 a_36681_14894.t2 a_36898_14914.t0 VSS.t2621 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2251 a_21938_6607.t0 a_21581_6534.t4 VDD.t365 VDD.t139 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2252 VSS.t1918 a_30161_3694.t2 a_30378_3714.t0 VSS.t1917 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2253 VSS.t4043 a_44199_6194# a_44289_6290.t0 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2254 VSS.t4307 a_10601_20494.t2 a_10818_20514.t0 VSS.t4306 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2255 VSS.t548 VSS.t547 a_24563_14950.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2256 VSS.t1432 a_36681_9294.t2 a_36898_9314.t0 VSS.t1431 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2257 a_16548_20433.t0 a_16320_20293.t2 a_16739_20216.t0 VSS.t2920 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2258 a_14218_617.t2 VDD.t1637 a_14319_914.t1 VSS.t3957 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X2259 VSS.t291 a_44199_20194# a_44289_20290.t3 VSS.t3161 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2260 a_27815_17416.t0 a_28612_17760.t3 a_28075_17639.t1 VDD.t733 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2261 a_24729_9090.t4 a_24639_8994# a_24563_9350.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2262 VDD.t334 VDD.t1527 a_8255_6216.t1 VDD.t141 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2263 a_2310_629.t1 a_2021_934.t4 a_2247_629.t0 VSS.t2037 sg13_lv_nmos ad=0.1596p pd=1.6u as=38.85f
+ ps=0.605u w=0.42u l=0.13u
X2264 a_2247_629.t0 VDD.t1621 VSS.t3948 VSS.t3947 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2265 a_41141_3734.t2 a_41652_3760.t2 a_42400_3493.t1 VSS.t1960 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2266 a_31249_11890.t1 a_31159_11794# VSS.t3577 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2267 VSS.t2503 a_31159_8994# a_31249_9090.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2268 a_46919_914.t2 VDD.t1687 VDD.t719 VDD.t4 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X2269 a_10601_12094.t0 a_9800_11893.t2 VSS.t11 VSS.t12 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X2270 a_28101_17734.t0 a_28612_17760.t2 a_29360_17493.t1 VSS.t2292 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2271 VSS.t4136 a_40010_17398.t2 a_40298_17417.t2 VSS.t4137 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2272 a_3508_12033.t0 a_3280_11893.t2 a_3699_11816.t0 VSS.t2428 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2273 a_11689_6290.t2 a_11599_6194# VSS.t3100 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2274 a_1178_3417.t1 a_890_3398.t2 VSS.t1757 VSS.t1756 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X2275 a_44289_14690.t4 a_44199_14594# a_44123_14950.t6 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2276 a_5169_3490.t7 a_5079_3394# a_5003_3750.t8 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2277 6MSB_0.OUTN.t52 a_10818_14914.t2 a_11523_14950.t7 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2278 VSS.t1509 a_n2646_2484.t6 a_26665_3794.t0 VSS.t1508 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2279 a_22840_9093.t0 a_21990_9273.t2 a_21581_9334.t2 VDD.t156 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2280 a_40399_12114.t2 a_n2770_240.t11 a_40298_11817.t1 VSS.t3369 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2281 a_41550_9273.t0 CLK.t25 VSS.t1449 VSS.t3666 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2282 VDD.t794 a_36108_20433.t2 a_36069_20531.t0 VDD.t793 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2283 6MSB_0.OUTP.t52 a_10397_17694.t2 a_11523_17750.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2284 VDD.t920 a_13625_14994.t2 a_13930_14598.t1 VDD.t887 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2285 a_31083_3750.t9 a_31159_3394# a_31249_3490.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2286 a_7799_17714.t1 a_n2648_3264.t16 VDD.t1155 VDD.t741 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2287 a_50809_690.t4 a_50719_594# a_50643_950.t2 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2288 a_8515_14839.t1 a_8950_14873.t3 a_8255_14616.t1 VSS.t4013 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2289 a_27359_14914.t1 a_n2044_1752.t13 VDD.t928 VDD.t884 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2290 a_44289_9090.t3 a_44199_8994# VSS.t4285 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2291 a_3509_25305.t1 X6.t1 a_3893_25535.t0 VSS.t98 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X2292 a_28075_12039.t1 a_28510_12073.t3 a_27815_11816.t3 VSS.t72 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2293 a_28458_1007.t0 a_28101_934.t4 VDD.t677 VDD.t456 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2294 a_3508_833.t1 a_3280_693.t2 a_3699_616.t0 VSS.t2043 sg13_lv_nmos ad=0.1428p pd=1.52u as=37.8f
+ ps=0.6u w=0.42u l=0.13u
X2295 6MSB_0.OUTP.t125 a_23437_17694.t2 a_24563_17750.t5 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2296 a_13930_17398.t1 a_13625_17794.t2 VDD.t749 VDD.t748 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2297 VDD.t1134 a_n2044_4040.t5 a_26759_17794.t0 VDD.t733 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X2298 a_44123_950.t6 a_43418_914.t2 6MSB_0.OUTN.t104 VSS.t1129 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2299 a_7410_3398.t0 a_7105_3794.t2 VSS.t1515 VSS.t1811 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X2300 VDD.t906 a_48920_17493.t2 a_49148_17633.t1 VDD.t905 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2301 a_44123_3750.t5 a_43418_3714.t2 6MSB_0.OUTN.t17 VSS.t1131 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2302 a_5169_17490.t0 a_5079_17394# VSS.t371 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2303 a_41141_9334.t1 a_41115_9239.t3 VDD.t255 VDD.t147 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2304 VSS.t3110 VDD.t1301 a_48348_27219.t0 VSS.t3727 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2305 a_10028_12033.t0 a_9800_11893.t2 a_10219_11816.t0 VSS.t8 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2306 VDD.t62 a_29360_11893.t2 a_29957_12094.t1 VDD.t50 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2307 a_24563_20550.t7 a_24639_20194# a_24729_20290.t4 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2308 a_46919_17714.t2 a_46530_17398.t2 VDD.t1801 VDD.t905 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.4032p ps=2.96u w=1.12u l=0.13u
X2309 VDD.t1079 VDD.t1417 a_27815_14616.t2 VDD.t884 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2310 a_31083_3750.t6 a_30378_3714.t2 6MSB_0.OUTN.t42 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2311 a_13625_6594.t0 a_1253_24711.t4 VSS.t2545 VSS.t2544 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2312 a_34429_3416.t0 a_33879_3714.t3 a_34335_3416.t0 VSS.t1925 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2313 a_16739_17416.t0 VDD.t1365 VSS.t2425 VSS.t3777 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2314 a_31083_6550.t5 a_30378_6514.t2 6MSB_0.OUTN.t37 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2315 a_7799_12114.t0 a_7410_11798.t2 VDD.t788 VDD.t17 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2316 a_4298_14914.t0 a_4081_14894.t2 VSS.t4023 VSS.t4022 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2317 VDD.t471 a_n2042_2484.t13 a_27359_3714.t0 VDD.t295 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2318 VSS.t2715 a_16320_14693.t2 a_16917_14894.t0 VSS.t2713 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2319 VSS.t826 VSS.t824 VSS.t825 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2320 6MSB_0.OUTP.t118 a_42997_894.t2 a_44123_950.t0 VSS.t1164 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2321 a_48323_23895.t0 a_48758_23938.t3 a_48063_24365.t1 VSS.t2975 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2322 a_14319_17714.t2 a_n2648_3264.t15 VDD.t838 VDD.t748 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2323 VSS.t1700 a_42628_6433.t2 a_42306_6293.t1 VSS.t1699 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2324 a_15035_14839.t0 a_15470_14873.t3 a_14775_14616.t3 VSS.t2768 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2325 VDD.t695 a_35880_693.t2 a_36108_833.t1 VDD.t454 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2326 6MSB_0.OUTN.t16 a_43418_3714.t2 a_44123_3750.t4 VSS.t1128 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2327 a_48018_6607.t0 a_47661_6534.t4 VDD.t425 VDD.t0 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2328 a_44289_14690.t1 a_44199_14594# VSS.t2413 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2329 VDD.t722 VDD.t1691 a_47635_839.t2 VDD.t4 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X2330 a_23641_14894.t0 a_22840_14693.t2 VSS.t2700 VSS.t2701 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2331 VDD.t316 a_n2646_2484.t16 a_14319_6514.t0 VDD.t127 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2332 a_37603_950.t2 VSS.t904 VSS.t1070 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X2333 VSS.t651 VSS.t649 VSS.t650 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2334 6MSB_0.OUTP.t54 a_29957_3694.t2 a_31083_3750.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2335 a_5003_6550.t2 VSS.t782 VSS.t784 VSS.t783 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X2336 a_10397_894.t1 a_9800_693.t2 VDD.t635 VDD.t460 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2337 a_1279_914.t2 VDD.t1617 VDD.t614 VDD.t462 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X2338 VSS.t3487 a_50719_3394# a_50809_3490.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2339 a_28101_3734.t0 a_28075_3639.t3 VSS.t1901 VSS.t1900 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2340 VSS.t2790 a_31159_17394# a_31249_17490.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2341 a_44289_11890.t0 a_44199_11794# VSS.t636 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2342 a_34978_9407.t0 a_34621_9334.t4 VDD.t241 VDD.t150 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2343 6MSB_0.OUTN.t36 a_30378_6514.t2 a_31083_6550.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2344 a_3280_6293.t1 a_2430_6473.t2 a_3186_6293.t0 VSS.t1534 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2345 VDD.t564 a_39705_3794.t2 a_40010_3398.t1 VDD.t282 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2346 VSS.t1713 a_43201_6494.t2 a_43418_6514.t0 VSS.t1712 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2347 a_37769_20290.t3 a_37679_20194# VSS.t2346 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2348 a_18043_12150.t7 a_18119_11794# a_18209_11890.t4 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2349 VSS.t3596 a_5079_594# a_5169_690.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2350 VSS.t1913 a_29360_3493.t2 a_29957_3694.t0 VSS.t1911 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2351 VSS.t1749 X10.t4 a_n2852_3612.t0 VSS.t2583 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X2352 a_37603_17750.t3 a_37679_17394# a_37769_17490.t6 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2353 a_31249_690.t2 a_31159_594# VSS.t3499 VSS.t3503 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2354 a_1997_24701.t1 a_1997_24905.t2 VDD.t1162 VDD.t76 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.1918p
+ ps=1.5u w=0.84u l=0.13u
X2355 a_27359_6514.t0 a_n2646_2484.t14 VDD.t311 VDD.t137 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2356 a_21389_616.t0 a_20839_914.t3 a_21295_616.t1 VSS.t2117 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2357 a_16917_9294.t1 a_16320_9093.t2 VDD.t201 VDD.t159 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2358 a_15061_6534.t0 a_15035_6439.t3 VSS.t1587 VSS.t1586 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2359 VSS.t1404 a_30161_9294.t2 a_30378_9314.t0 VSS.t1403 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2360 VSS.t3188 a_890_20198.t2 a_1178_20217.t0 VSS.t3189 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2361 a_28075_3639.t1 a_28510_3673.t3 a_27815_3416.t3 VSS.t1907 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2362 VDD.t1773 a_49608_24288.t2 a_49836_24166.t0 VDD.t760 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2363 a_14319_12114.t2 a_13930_11798.t2 VDD.t1121 VDD.t25 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2364 a_7105_9394.t0 a_2713_24910.t5 VSS.t3060 VSS.t3059 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2365 VDD.t289 VDD.t1521 a_1735_6216.t1 VDD.t143 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2366 a_44123_950.t8 a_44199_594# a_44289_690.t5 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2367 a_42997_3694.t0 a_42400_3493.t2 VSS.t1966 VSS.t1965 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2368 VSS.t3192 a_39705_20594.t2 a_40010_20198.t0 VSS.t3191 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X2369 a_41141_9334.t2 a_41652_9360.t2 a_42400_9093.t1 VSS.t1446 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2370 a_2713_24685.t0 a_2713_24910.t10 VSS.t3005 VSS.t3004 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.14642p ps=1.155u w=0.55u l=0.13u
X2371 VSS.t1236 a_n2042_972.t3 a_39705_6594.t0 VSS.t1235 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2372 a_31249_17490.t1 a_31159_17394# VSS.t2788 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2373 VDD.t38 a_20450_11798.t2 a_20839_12114.t0 VDD.t34 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2374 VDD.t455 a_n2042_2484.t4 a_33279_994.t0 VDD.t454 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2375 a_40010_598.t1 a_39705_994.t2 VDD.t449 VDD.t448 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2376 a_10601_17694.t0 a_9800_17493.t2 VSS.t2319 VSS.t2318 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2377 6MSB_0.OUTP.t50 a_49517_9294.t2 a_50643_9350.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2378 VDD.t587 a_49148_3633.t2 a_49109_3731.t0 VDD.t293 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2379 a_3508_17633.t0 a_3280_17493.t2 a_3699_17416.t0 VSS.t2382 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2380 VSS.t626 VSS.t623 VSS.t626 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2381 a_1178_9017.t1 a_890_8998.t2 VSS.t1233 VSS.t1234 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X2382 VSS.t805 VSS.t780 VSS.t805 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2383 a_29957_6494.t0 a_29360_6293.t2 VSS.t1651 VSS.t1650 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2384 VSS.t1975 a_46225_3794.t2 a_46530_3398.t0 VSS.t1974 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X2385 6MSB_0.OUTN.t74 a_43418_14914.t2 a_44123_14950.t8 VSS.t1128 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2386 a_36108_14833.t1 VDD.t1405 VDD.t1222 VDD.t846 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X2387 a_35880_11893.t0 a_35030_12073.t2 a_34621_12134.t2 VDD.t66 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2388 a_3280_3493.t0 a_2430_3673.t2 a_2021_3734.t2 VDD.t303 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2389 a_5169_9090.t7 a_5079_8994# a_5003_9350.t8 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2390 a_34429_20216.t0 a_33879_20514.t3 a_34335_20216.t0 VSS.t2786 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X2391 VSS.t61 a_26665_12194.t2 a_26970_11798.t0 VSS.t60 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X2392 VDD.t396 a_36108_6433.t2 a_36069_6531.t0 VDD.t135 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2393 a_40399_17714.t0 a_n2648_3264.t11 a_40298_17417.t0 VSS.t3426 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2394 VDD.t861 a_46225_14994.t2 a_46530_14598.t1 VDD.t3 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2395 VDD.t1719 a_29360_20293.t2 a_29957_20494.t1 VDD.t9 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2396 a_31083_9350.t9 a_31159_8994# a_31249_9090.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2397 VSS.t200 VSS.t198 a_51453_23453.t1 VSS.t199 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2398 a_31249_11890.t3 a_31159_11794# VSS.t3581 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2399 a_36681_894.t0 a_35880_693.t2 VSS.t2189 VSS.t2190 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X2400 a_7799_20514.t0 a_7410_20198.t2 VDD.t1041 VDD.t762 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2401 VSS.t3603 a_44199_594# a_44289_690.t0 VSS.t3602 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2402 a_4341_24931.t0 a_4305_24905.t2 VSS.t2532 VSS.t107 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X2403 a_28075_17639.t0 a_28510_17673.t3 a_27815_17416.t1 VSS.t2293 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2404 a_26970_14598.t0 a_26665_14994.t2 VSS.t2707 VSS.t2706 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X2405 VSS.t626 a_11599_11794# a_11689_11890.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2406 VDD.t315 a_13930_6198.t2 a_14319_6514.t2 VDD.t127 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2407 a_21938_1007.t0 a_21581_934.t4 VDD.t662 VDD.t458 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2408 a_44123_6550.t6 a_43418_6514.t2 6MSB_0.OUTN.t12 VSS.t1129 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2409 a_890_3398.t1 a_585_3794.t2 VDD.t304 VDD.t303 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2410 a_47469_6216.t0 a_46919_6514.t3 a_47375_6216.t0 VSS.t1720 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2411 VDD.t992 a_48758_24994.t3 a_48860_25081.t1 VDD.t813 sg13_lv_pmos ad=1.4292p pd=9.04u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X2412 a_31083_12150.t5 a_30378_12114.t2 6MSB_0.OUTN.t69 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2413 a_27815_11816.t2 a_28612_12160.t3 a_28075_12039.t0 VDD.t50 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2414 a_16917_3694.t0 a_16320_3493.t2 VSS.t1858 VSS.t1857 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2415 a_50626_23927.t1 a_50409_23971.t2 VDD.t979 VDD.t760 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X2416 a_50809_17490.t6 a_50719_17394# a_50643_17750.t2 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2417 a_42628_12033.t0 a_42400_11893.t2 a_42819_11816.t0 VSS.t1151 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2418 a_11689_690.t7 a_11599_594# a_11523_950.t8 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2419 a_10028_17633.t0 a_9800_17493.t2 a_10219_17416.t0 VSS.t2317 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2420 VSS.t883 VSS.t881 VSS.t882 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2421 VSS.t4247 a_37679_14594# a_37769_14690.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2422 a_34429_9016.t0 a_33879_9314.t3 a_34335_9016.t0 VSS.t1412 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2423 a_48638_24750.t0 a_48860_25081.t3 a_48323_24960.t1 VSS.t2520 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2424 a_18043_20550.t4 a_18119_20194# a_18209_20290.t6 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2425 VDD.t1035 a_33185_17794.t2 a_33490_17398.t1 VDD.t893 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2426 VSS.t512 VSS.t511 a_37603_14950.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2427 VSS.t2458 a_48920_14693.t2 a_49517_14894.t0 VSS.t2459 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2428 VDD.t155 a_n2042_972.t13 a_27359_9314.t1 VDD.t153 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2429 a_21990_12073.t0 CLK.t36 VSS.t46 VSS.t3621 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2430 6MSB_0.OUTP.t70 a_42997_6494.t2 a_44123_6550.t0 VSS.t1164 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2431 VDD.t1620 VDD.t1617 a_1279_914.t2 VDD.t462 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X2432 a_28390_6229.t0 a_28612_6560.t3 a_28075_6439.t0 VSS.t1640 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2433 VDD.t663 a_23068_833.t2 a_23029_931.t0 VDD.t458 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2434 a_14319_20514.t0 a_13930_20198.t2 VDD.t1016 VDD.t7 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2435 a_7799_12114.t2 a_n2770_240.t16 VDD.t789 VDD.t17 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2436 VSS.t282 VSS.t274 VSS.t281 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2437 a_50643_17750.t2 VSS.t418 VSS.t489 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X2438 VSS.t1708 a_42400_6293.t2 a_42997_6494.t0 VSS.t1706 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2439 a_21581_3734.t0 a_21555_3639.t3 VSS.t1875 VSS.t1874 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2440 a_1178_11817.t2 a_n2770_240.t17 a_1279_12114.t1 VSS.t3382 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2441 a_28101_9334.t0 a_28075_9239.t3 VSS.t1387 VSS.t1386 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2442 VDD.t1082 a_20450_20198.t2 a_20839_20514.t0 VDD.t11 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X2443 a_14775_14616.t2 a_15572_14960.t3 a_15035_14839.t1 VDD.t887 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2444 VDD.t251 a_39705_9394.t2 a_40010_8998.t1 VDD.t147 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2445 VSS.t2893 a_50719_8994# a_50809_9090.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2446 a_44289_17490.t0 a_44199_17394# VSS.t416 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2447 a_13930_11798.t1 a_13625_12194.t2 VDD.t26 VDD.t25 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2448 VDD.t51 a_n2044_1752.t5 a_26759_12194.t0 VDD.t50 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2449 a_31083_12150.t4 a_29957_12094.t2 6MSB_0.OUTP.t78 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2450 VDD.t116 a_48920_11893.t2 a_49148_12033.t1 VDD.t1 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2451 VSS.t1399 a_29360_9093.t2 a_29957_9294.t0 VSS.t1397 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2452 a_29549_6531.t0 a_28612_6560.t2 a_29360_6293.t0 VDD.t137 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2453 a_35880_20293.t1 a_35030_20473.t2 a_34621_20534.t3 VDD.t793 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2454 a_7410_14598.t1 a_7105_14994.t2 VDD.t1141 VDD.t912 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2455 a_10601_14894.t1 a_9800_14693.t2 VDD.t915 VDD.t912 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2456 VSS.t1766 VDD.t1569 a_1829_3416.t0 VSS.t3912 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2457 a_27359_6514.t2 a_26970_6198.t2 VDD.t376 VDD.t137 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2458 a_46919_12114.t0 a_46530_11798.t2 VDD.t110 VDD.t1 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2459 a_28075_9239.t0 a_28510_9273.t3 a_27815_9016.t3 VSS.t1393 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2460 VDD.t611 X10.t0 a_n2966_249.t1 VDD.t610 sg13_lv_pmos ad=0.2086p pd=1.5u as=0.34p ps=2.68u w=1u
+ l=0.13u
X2461 a_n2347_1368.t0 X10.t1 VSS.t2587 VSS.t2586 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X2462 a_43418_14914.t0 a_43201_14894.t2 VSS.t2646 VSS.t2645 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2463 a_48070_873.t0 CLK.t0 VSS.t2238 VSS.t3691 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2464 6MSB_0.OUTN.t57 a_36898_14914.t2 a_37603_14950.t6 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2465 a_42997_9294.t0 a_42400_9093.t2 VSS.t1452 VSS.t1451 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2466 VSS.t1775 a_n2042_2484.t8 a_7105_994.t0 VSS.t1774 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2467 VSS.t550 a_24639_14594# a_24729_14690.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2468 a_41367_6229.t0 VDD.t1557 VSS.t3906 VSS.t3905 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2469 VDD.t980 a_50409_23971.t2 a_50626_23927.t1 VDD.t760 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X2470 a_21581_12134.t0 a_21555_12039.t3 VSS.t40 VSS.t39 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X2471 a_42400_693.t1 a_41550_873.t2 a_42306_693.t0 VSS.t2206 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2472 a_1279_20514.t1 a_n2044_4040.t16 a_1178_20217.t1 VSS.t3550 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2473 VSS.t2057 a_7105_994.t2 a_7410_598.t0 VSS.t2056 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X2474 VDD.t570 a_42628_3633.t2 a_42589_3731.t0 VDD.t282 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2475 a_14319_12114.t1 a_n2770_240.t15 VDD.t1114 VDD.t25 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2476 VDD.t272 a_49148_9233.t2 a_49109_9331.t0 VDD.t2 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2477 VSS.t386 VSS.t309 VSS.t386 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2478 VSS.t3558 a_24639_11794# a_24729_11890.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2479 a_48018_1007.t0 a_47661_934.t4 VDD.t722 VDD.t4 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2480 a_3280_9093.t0 a_2430_9273.t2 a_2021_9334.t3 VDD.t122 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2481 a_27815_20216.t1 a_28612_20560.t3 a_28075_20439.t0 VDD.t9 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2482 VSS.t3415 a_26665_17794.t2 a_26970_17398.t0 VSS.t3414 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X2483 a_14775_17416.t2 a_14319_17714.t3 VDD.t822 VDD.t748 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2484 a_n2946_1036.t1 X8.t0 VDD.t740 VDD.t597 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p ps=2.36u
+ w=0.84u l=0.13u
X2485 VSS.t880 a_24639_3394# a_24729_3490.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2486 a_28101_20534.t1 a_28612_20560.t2 a_29360_20293.t0 VSS.t2955 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2487 VSS.t2629 a_40010_20198.t2 a_40298_20217.t0 VSS.t2628 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2488 a_35030_14873.t0 CLK.t42 VSS.t3653 VSS.t3652 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2489 a_37603_12150.t3 a_37679_11794# a_37769_11890.t4 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2490 a_20450_8998.t0 a_20145_9394.t2 VSS.t1350 VSS.t1349 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X2491 a_31249_17490.t3 a_31159_17394# VSS.t2792 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2492 a_23858_914.t1 a_23641_894.t2 VDD.t669 VDD.t458 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X2493 VSS.t386 a_11599_17394# a_11689_17490.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2494 a_31083_14950.t1 a_29957_14894.t2 6MSB_0.OUTP.t11 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2495 a_34978_17807.t0 a_34621_17734.t4 VDD.t1070 VDD.t893 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2496 a_42997_14894.t0 a_42400_14693.t2 VSS.t2661 VSS.t2660 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2497 VSS.t18 a_n2044_1752.t7 a_13625_12194.t0 VSS.t2816 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2498 a_16548_6433.t0 a_16320_6293.t2 a_16739_6216.t0 VSS.t1596 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2499 a_40949_6216.t0 a_40399_6514.t3 a_40855_6216.t0 VSS.t1693 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2500 a_50809_690.t6 a_50719_594# a_50643_950.t9 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2501 a_7105_3794.t0 a_2713_24910.t3 VSS.t2993 VSS.t2992 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2502 6MSB_0.OUTP.t60 a_10397_20494.t2 a_11523_20550.t0 VSS.t4127 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2503 a_8830_14629.t1 a_8541_14934.t4 a_8767_14629.t0 VSS.t4009 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2504 a_28101_14934.t2 a_28075_14839.t3 VDD.t1079 VDD.t884 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X2505 a_890_8998.t1 a_585_9394.t2 VDD.t130 VDD.t122 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2506 a_7799_20514.t2 a_n2044_4040.t15 VDD.t1042 VDD.t762 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2507 a_31083_17750.t6 a_30378_17714.t2 6MSB_0.OUTN.t49 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2508 a_16917_9294.t0 a_16320_9093.t2 VSS.t1346 VSS.t1345 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2509 a_15350_629.t1 a_15061_934.t4 a_15287_629.t0 VSS.t2093 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2510 6MSB_0.OUTP.t68 a_50817_27517.t2 a_51442_27857.t3 VSS.t3074 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2511 a_42628_17633.t1 a_42400_17493.t2 a_42819_17416.t0 VSS.t3250 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2512 a_24729_3490.t7 a_24639_3394# a_24563_3750.t8 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2513 a_51683_26669.t3 4LSB_weighted_0.VBIAS a_51440_26253.t5 VSS.t4062 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X2514 VSS.t734 VSS.t732 VSS.t733 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2515 a_8950_6473.t0 CLK.t22 VSS.t1567 VSS.t3669 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2516 6MSB_0.OUTP.t6 a_49517_3694.t2 a_50643_3750.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2517 a_23641_17694.t1 a_22840_17493.t2 VDD.t1129 VDD.t737 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2518 VDD.t353 a_16320_6293.t2 a_16548_6433.t1 VDD.t127 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2519 a_33778_11817.t1 a_33490_11798.t2 VSS.t95 VSS.t96 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X2520 a_7698_617.t1 a_7410_598.t2 VSS.t2059 VSS.t2060 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X2521 a_n2648_1016.t0 a_n2946_1036.t2 VSS.t2015 VSS.t2014 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.1331p ps=1.12u w=0.74u l=0.13u
X2522 6MSB_0.OUTP.t23 a_23437_20494.t2 a_24563_20550.t5 VSS.t2568 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2523 a_13930_20198.t1 a_13625_20594.t2 VDD.t8 VDD.t7 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2524 VDD.t10 VSS.t271 a_26759_20594.t0 VDD.t9 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X2525 a_46818_3417.t1 a_n2042_2484.t10 a_46919_3714.t0 VSS.t1779 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2526 a_44289_3490.t0 a_44199_3394# VSS.t977 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2527 a_2713_24910.t0 a_2713_25289.t2 VSS.t3471 VSS.t3470 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X2528 a_5169_20290.t0 a_5079_20194# VSS.t113 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2529 a_21990_17673.t0 CLK.t52 VSS.t3645 VSS.t3644 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2530 a_50643_12150.t1 a_49517_12094.t2 6MSB_0.OUTP.t99 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2531 a_5003_17750.t7 a_5079_17394# a_5169_17490.t4 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2532 a_5003_14950.t8 a_4298_14914.t2 6MSB_0.OUTN.t58 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2533 a_34621_14934.t2 a_34595_14839.t3 VSS.t3708 VSS.t4196 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2534 a_31249_6290.t0 a_31159_6194# VSS.t848 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2535 a_2021_14934.t3 a_2532_14960.t2 a_3280_14693.t1 VSS.t2855 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2536 a_24563_12150.t6 a_23858_12114.t2 6MSB_0.OUTN.t76 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2537 a_48949_26480.t1 CLK.t65 VDD.t981 VDD.t13 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.4292p ps=9.04u
+ w=1.12u l=0.13u
X2538 a_16739_20216.t0 VDD.t1333 VSS.t2919 VSS.t3755 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2539 6MSB_0.OUTP.t29 a_29957_9294.t2 a_31083_9350.t6 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2540 a_8541_6534.t1 a_8515_6439.t3 VDD.t334 VDD.t141 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2541 a_1178_17417.t2 a_n2648_3264.t17 a_1279_17714.t2 VSS.t3439 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2542 VSS.t4250 a_37679_14594# a_37769_14690.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2543 a_21581_9334.t0 a_21555_9239.t3 VSS.t1359 VSS.t1358 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2544 a_33879_3714.t2 a_33490_3398.t2 VDD.t550 VDD.t290 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2545 VSS.t3021 a_11599_3394# a_11689_3490.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2546 a_15350_14629.t1 a_15061_14934.t4 a_15287_14629.t0 VSS.t2765 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2547 a_14319_20514.t2 a_n2044_4040.t14 VDD.t1017 VDD.t7 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2548 a_1279_17714.t0 a_890_17398.t2 VDD.t1094 VDD.t752 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2549 a_20738_14617.t2 a_n2044_1752.t14 a_20839_14914.t2 VSS.t2828 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2550 a_8541_934.t0 a_8515_839.t3 VSS.t2064 VSS.t2063 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X2551 a_31083_17750.t4 a_29957_17694.t2 6MSB_0.OUTP.t130 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2552 VSS.t1245 VDD.t1473 a_1829_9016.t0 VSS.t3848 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2553 VDD.t735 a_28510_17673.t3 a_28612_17760.t1 VDD.t733 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X2554 a_50809_11890.t6 a_50719_11794# a_50643_12150.t2 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2555 a_20839_6514.t2 a_20450_6198.t2 VDD.t361 VDD.t139 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2556 a_18043_950.t9 a_18119_594# a_18209_690.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2557 a_33279_3794.t0 a_3545_25331.t3 a_33185_3794.t1 VDD.t290 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2558 a_50643_17750.t5 a_50719_17394# a_50809_17490.t7 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2559 a_28075_839.t0 a_28510_873.t3 a_27815_616.t3 VSS.t2152 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X2560 a_37603_3750.t2 VSS.t886 VSS.t971 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X2561 VSS.t4223 a_31159_20194# a_31249_20290.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2562 VDD.t68 a_33185_12194.t2 a_33490_11798.t1 VDD.t66 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2563 VDD.t600 a_n2646_1728.t2 a_n2342_2100.t0 VDD.t597 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2564 a_51683_26669.t1 4LSB_weighted_0.VBIAS VSS.t4060 VSS.t4062 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X2565 a_37769_14690.t2 a_37679_14594# VSS.t4249 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2566 a_49988_27534.t0 a_49051_27563.t2 a_49799_27296.t0 VDD.t14 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2567 a_48638_24750.t1 a_48349_25055.t4 a_48575_24750.t0 VSS.t2402 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2568 a_37603_20550.t3 a_37679_20194# a_37769_20290.t4 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2569 a_21581_17734.t0 a_21555_17639.t3 VSS.t3084 VSS.t3083 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2570 a_31249_17490.t7 a_31159_17394# a_31083_17750.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2571 VSS.t2707 a_n2648_3264.t5 a_26665_14994.t0 VSS.t3418 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2572 a_4298_914.t0 a_4081_894.t2 VSS.t2052 VSS.t2051 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2573 VDD.t596 a_n2347_2880.t2 a_n2042_2484.t1 VDD.t286 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2574 a_2713_24910.t1 a_2713_25289.t2 VDD.t1164 VDD.t71 sg13_lv_pmos ad=0.252p pd=1.57u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X2575 a_11523_14950.t9 a_10818_14914.t2 6MSB_0.OUTN.t52 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2576 a_20239_6594.t0 a_521_25453.t4 a_20145_6594.t1 VDD.t139 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2577 VDD.t715 a_43201_894.t2 a_43418_914.t1 VDD.t448 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X2578 a_5003_14950.t0 VSS.t495 VSS.t496 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2579 VDD.t257 a_42628_9233.t2 a_42589_9331.t0 VDD.t147 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X2580 a_39705_994.t0 a_4321_24727.t2 VSS.t2808 VSS.t2807 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2581 VSS.t3301 a_24639_17394# a_24729_17490.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2582 a_34910_11829.t1 a_34621_12134.t4 a_34847_11829.t0 VSS.t1100 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2583 a_29588_6433.t0 VDD.t1549 VDD.t381 VDD.t137 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X2584 VSS.t833 a_37679_6194# a_37769_6290.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2585 a_40298_11817.t2 a_n2770_240.t11 a_40399_12114.t2 VSS.t3370 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2586 a_50643_12150.t2 VSS.t642 VSS.t669 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X2587 a_15350_3429.t1 a_15061_3734.t4 a_15287_3429.t0 VSS.t1848 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2588 a_51453_23453.t6 4LSB_weighted_0.VBIAS a_51517_23976.t5 VSS.t4076 sg13_hv_nmos ad=0.114p
+ pd=0.98u as=0.114p ps=0.98u w=0.6u l=0.48u
X2589 a_21990_14873.t1 CLK.t44 VDD.t877 VDD.t736 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2590 VDD.t946 a_n2044_1752.t13 a_27359_14914.t1 VDD.t884 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2591 VDD.t553 VDD.t1599 a_34335_3416.t1 VDD.t290 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2592 a_31249_20290.t1 a_31159_20194# VSS.t4220 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2593 a_50809_17490.t7 a_50719_17394# a_50643_17750.t4 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2594 a_8767_14629.t0 VDD.t1399 VSS.t3718 VSS.t3717 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2595 a_16917_14894.t0 a_16320_14693.t2 VSS.t2714 VSS.t2713 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2596 VSS.t731 a_24639_8994# a_24729_9090.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2597 VSS.t2639 a_18119_594# a_18209_690.t1 VSS.t2638 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2598 a_10601_20494.t0 a_9800_20293.t2 VSS.t4301 VSS.t4302 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2599 a_28390_11829.t0 a_28612_12160.t3 a_28075_12039.t1 VSS.t65 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2600 a_28327_11829.t0 VDD.t1449 VSS.t3835 VSS.t3834 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2601 a_31249_690.t1 a_31159_594# VSS.t3496 VSS.t3497 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2602 VSS.t2658 a_41550_14873.t3 a_41652_14960.t0 VSS.t2657 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2603 a_3508_20433.t0 a_3280_20293.t2 a_3699_20216.t0 VSS.t3181 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2604 a_8541_6534.t3 a_9052_6560.t2 a_9800_6293.t1 VSS.t1564 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2605 a_49109_931.t0 a_48172_960.t2 a_48920_693.t0 VDD.t4 sg13_lv_pmos ad=52.5f pd=0.67u as=0.19115p
+ ps=1.565u w=0.42u l=0.13u
X2606 VSS.t975 VSS.t972 VSS.t975 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2607 a_37769_6290.t7 a_37679_6194# a_37603_6550.t8 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2608 a_40399_20514.t2 a_n2044_4040.t10 a_40298_20217.t1 VSS.t3538 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X2609 VSS.t2328 a_n2044_4040.t7 a_13625_17794.t0 VSS.t4154 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2610 VDD.t907 a_48920_17493.t2 a_49517_17694.t1 VDD.t905 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2611 a_18043_3750.t3 a_18119_3394# a_18209_3490.t6 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2612 a_15470_3673.t1 CLK.t13 VDD.t510 VDD.t299 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2613 VSS.t1079 a_44199_594# a_44289_690.t3 VSS.t3611 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2614 a_24729_9090.t7 a_24639_8994# a_24563_9350.t8 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2615 a_28075_20439.t1 a_28510_20473.t3 a_27815_20216.t0 VSS.t2956 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2616 a_18209_14690.t4 a_18119_14594# a_18043_14950.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2617 a_33778_17417.t1 a_33490_17398.t2 VSS.t3205 VSS.t3206 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2618 a_7199_17794.t0 a_2713_24910.t8 a_7105_17794.t1 VDD.t741 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2619 a_15350_14629.t0 a_15572_14960.t3 a_15035_14839.t0 VSS.t2762 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2620 a_44289_9090.t0 a_44199_8994# VSS.t743 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2621 a_46818_9017.t1 a_n2042_972.t10 a_46919_9314.t0 VSS.t1261 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2622 a_21295_6216.t1 a_20839_6514.t3 VDD.t363 VDD.t139 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2623 VDD.t637 a_9800_693.t2 a_10397_894.t1 VDD.t460 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2624 a_15287_14629.t0 VDD.t1393 VSS.t3805 VSS.t3804 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2625 a_13930_598.t0 a_13625_994.t2 VSS.t1755 VSS.t2083 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X2626 a_50809_6290.t6 a_50719_6194# a_50643_6550.t9 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2627 a_50643_17750.t1 a_49517_17694.t2 6MSB_0.OUTP.t5 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2628 a_14775_11816.t1 a_14319_12114.t3 VDD.t1123 VDD.t25 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2629 VSS.t2156 a_29588_833.t2 a_29266_693.t1 VSS.t2155 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2630 a_46919_6514.t2 a_46530_6198.t2 VDD.t421 VDD.t0 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2631 a_10028_20433.t1 a_9800_20293.t2 a_10219_20216.t0 VSS.t4298 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2632 a_17338_17714.t1 a_17121_17694.t2 VDD.t967 VDD.t748 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X2633 a_20450_3398.t0 a_20145_3794.t2 VSS.t1511 VSS.t1865 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X2634 a_24563_17750.t9 a_23858_17714.t2 6MSB_0.OUTN.t124 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2635 a_3877_6494.t1 a_3280_6293.t2 VDD.t323 VDD.t143 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2636 a_2021_3734.t0 a_1995_3639.t3 VSS.t1766 VSS.t1765 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X2637 VDD.t1714 a_33185_20594.t2 a_33490_20198.t1 VDD.t793 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2638 a_47950_14629.t0 a_47661_14934.t4 a_47887_14629.t0 VSS.t2251 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2639 VSS.t1855 a_15470_3673.t3 a_15572_3760.t0 VSS.t1854 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2640 VSS.t4269 a_11599_8994# a_11689_9090.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2641 a_33879_9314.t2 a_33490_8998.t2 VDD.t237 VDD.t150 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2642 VDD.t1001 a_1201_24685.t2 a_1253_24711.t1 VDD.t76 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2643 a_34978_12207.t0 a_34621_12134.t4 VDD.t82 VDD.t66 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2644 a_5003_6550.t8 a_5079_6194# a_5169_6290.t5 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2645 a_7799_914.t0 a_7410_598.t2 VDD.t628 VDD.t460 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2646 a_15035_3639.t1 a_15470_3673.t3 a_15418_3807.t0 VDD.t299 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2647 a_21555_14839.t0 a_21990_14873.t3 a_21938_15007.t0 VDD.t736 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2648 a_28390_629.t0 a_28612_960.t3 a_28075_839.t0 VSS.t2146 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X2649 a_46319_6594.t0 VSS.t867 a_46225_6594.t1 VDD.t0 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X2650 a_35030_17673.t1 CLK.t50 VDD.t898 VDD.t893 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2651 a_34847_629.t0 VDD.t1667 VSS.t3978 VSS.t3977 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2652 a_50626_25035.t0 a_50409_25015.t2 VSS.t2683 VSS.t2682 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2653 VSS.t1195 a_49721_12094.t2 a_49938_12114.t0 VSS.t1194 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2654 a_34910_629.t1 a_34621_934.t4 a_34847_629.t0 VSS.t2177 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2655 a_1279_17714.t1 a_n2648_3264.t17 VDD.t1095 VDD.t752 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2656 VSS.t4019 a_3280_14693.t2 a_3877_14894.t0 VSS.t4018 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2657 a_33279_9394.t0 a_3545_25331.t5 a_33185_9394.t1 VDD.t150 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2658 a_20839_14914.t1 a_n2044_1752.t14 VDD.t902 VDD.t736 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2659 a_23641_12094.t1 a_22840_11893.t2 VDD.t46 VDD.t34 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2660 a_44289_20290.t0 a_44199_20194# VSS.t320 VSS.t3154 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2661 a_1995_14839.t1 a_2430_14873.t3 a_1735_14616.t2 VSS.t2856 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2662 a_36898_14914.t1 a_36681_14894.t2 VDD.t851 VDD.t846 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X2663 a_37603_9350.t2 VSS.t739 VSS.t750 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X2664 6MSB_0.OUTN.t91 a_17338_9314.t2 a_18043_9350.t6 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2665 a_5169_690.t5 a_5079_594# a_5003_950.t7 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2666 VDD.t587 a_48070_3673.t3 a_48172_3760.t1 VDD.t293 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2667 a_18209_3490.t3 a_18119_3394# VSS.t2397 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2668 a_44123_17750.t4 a_44199_17394# a_44289_17490.t6 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2669 a_44123_14950.t9 a_43418_14914.t2 6MSB_0.OUTN.t74 VSS.t1129 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2670 a_3469_931.t0 a_2532_960.t2 a_3280_693.t0 VDD.t462 sg13_lv_pmos ad=52.5f pd=0.67u as=0.19115p
+ ps=1.565u w=0.42u l=0.13u
X2671 VDD.t969 a_n2044_4040.t6 a_20239_17794.t0 VDD.t737 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X2672 a_18209_6290.t5 a_18119_6194# a_18043_6550.t7 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2673 VDD.t1640 VDD.t1637 a_14319_914.t2 VDD.t444 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X2674 6MSB_0.OUTP.t119 a_42997_894.t2 a_44123_950.t5 VSS.t1166 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2675 a_48540_27537.t1 a_48514_27442.t3 VDD.t1014 VDD.t14 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2676 a_24729_17490.t6 a_24639_17394# a_24563_17750.t6 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2677 a_41141_14934.t1 a_41652_14960.t2 a_42400_14693.t0 VSS.t2655 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2678 VDD.t330 a_7105_6594.t2 a_7410_6198.t1 VDD.t141 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2679 a_28390_6229.t1 a_28101_6534.t4 a_28327_6229.t0 VSS.t1643 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2680 a_n2253_2880.t0 X8.t2 a_n2347_2880.t1 VDD.t286 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X2681 VDD.t424 VDD.t1563 a_47375_6216.t1 VDD.t0 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2682 a_34910_17429.t1 a_34621_17734.t4 a_34847_17429.t0 VSS.t3274 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2683 a_5003_12150.t7 a_5079_11794# a_5169_11890.t5 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2684 VSS.t1106 a_36108_12033.t2 a_35786_11893.t1 VSS.t1105 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2685 a_40298_17417.t1 a_n2648_3264.t11 a_40399_17714.t0 VSS.t3427 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2686 a_36477_14894.t1 a_35880_14693.t2 VDD.t847 VDD.t846 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2687 a_40399_17714.t2 a_40010_17398.t2 VDD.t1729 VDD.t812 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.4032p ps=2.96u w=1.12u l=0.13u
X2688 VDD.t904 VDD.t1409 a_21295_14616.t1 VDD.t736 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2689 a_40298_3417.t0 a_40010_3398.t2 VSS.t1950 VSS.t1949 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2690 VDD.t447 a_890_3398.t2 a_1279_3714.t0 VDD.t303 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2691 6MSB_0.OUTP.t55 a_29957_3694.t2 a_31083_3750.t5 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2692 a_15350_9029.t1 a_15061_9334.t4 a_15287_9029.t0 VSS.t1337 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2693 VDD.t240 VDD.t1503 a_34335_9016.t1 VDD.t150 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2694 VSS.t1875 VDD.t1587 a_21389_3416.t0 VSS.t3926 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2695 VDD.t968 a_17121_17694.t2 a_17338_17714.t1 VDD.t748 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X2696 VSS.t1491 a_585_6594.t2 a_890_6198.t0 VSS.t1490 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X2697 a_44289_3490.t7 a_44199_3394# a_44123_3750.t8 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2698 a_28390_17429.t0 a_28612_17760.t3 a_28075_17639.t0 VSS.t2289 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2699 a_28327_17429.t0 VDD.t1379 VSS.t3787 VSS.t3786 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2700 a_1279_12114.t0 a_890_11798.t2 VDD.t874 VDD.t765 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2701 a_18043_9350.t4 a_16917_9294.t2 6MSB_0.OUTP.t36 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2702 VSS.t258 VSS.t245 VSS.t258 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2703 VSS.t555 VSS.t554 VSS.t555 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2704 a_20145_9394.t0 a_521_25453.t5 VSS.t2301 VSS.t2300 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2705 VSS.t2729 a_20450_14598.t2 a_20738_14617.t0 VSS.t2728 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X2706 a_8767_3429.t0 VDD.t1575 VSS.t3918 VSS.t3917 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2707 a_50205_25015.t0 a_49608_24814.t2 VSS.t4309 VSS.t4277 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2708 VSS.t3325 VDD.t1417 a_27909_14616.t0 VSS.t3803 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2709 VDD.t58 a_28510_12073.t3 a_28612_12160.t1 VDD.t50 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2710 VSS.t752 VSS.t747 VSS.t752 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2711 a_28510_6473.t1 CLK.t19 VDD.t381 VDD.t137 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2712 a_31249_6290.t7 a_31159_6194# a_31083_6550.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2713 VSS.t2548 a_26665_20594.t2 a_26970_20198.t0 VSS.t2547 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X2714 VDD.t672 a_26665_994.t2 a_26970_598.t1 VDD.t456 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2715 a_50643_12150.t5 a_50719_11794# a_50809_11890.t7 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2716 a_27815_6216.t3 a_28612_6560.t3 a_28075_6439.t1 VDD.t137 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2717 a_11523_3750.t3 a_11599_3394# a_11689_3490.t6 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2718 a_14775_20216.t2 a_14319_20514.t3 VDD.t1738 VDD.t7 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2719 a_44123_14950.t0 VSS.t513 VSS.t515 VSS.t514 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2720 a_15470_9273.t1 CLK.t29 VDD.t199 VDD.t159 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2721 a_18043_9350.t3 a_18119_8994# a_18209_9090.t6 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2722 a_31249_11890.t7 a_31159_11794# a_31083_12150.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2723 a_50809_3490.t5 a_50719_3394# a_50643_3750.t7 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2724 a_31249_20290.t3 a_31159_20194# VSS.t4219 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2725 6MSB_0.OUTP.t51 a_49517_9294.t2 a_50643_9350.t2 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2726 6MSB_0.OUTP.t105 a_16917_894.t2 a_18043_950.t5 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2727 VSS.t258 a_11599_20194# a_11689_20290.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2728 a_31083_17750.t3 a_31159_17394# a_31249_17490.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2729 VDD.t852 a_36681_14894.t2 a_36898_14914.t1 VDD.t846 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X2730 a_34978_20607.t0 a_34621_20534.t4 VDD.t820 VDD.t793 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X2731 a_47635_17639.t1 a_48070_17673.t3 a_48018_17807.t0 VDD.t905 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2732 a_47887_14629.t0 VDD.t1271 VSS.t3820 VSS.t3819 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2733 a_33490_6198.t0 a_33185_6594.t2 VSS.t1251 VSS.t1660 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X2734 a_24729_690.t4 a_24639_594# a_24563_950.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2735 a_31083_20550.t6 a_30378_20514.t2 6MSB_0.OUTN.t103 VSS.t2887 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2736 VDD.t984 a_29360_14693.t2 a_29588_14833.t1 VDD.t884 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2737 a_42628_20433.t0 a_42400_20293.t2 a_42819_20216.t0 VSS.t2487 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2738 a_49938_17714.t1 a_49721_17694.t2 VDD.t910 VDD.t905 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X2739 VSS.t1648 a_28510_6473.t3 a_28612_6560.t0 VSS.t1647 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2740 a_35880_14693.t1 a_35030_14873.t2 a_35786_14693.t0 VSS.t4199 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X2741 a_8349_11816.t0 a_7799_12114.t3 a_8255_11816.t0 VSS.t2469 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2742 a_50809_11890.t7 a_50719_11794# a_50643_12150.t4 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2743 a_11689_14690.t4 a_11599_14594# a_11523_14950.t6 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2744 a_521_25453.t0 a_485_25427.t2 VSS.t3050 VSS.t3049 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2745 a_23641_20494.t1 a_22840_20293.t2 VDD.t1763 VDD.t11 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2746 a_2021_9334.t0 a_1995_9239.t3 VSS.t1245 VSS.t1244 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X2747 VSS.t1343 a_15470_9273.t3 a_15572_9360.t0 VSS.t1342 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2748 a_15061_3734.t2 a_15572_3760.t2 a_16320_3493.t1 VSS.t1852 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2749 a_521_25453.t1 a_485_25427.t2 VDD.t1004 VDD.t73 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.7336p
+ ps=3.55u w=1.12u l=0.13u
X2750 VSS.t2455 a_49148_14833.t2 a_48826_14693.t1 VSS.t2454 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2751 a_37603_950.t9 a_37679_594# a_37769_690.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2752 a_21990_20473.t0 CLK.t59 VSS.t3118 VSS.t3641 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2753 a_18043_12150.t5 a_17338_12114.t2 6MSB_0.OUTN.t83 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2754 a_15035_9239.t1 a_15470_9273.t3 a_15418_9407.t0 VDD.t159 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2755 a_50809_690.t7 a_50719_594# a_50643_950.t8 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2756 VDD.t118 a_48920_11893.t2 a_49517_12094.t1 VDD.t1 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2757 VDD.t1037 VDD.t1375 a_34335_17416.t3 VDD.t893 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2758 a_37769_17490.t4 a_37679_17394# a_37603_17750.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2759 a_50643_14950.t3 a_50719_14594# a_50809_14690.t4 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2760 a_5003_20550.t4 a_5079_20194# a_5169_20290.t6 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2761 VDD.t1749 a_39705_14994.t2 a_40010_14598.t1 VDD.t810 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X2762 VSS.t2176 VDD.t1667 a_34429_616.t0 VSS.t3976 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2763 a_42400_6293.t1 a_41550_6473.t2 a_42306_6293.t0 VSS.t1698 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2764 a_2381_24931.t0 a_1997_24905.t2 VSS.t3468 VSS.t3467 sg13_lv_nmos ad=0.1216p pd=1.02u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2765 VSS.t2743 a_49721_17694.t2 a_49938_17714.t0 VSS.t2742 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2766 a_24729_3490.t5 a_24639_3394# a_24563_3750.t7 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2767 VSS.t1745 a_n2648_4040.t2 a_n2248_4060.t0 VSS.t1744 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1216p ps=1.02u w=0.64u l=0.13u
X2768 VDD.t963 a_16320_17493.t2 a_16548_17633.t1 VDD.t748 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2769 a_46319_17794.t0 VSS.t492 a_46225_17794.t1 VDD.t905 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2770 a_34910_3429.t1 a_34621_3734.t4 a_34847_3429.t0 VSS.t1929 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2771 a_49836_24166.t1 a_49608_24288.t2 a_50027_24365.t0 VSS.t4274 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2772 a_1178_20217.t2 a_n2044_4040.t16 a_1279_20514.t1 VSS.t3551 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2773 a_n2646_2484.t1 a_n2951_2880.t2 VDD.t580 VDD.t286 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X2774 a_1279_20514.t0 a_890_20198.t2 VDD.t1028 VDD.t5 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2775 a_20450_14598.t0 a_20145_14994.t2 VSS.t3175 VSS.t3174 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X2776 a_7199_12194.t0 a_2713_24910.t6 a_7105_12194.t1 VDD.t17 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2777 VDD.t272 a_48070_9273.t3 a_48172_9360.t1 VDD.t2 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2778 a_31083_20550.t4 a_29957_20494.t2 6MSB_0.OUTP.t122 VSS.t3460 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2779 a_18209_9090.t3 a_18119_8994# VSS.t3510 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2780 a_46225_9394.t0 VSS.t759 VSS.t761 VSS.t760 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X2781 a_11689_6290.t5 a_11599_6194# a_11523_6550.t7 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2782 6MSB_0.OUTP.t71 a_42997_6494.t2 a_44123_6550.t5 VSS.t1166 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2783 a_21870_6229.t1 a_21581_6534.t4 a_21807_6229.t0 VSS.t1615 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2784 VDD.t1733 a_49799_27296.t2 a_50027_27436.t0 VDD.t14 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2785 VDD.t989 a_28510_20473.t3 a_28612_20560.t1 VDD.t9 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2786 a_1735_14616.t3 a_2532_14960.t3 a_1995_14839.t0 VDD.t817 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2787 VSS.t1668 VDD.t1551 a_34429_6216.t0 VSS.t3900 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2788 a_23641_3694.t1 a_22840_3493.t2 VDD.t528 VDD.t297 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2789 VSS.t2723 a_36108_17633.t2 a_35786_17493.t0 VSS.t2722 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2790 a_17338_12114.t1 a_17121_12094.t2 VDD.t32 VDD.t25 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X2791 a_50809_690.t1 a_50719_594# VSS.t3993 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2792 VSS.t4027 a_31159_14594# a_31249_14690.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2793 VDD.t124 a_890_8998.t2 a_1279_9314.t0 VDD.t122 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2794 a_40298_9017.t0 a_40010_8998.t2 VSS.t1438 VSS.t1439 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2795 a_31249_20290.t6 a_31159_20194# a_31083_20550.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2796 a_18043_12150.t4 a_16917_12094.t2 6MSB_0.OUTP.t86 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2797 VSS.t1359 VDD.t1491 a_21389_9016.t0 VSS.t3860 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X2798 a_42400_3493.t0 a_41550_3673.t2 a_41141_3734.t3 VDD.t282 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2799 VSS.t859 VSS.t856 VSS.t859 VSS.t130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X2800 a_21581_20534.t2 a_21555_20439.t3 VSS.t3314 VSS.t3313 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X2801 a_44289_9090.t7 a_44199_8994# a_44123_9350.t8 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2802 a_3508_3633.t0 a_3280_3493.t2 a_3699_3416.t0 VSS.t1801 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2803 VSS.t473 VSS.t472 a_31083_14950.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2804 a_11689_14690.t1 a_11599_14594# VSS.t3027 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2805 a_11523_9350.t4 a_10397_9294.t2 6MSB_0.OUTP.t102 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2806 VSS.t2581 a_50600_26513.t2 a_50817_26469.t0 VSS.t3 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X2807 a_44123_17750.t6 a_44199_17394# a_44289_17490.t5 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2808 VSS.t2662 a_42400_14693.t2 a_42997_14894.t0 VSS.t2660 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X2809 a_3877_6494.t0 a_3280_6293.t2 VSS.t1543 VSS.t1542 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2810 a_49517_894.t0 a_48920_693.t2 VSS.t2243 VSS.t2242 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2811 VSS.t1905 a_29588_3633.t2 a_29266_3493.t1 VSS.t1904 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2812 VSS.t3150 a_24639_20194# a_24729_20290.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2813 a_40399_17714.t1 a_n2648_3264.t11 VDD.t1145 VDD.t812 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2184p ps=1.51u w=1.12u l=0.13u
X2814 a_35030_12073.t1 CLK.t34 VDD.t83 VDD.t66 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X2815 a_8767_9029.t0 VDD.t1479 VSS.t3853 VSS.t3852 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2816 a_21990_6473.t1 CLK.t20 VDD.t366 VDD.t139 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2817 a_48758_23938.t1 CLK.t63 VDD.t1161 VDD.t760 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.4292p
+ ps=9.04u w=1.12u l=0.13u
X2818 a_24729_17490.t4 a_24639_17394# a_24563_17750.t8 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2819 a_41115_14839.t1 a_41550_14873.t3 a_40855_14616.t0 VSS.t2656 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X2820 a_11689_11890.t0 a_11599_11794# VSS.t621 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2821 a_1279_12114.t2 a_n2770_240.t17 VDD.t875 VDD.t765 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2822 VDD.t483 a_3280_3493.t2 a_3508_3633.t1 VDD.t303 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2823 VSS.t1591 a_16548_6433.t2 a_16226_6293.t1 VSS.t1590 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2824 a_11523_9350.t3 a_11599_8994# a_11689_9090.t6 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2825 VDD.t682 a_29360_693.t2 a_29957_894.t1 VDD.t456 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2826 a_44123_6550.t9 a_44199_6194# a_44289_6290.t7 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2827 VDD.t1050 VDD.t1311 a_48254_26907.t3 VDD.t13 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2828 a_44123_12150.t6 a_44199_11794# a_44289_11890.t7 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2829 6MSB_0.OUTN.t127 a_17338_3714.t2 a_18043_3750.t6 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2830 VDD.t35 a_n2044_1752.t6 a_20239_12194.t0 VDD.t34 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2831 VSS.t3445 a_50719_11794# a_50809_11890.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2832 a_50809_9090.t5 a_50719_8994# a_50643_9350.t7 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2833 6MSB_0.OUTP.t45 a_16917_6494.t2 a_18043_6550.t5 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2834 VDD.t339 a_9800_6293.t2 a_10397_6494.t1 VDD.t141 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2835 VSS.t2154 a_28510_873.t3 a_28612_960.t0 VSS.t2153 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2836 a_24729_11890.t6 a_24639_11794# a_24563_12150.t7 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2837 a_49148_833.t1 VDD.t1695 VDD.t723 VDD.t4 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X2838 VSS.t4035 a_24639_3394# a_24729_3490.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2839 a_1735_17416.t2 a_1279_17714.t3 VDD.t1136 VDD.t752 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2840 VDD.t962 a_2430_14873.t3 a_2532_14960.t1 VDD.t817 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2841 VSS.t2240 a_49148_833.t2 a_48826_693.t1 VSS.t2239 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2842 VSS.t261 VSS.t259 a_13625_20594.t0 VSS.t260 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X2843 VSS.t617 VSS.t616 a_50643_12150.t1 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2844 a_40399_12114.t0 a_40010_11798.t2 VDD.t95 VDD.t91 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2845 a_28101_6534.t3 a_28612_6560.t2 a_29360_6293.t1 VSS.t1645 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2846 VSS.t2636 a_18119_594# a_18209_690.t0 VSS.t2635 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2847 a_18043_950.t0 VSS.t1009 VSS.t1010 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2848 a_8349_17416.t0 a_7799_17714.t3 a_8255_17416.t2 VSS.t3338 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2849 VDD.t33 a_17121_12094.t2 a_17338_12114.t1 VDD.t25 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X2850 a_21555_6439.t0 a_21990_6473.t3 a_21938_6607.t0 VDD.t139 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2851 a_40855_616.t1 a_40399_914.t3 VDD.t705 VDD.t448 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2852 VDD.t304 a_n2646_2484.t10 a_679_3794.t0 VDD.t303 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2853 a_35030_3673.t0 CLK.t10 VSS.t1936 VSS.t3681 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2854 a_18043_3750.t4 a_16917_3694.t2 6MSB_0.OUTP.t42 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2855 a_51517_23976.t5 4LSB_weighted_0.VBIAS a_51453_23453.t5 VSS.t4075 sg13_hv_nmos ad=0.114p
+ pd=0.98u as=0.114p ps=0.98u w=0.6u l=0.48u
X2856 a_36069_17731.t0 a_35132_17760.t2 a_35880_17493.t0 VDD.t893 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X2857 a_20145_3794.t0 a_521_25453.t3 VSS.t3477 VSS.t3476 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2858 a_18043_14950.t1 a_16917_14894.t2 6MSB_0.OUTP.t13 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2859 a_51440_26253.t2 a_50396_26489.t2 6MSB_0.OUTN.t86 VSS.t2593 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2860 a_33778_20217.t1 a_33490_20198.t2 VSS.t2784 VSS.t2785 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2861 a_15061_9334.t3 a_15572_9360.t2 a_16320_9093.t1 VSS.t1340 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2862 a_7199_20594.t0 a_2713_24910.t9 a_7105_20594.t1 VDD.t762 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X2863 a_9800_693.t0 a_8950_873.t2 a_8541_934.t3 VDD.t460 sg13_lv_pmos ad=0.19115p pd=1.565u as=0.34p
+ ps=2.68u w=1u l=0.13u
X2864 a_37769_3490.t3 a_37679_3394# VSS.t3284 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2865 a_17121_3694.t0 a_16320_3493.t2 VSS.t1859 VSS.t1860 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2866 a_18043_17750.t4 a_17338_17714.t2 6MSB_0.OUTN.t21 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2867 a_17338_6514.t0 a_17121_6494.t2 VSS.t1602 VSS.t1601 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2868 a_27815_616.t2 a_28612_960.t3 a_28075_839.t1 VDD.t456 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2869 a_17338_20514.t1 a_17121_20494.t2 VDD.t977 VDD.t7 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X2870 VSS.t2054 a_4081_894.t2 a_4298_914.t0 VSS.t2053 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X2871 a_49721_3694.t1 a_48920_3493.t2 VDD.t591 VDD.t293 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2872 a_18043_6550.t9 a_18119_6194# a_18209_6290.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2873 6MSB_0.OUTN.t113 a_49938_914.t2 a_50643_950.t6 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2874 a_24563_20550.t9 a_23858_20514.t2 6MSB_0.OUTN.t24 VSS.t3464 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2875 VSS.t461 VSS.t459 VSS.t460 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2876 a_24729_6290.t3 a_24639_6194# VSS.t4144 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2877 VSS.t1761 a_n2042_2484.t3 a_39705_994.t0 VSS.t1760 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2878 a_46319_994.t0 VSS.t1086 a_46225_994.t1 VDD.t4 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X2879 a_24729_9090.t5 a_24639_8994# a_24563_9350.t7 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2880 a_36477_3694.t1 a_35880_3493.t2 VDD.t557 VDD.t290 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2881 6MSB_0.OUTP.t7 a_49517_3694.t2 a_50643_3750.t5 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2882 a_34910_9029.t1 a_34621_9334.t4 a_34847_9029.t0 VSS.t1416 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2883 a_31083_12150.t3 a_31159_11794# a_31249_11890.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2884 a_36681_6494.t1 a_35880_6293.t2 VDD.t400 VDD.t135 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2885 a_3877_894.t0 a_3280_693.t2 VSS.t2045 VSS.t2044 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2886 a_24729_14690.t0 a_24639_14594# VSS.t545 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2887 6MSB_0.OUTN.t85 a_49938_12114.t2 a_50643_12150.t9 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2888 a_47635_12039.t1 a_48070_12073.t3 a_48018_12207.t0 VDD.t1 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X2889 a_47469_11816.t0 a_46919_12114.t3 a_47375_11816.t0 VSS.t1168 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X2890 a_37603_3750.t8 a_37679_3394# a_37769_3490.t5 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2891 a_35030_20473.t1 CLK.t57 VDD.t794 VDD.t793 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X2892 a_23437_6494.t1 a_22840_6293.t2 VDD.t368 VDD.t139 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2893 VDD.t1051 a_49148_17633.t2 a_49109_17731.t0 VDD.t905 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=52.5f ps=0.67u w=0.42u l=0.13u
X2894 a_49938_12114.t1 a_49721_12094.t2 VDD.t120 VDD.t1 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X2895 a_24563_9350.t0 VSS.t690 VSS.t691 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2896 a_23641_9294.t1 a_22840_9093.t2 VDD.t216 VDD.t156 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2897 a_28101_934.t1 a_28075_839.t3 VDD.t676 VDD.t456 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2898 VSS.t2072 a_10028_833.t2 a_9706_693.t1 VSS.t2071 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2899 a_4298_914.t1 a_4081_894.t2 VDD.t624 VDD.t462 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X2900 a_1279_20514.t2 a_n2044_4040.t16 VDD.t1029 VDD.t5 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2901 a_50643_950.t4 a_49517_894.t2 6MSB_0.OUTP.t116 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2902 a_18043_17750.t8 a_18119_17394# a_18209_17490.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2903 a_24563_6550.t8 a_24639_6194# a_24729_6290.t5 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2904 VSS.t2245 a_48920_693.t2 a_49517_894.t0 VSS.t2244 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X2905 a_23858_12114.t0 a_23641_12094.t2 VSS.t55 VSS.t54 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X2906 a_44123_20550.t7 a_44199_20194# a_44289_20290.t4 VSS.t3155 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2907 a_18043_17750.t5 a_16917_17694.t2 6MSB_0.OUTP.t126 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X2908 a_3508_9233.t1 a_3280_9093.t2 a_3699_9016.t0 VSS.t1281 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X2909 a_42400_9093.t0 a_41550_9273.t2 a_41141_9334.t3 VDD.t147 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2910 a_3508_833.t0 VDD.t1625 VDD.t618 VDD.t462 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X2911 VDD.t12 VSS.t264 a_20239_20594.t0 VDD.t11 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2912 a_24729_20290.t4 a_24639_20194# a_24563_20550.t6 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2913 a_7105_14994.t0 a_2713_24910.t7 VSS.t2999 VSS.t2998 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2914 VSS.t546 VSS.t542 VSS.t545 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2915 a_34910_20229.t1 a_34621_20534.t4 a_34847_20229.t0 VSS.t2550 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X2916 VDD.t81 VDD.t1455 a_34335_11816.t1 VDD.t66 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2917 a_37769_11890.t5 a_37679_11794# a_37603_12150.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2918 VSS.t1391 a_29588_9233.t2 a_29266_9093.t1 VSS.t1390 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2919 a_40298_20217.t2 a_n2044_4040.t10 a_40399_20514.t2 VSS.t3539 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X2920 a_50643_3750.t9 a_50719_3394# a_50809_3490.t7 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2921 a_40399_20514.t0 a_40010_20198.t2 VDD.t854 VDD.t801 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X2922 a_9800_17493.t1 a_8950_17673.t2 a_8541_17734.t1 VDD.t741 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2923 a_11689_17490.t0 a_11599_17394# VSS.t293 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2924 a_37603_17750.t8 a_37679_17394# a_37769_17490.t5 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2925 a_16320_693.t1 a_15470_873.t2 a_16226_693.t0 VSS.t2094 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X2926 VDD.t28 a_16320_11893.t2 a_16548_12033.t1 VDD.t25 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2927 a_46319_12194.t0 VSS.t659 a_46225_12194.t1 VDD.t1 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X2928 VDD.t168 a_3280_9093.t2 a_3508_9233.t0 VDD.t122 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X2929 VDD.t998 a_48949_27476.t3 a_49051_27563.t1 VDD.t14 sg13_lv_pmos ad=1.4292p pd=9.04u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2930 a_18209_17490.t7 a_18119_17394# a_18043_17750.t7 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2931 VSS.t2776 a_37679_6194# a_37769_6290.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2932 a_10601_894.t1 a_9800_693.t2 VDD.t637 VDD.t460 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2933 VDD.t978 a_17121_20494.t2 a_17338_20514.t1 VDD.t7 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X2934 a_28390_20229.t0 a_28612_20560.t3 a_28075_20439.t1 VSS.t2935 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2935 a_28327_20229.t0 VDD.t1291 VSS.t3763 VSS.t3762 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2936 a_40855_14616.t1 a_41652_14960.t3 a_41115_14839.t0 VDD.t810 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X2937 VSS.t3524 a_5079_11794# a_5169_11890.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2938 a_29779_616.t0 VDD.t1665 VSS.t2156 VSS.t3973 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X2939 a_46225_3794.t0 VSS.t989 VSS.t991 VSS.t990 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X2940 a_18209_3490.t2 a_18119_3394# VSS.t2395 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2941 a_10818_14914.t0 a_10601_14894.t2 VSS.t2751 VSS.t2750 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2942 a_34621_3734.t2 a_35132_3760.t2 a_35880_3493.t1 VSS.t1933 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2943 VSS.t2373 a_50719_17394# a_50809_17490.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2944 VDD.t1400 VDD.t1399 a_8515_14839.t2 VDD.t912 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2945 VSS.t4174 a_24639_8994# a_24729_9090.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2946 a_11523_950.t7 a_11599_594# a_11689_690.t4 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2947 a_3877_14894.t0 a_3280_14693.t2 VSS.t4017 VSS.t4016 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2948 a_24563_950.t4 a_23437_894.t2 6MSB_0.OUTP.t112 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2949 a_48070_6473.t0 CLK.t16 VSS.t1730 VSS.t3675 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2950 VSS.t375 VSS.t373 a_50643_17750.t1 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X2951 VDD.t1216 a_21990_17673.t3 a_22092_17760.t1 VDD.t737 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X2952 a_33185_6594.t0 a_3545_25331.t4 VSS.t2681 VSS.t2680 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X2953 a_485_25427.t0 X7.t5 VSS.t101 VSS.t100 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1371p ps=1.12u
+ w=0.64u l=0.13u
X2954 VSS.t1567 a_8950_6473.t3 a_9052_6560.t0 VSS.t1566 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2955 a_21581_6534.t2 a_22092_6560.t2 a_22840_6293.t1 VSS.t1619 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2956 VDD.t629 a_7410_598.t2 a_7799_914.t0 VDD.t460 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2957 VSS.t2945 a_28510_14873.t3 a_28612_14960.t0 VSS.t2944 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2958 a_11523_950.t0 VSS.t997 VSS.t998 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2959 VDD.t465 a_n2042_2484.t10 a_46919_3714.t1 VDD.t293 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2960 a_28327_3429.t0 VDD.t1593 VSS.t3930 VSS.t3929 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2961 VDD.t130 a_n2770_240.t9 a_679_9394.t0 VDD.t122 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2962 a_18043_6550.t0 VSS.t776 VSS.t777 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X2963 VDD.t618 a_2430_873.t3 a_2532_960.t1 VDD.t462 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X2964 VSS.t836 VSS.t834 VSS.t835 VSS.t415 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X2965 a_35030_9273.t0 CLK.t26 VSS.t1421 VSS.t3665 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X2966 a_41141_934.t3 a_41652_960.t2 a_42400_693.t1 VSS.t2207 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X2967 a_11523_3750.t4 a_10397_3694.t2 6MSB_0.OUTP.t30 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2968 a_31083_20550.t3 a_31159_20194# a_31249_20290.t7 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2969 a_44123_12150.t8 a_44199_11794# a_44289_11890.t5 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2970 a_24729_690.t6 a_24639_594# a_24563_950.t9 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2971 a_16320_17493.t0 a_15470_17673.t2 a_15061_17734.t3 VDD.t748 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X2972 VSS.t3175 a_n2648_3264.t6 a_20145_14994.t0 VSS.t3419 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X2973 a_40399_12114.t1 a_n2770_240.t11 VDD.t96 VDD.t91 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X2974 a_18043_3750.t7 a_18119_3394# a_18209_3490.t4 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2975 VDD.t958 a_n2648_3264.t9 a_679_14994.t0 VDD.t817 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X2976 a_24729_11890.t4 a_24639_11794# a_24563_12150.t9 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2977 VSS.t3449 a_50719_11794# a_50809_11890.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2978 a_10601_3694.t0 a_9800_3493.t2 VSS.t1832 VSS.t1833 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X2979 a_17121_9294.t0 a_16320_9093.t2 VSS.t1347 VSS.t1348 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X2980 a_37769_9090.t3 a_37679_8994# VSS.t3590 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X2981 a_27359_914.t1 VDD.t1659 a_27258_617.t1 VSS.t3968 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X2982 a_10818_6514.t0 a_10601_6494.t2 VSS.t1576 VSS.t1575 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2983 a_49517_6494.t1 a_48920_6293.t2 VDD.t428 VDD.t0 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X2984 a_47661_6534.t1 a_47635_6439.t3 VDD.t424 VDD.t0 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X2985 VDD.t1158 a_n2648_3264.t17 a_1279_17714.t1 VDD.t752 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2986 VSS.t3481 a_11599_11794# a_11689_11890.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2987 VSS.t1040 VSS.t1037 VSS.t1039 VSS.t1038 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u
+ l=0.45u
X2988 a_40855_17416.t0 a_40399_17714.t3 VDD.t1731 VDD.t812 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X2989 VDD.t925 VDD.t1393 a_15035_14839.t2 VDD.t887 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X2990 a_49721_9294.t1 a_48920_9093.t2 VDD.t276 VDD.t2 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X2991 a_5169_3490.t5 a_5079_3394# a_5003_3750.t7 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X2992 VSS.t4070 4LSB_weighted_0.VBIAS a_51516_24785.t4 VSS.t4065 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X2993 a_2310_14629.t0 a_2532_14960.t3 a_1995_14839.t1 VSS.t2811 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X2994 a_2247_14629.t0 VDD.t1281 VSS.t3798 VSS.t3797 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X2995 a_10397_14894.t0 a_9800_14693.t2 VSS.t2746 VSS.t2745 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X2996 VDD.t948 a_n2044_1752.t14 a_20839_14914.t1 VDD.t736 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X2997 VDD.t862 a_41550_14873.t3 a_41652_14960.t1 VDD.t810 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X2998 6MSB_0.OUTP.t49 a_3877_9294.t2 a_5003_9350.t5 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X2999 6MSB_0.OUTN.t1 a_49938_6514.t2 a_50643_6550.t6 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3000 VSS.t407 VSS.t405 VSS.t406 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3001 a_21870_11829.t0 a_22092_12160.t3 a_21555_12039.t1 VSS.t37 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3002 a_36898_914.t0 a_36681_894.t2 VSS.t2192 VSS.t2191 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X3003 a_36477_9294.t1 a_35880_9093.t2 VDD.t243 VDD.t150 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X3004 a_50809_6290.t4 a_50719_6194# a_50643_6550.t2 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3005 a_1735_11816.t2 a_1279_12114.t3 VDD.t1747 VDD.t765 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3006 VSS.t3825 VDD.t1435 a_1829_11816.t0 VSS.t3824 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3007 VSS.t2532 a_4285_24701.t2 a_4321_24727.t0 VSS.t2531 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3008 6MSB_0.OUTN.t55 a_49938_17714.t2 a_50643_17750.t8 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3009 a_50809_11890.t2 a_50719_11794# VSS.t3447 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3010 a_31083_3750.t8 a_31159_3394# a_31249_3490.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3011 VDD.t971 VDD.t1287 a_34335_20216.t1 VDD.t793 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3012 a_37769_20290.t6 a_37679_20194# a_37603_20550.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3013 a_47469_17416.t0 a_46919_17714.t3 a_47375_17416.t3 VSS.t4323 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3014 a_37603_9350.t8 a_37679_8994# a_37769_9090.t5 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3015 a_24729_690.t2 a_24639_594# VSS.t3132 VSS.t3133 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3016 VDD.t1058 a_42400_17493.t2 a_42997_17694.t1 VDD.t812 sg13_lv_pmos ad=0.2083p pd=1.5u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3017 a_21555_839.t0 a_21990_873.t3 a_21938_1007.t0 VDD.t458 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3018 a_51440_25469.t4 a_50626_25035.t2 6MSB_0.OUTP.t33 VSS.t2599 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3019 a_50643_6550.t5 a_49517_6494.t2 6MSB_0.OUTP.t2 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3020 VSS.t817 VSS.t815 VSS.t816 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3021 6MSB_0.OUTP.t106 a_36477_894.t2 a_37603_950.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3022 VDD.t974 a_16320_20293.t2 a_16548_20433.t1 VDD.t7 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3023 a_36069_12131.t0 a_35132_12160.t2 a_35880_11893.t0 VDD.t66 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3024 a_23858_17714.t0 a_23641_17694.t2 VSS.t3409 VSS.t3408 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3025 a_9800_3493.t1 a_8950_3673.t2 a_9706_3493.t0 VSS.t1822 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3026 a_37603_950.t8 a_37679_594# a_37769_690.t5 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3027 6MSB_0.OUTP.t39 a_50626_23927.t2 a_51453_23453.t3 VSS.t2298 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3028 6MSB_0.OUTP.t96 a_23437_12094.t2 a_24563_12150.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3029 a_2430_6473.t1 CLK.t23 VDD.t321 VDD.t143 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3030 a_5003_6550.t3 a_5079_6194# a_5169_6290.t6 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3031 VSS.t2475 a_36108_20433.t2 a_35786_20293.t0 VSS.t2474 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3032 a_50643_9350.t9 a_50719_8994# a_50809_9090.t7 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3033 VSS.t903 VSS.t901 VSS.t903 VSS.t902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X3034 VSS.t1885 a_22840_3493.t2 a_23437_3694.t0 VSS.t1883 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3035 a_18209_3490.t0 a_18119_3394# VSS.t956 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3036 a_48706_23974.t0 a_48349_23931.t4 VDD.t761 VDD.t760 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3037 VSS.t2238 a_48070_873.t3 a_48172_960.t0 VSS.t2237 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3038 VSS.t844 VSS.t827 a_31083_6550.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3039 a_37769_11890.t1 a_37679_11794# VSS.t3613 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3040 6MSB_0.OUTP.t93 a_36477_12094.t2 a_37603_12150.t5 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3041 a_41430_14629.t1 a_41141_14934.t4 a_41367_14629.t0 VSS.t4265 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3042 a_7410_6198.t1 a_7105_6594.t2 VDD.t142 VDD.t141 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3043 a_40399_20514.t1 a_n2044_4040.t10 VDD.t855 VDD.t801 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X3044 a_44123_20550.t9 a_44199_20194# a_44289_20290.t7 VSS.t3159 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3045 VSS.t2911 a_5079_17394# a_5169_17490.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3046 a_7698_6217.t0 a_7410_6198.t2 VSS.t1556 VSS.t1557 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3047 a_36477_3694.t0 a_35880_3493.t2 VSS.t1939 VSS.t1938 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3048 VSS.t3560 VDD.t1317 a_48157_24365.t0 VSS.t3699 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3049 VSS.t4158 a_24639_14594# a_24729_14690.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3050 VDD.t114 a_49148_12033.t2 a_49109_12131.t0 VDD.t1 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3051 a_18209_9090.t2 a_18119_8994# VSS.t3508 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3052 a_24729_20290.t6 a_24639_20194# a_24563_20550.t8 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3053 a_34621_9334.t3 a_35132_9360.t2 a_35880_9093.t1 VSS.t1418 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3054 a_24563_3750.t0 VSS.t924 VSS.t925 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3055 VSS.t994 VSS.t987 VSS.t993 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3056 a_18043_12150.t9 a_18119_11794# a_18209_11890.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3057 a_24563_6550.t4 a_23437_6494.t2 6MSB_0.OUTP.t120 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3058 a_46225_14994.t0 VSS.t573 VSS.t575 VSS.t574 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X3059 a_29779_11816.t0 VDD.t1453 VSS.t76 VSS.t3836 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3060 a_8830_629.t0 a_9052_960.t3 a_8515_839.t0 VSS.t2062 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X3061 6MSB_0.OUTN.t4 a_50205_23947.t2 a_51453_23453.t0 VSS.t3327 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3062 VSS.t306 VSS.t298 a_18043_17750.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3063 VDD.t1039 a_33490_17398.t2 a_33879_17714.t0 VDD.t893 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3064 a_28327_9029.t0 VDD.t1497 VSS.t3866 VSS.t3865 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3065 a_11523_6550.t0 VSS.t766 VSS.t767 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3066 a_1995_6439.t1 a_2430_6473.t3 a_2378_6607.t0 VDD.t143 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3067 a_27258_617.t2 VDD.t1659 a_27359_914.t1 VSS.t3969 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3068 a_30378_14914.t1 a_30161_14894.t2 VDD.t1074 VDD.t884 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X3069 VDD.t146 a_n2042_972.t10 a_46919_9314.t1 VDD.t2 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3070 a_18043_9350.t1 a_16917_9294.t2 6MSB_0.OUTP.t37 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3071 a_1735_20216.t2 a_1279_20514.t3 VDD.t1168 VDD.t5 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3072 a_48920_17493.t1 a_48070_17673.t2 a_47661_17734.t0 VDD.t905 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3073 a_890_11798.t0 a_585_12194.t2 VSS.t2687 VSS.t2686 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X3074 VDD.t526 a_22840_3493.t2 a_23068_3633.t0 VDD.t297 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3075 a_11523_3750.t7 a_11599_3394# a_11689_3490.t4 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3076 a_50027_24365.t0 VDD.t1321 VSS.t3562 VSS.t3561 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3077 a_18043_9350.t7 a_18119_8994# a_18209_9090.t4 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3078 VSS.t2377 a_50719_17394# a_50809_17490.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3079 a_10601_9294.t0 a_9800_9093.t2 VSS.t1322 VSS.t1323 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X3080 VSS.t1054 a_18119_594# a_18209_690.t3 VSS.t2642 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3081 a_9800_11893.t0 a_8950_12073.t2 a_8541_12134.t2 VDD.t17 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3082 a_37603_12150.t7 a_37679_11794# a_37769_11890.t6 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3083 VSS.t3044 a_44199_11794# a_44289_11890.t1 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3084 a_41141_3734.t0 a_41115_3639.t3 VSS.t1955 VSS.t1954 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3085 a_42997_6494.t1 a_42400_6293.t2 VDD.t414 VDD.t125 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X3086 6MSB_0.OUTN.t64 a_36898_12114.t2 a_37603_12150.t4 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3087 a_18209_11890.t7 a_18119_11794# a_18043_12150.t8 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3088 a_8349_20216.t0 a_7799_20514.t3 a_8255_20216.t2 VSS.t3214 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3089 VSS.t2360 a_11599_17394# a_11689_17490.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3090 VDD.t731 VDD.t1271 a_47635_14839.t2 VDD.t3 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X3091 a_36069_20531.t0 a_35132_20560.t2 a_35880_20293.t1 VDD.t793 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3092 a_18043_17750.t3 a_18119_17394# a_18209_17490.t4 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3093 a_5169_9090.t5 a_5079_8994# a_5003_9350.t7 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3094 a_44123_6550.t8 a_44199_6194# a_44289_6290.t5 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3095 a_21870_17429.t0 a_22092_17760.t3 a_21555_17639.t1 VSS.t3082 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3096 6MSB_0.OUTP.t84 a_36477_14894.t2 a_37603_14950.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3097 a_33879_14914.t0 a_n2044_1752.t12 a_33778_14617.t0 VSS.t2823 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3098 VSS.t2199 a_40010_598.t2 a_40298_617.t0 VSS.t2200 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X3099 a_50809_6290.t2 a_50719_6194# VSS.t2798 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3100 VDD.t965 a_16320_17493.t2 a_16917_17694.t1 VDD.t748 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3101 VSS.t2511 VDD.t1353 a_1829_17416.t0 VSS.t3726 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3102 a_5169_11890.t3 a_5079_11794# VSS.t3526 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3103 VSS.t2026 a_585_994.t2 a_890_598.t0 VSS.t2025 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X3104 a_48949_26480.t0 CLK.t65 VSS.t2940 VSS.t2939 sg13_lv_nmos ad=0.2516p pd=2.16u as=1.51765p
+ ps=9.285u w=0.74u l=0.13u
X3105 a_18043_20550.t8 a_17338_20514.t2 6MSB_0.OUTN.t119 VSS.t2883 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3106 a_50809_17490.t2 a_50719_17394# VSS.t2375 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3107 VSS.t2733 VDD.t1409 a_21389_14616.t0 VSS.t3806 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3108 VDD.t42 a_21990_12073.t3 a_22092_12160.t1 VDD.t34 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3109 a_31083_9350.t8 a_31159_8994# a_31249_9090.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3110 a_n2342_4060.t0 X10.t5 VDD.t832 VDD.t434 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p ps=2.36u
+ w=0.84u l=0.13u
X3111 a_5003_9350.t0 VSS.t674 VSS.t675 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3112 VDD.t1735 a_49799_27296.t2 a_50396_27497.t1 VDD.t14 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3113 VSS.t1012 VSS.t1011 a_5003_950.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3114 a_5003_12150.t6 a_4298_12114.t2 6MSB_0.OUTN.t79 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3115 a_11689_6290.t6 a_11599_6194# a_11523_6550.t9 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3116 VSS.t1998 a_48920_3493.t2 a_49517_3694.t0 VSS.t1996 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3117 a_10028_6433.t0 VDD.t1531 VDD.t336 VDD.t141 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X3118 6MSB_0.OUTP.t0 a_36477_6494.t2 a_37603_6550.t0 VSS.t1169 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3119 6MSB_0.OUTN.t70 a_23858_14914.t2 a_24563_14950.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3120 a_16320_11893.t0 a_15470_12073.t2 a_15061_12134.t3 VDD.t25 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3121 a_14319_3714.t0 a_n2042_2484.t15 a_14218_3417.t0 VSS.t1788 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3122 VDD.t420 a_46225_6594.t2 a_46530_6198.t1 VDD.t0 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X3123 a_9800_9093.t1 a_8950_9273.t2 a_9706_9093.t0 VSS.t1314 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3124 a_51453_23453.t5 4LSB_weighted_0.VBIAS a_51517_23976.t2 VSS.t4073 sg13_hv_nmos ad=0.114p
+ pd=0.98u as=0.114p ps=0.98u w=0.6u l=0.48u
X3125 VDD.t1146 a_n2648_3264.t11 a_40399_17714.t1 VDD.t812 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3126 VDD.t1075 a_30161_14894.t2 a_30378_14914.t1 VDD.t884 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X3127 VSS.t1680 a_35880_6293.t2 a_36477_6494.t0 VSS.t1678 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3128 a_24563_14950.t7 a_24639_14594# a_24729_14690.t5 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3129 a_41430_14629.t0 a_41652_14960.t3 a_41115_14839.t1 VSS.t4264 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3130 6MSB_0.OUTP.t124 a_23437_17694.t2 a_24563_17750.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3131 VDD.t754 a_3280_17493.t2 a_3508_17633.t1 VDD.t752 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3132 VDD.t886 a_26665_14994.t2 a_26970_14598.t1 VDD.t884 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X3133 a_41367_14629.t0 VDD.t1427 VSS.t3813 VSS.t3812 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3134 VSS.t673 VSS.t670 VSS.t673 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X3135 a_30161_894.t1 a_29360_693.t2 VDD.t682 VDD.t456 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3136 a_2021_934.t1 a_1995_839.t3 VDD.t616 VDD.t462 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X3137 VDD.t466 a_40010_3398.t2 a_40399_3714.t2 VDD.t282 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3138 VDD.t878 a_22840_14693.t2 a_23068_14833.t1 VDD.t736 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3139 VDD.t1119 a_n2770_240.t17 a_1279_12114.t2 VDD.t765 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3140 a_21581_12134.t2 a_22092_12160.t2 a_22840_11893.t1 VSS.t43 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3141 6MSB_0.OUTN.t101 a_4298_914.t2 a_5003_950.t6 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3142 a_18043_20550.t6 a_18119_20194# a_18209_20290.t5 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3143 a_40855_11816.t1 a_40399_12114.t3 VDD.t94 VDD.t91 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3144 a_18209_9090.t0 a_18119_8994# VSS.t717 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3145 VSS.t1371 a_22840_9093.t2 a_23437_9294.t0 VSS.t1369 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3146 VSS.t900 VSS.t897 VSS.t899 VSS.t898 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3147 VDD.t726 a_48920_693.t2 a_49148_833.t1 VDD.t4 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3148 a_49148_3633.t0 a_48920_3493.t2 a_49339_3416.t0 VSS.t1995 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3149 6MSB_0.OUTP.t17 a_3877_3694.t2 a_5003_3750.t5 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3150 a_49339_616.t0 VDD.t1695 VSS.t2240 VSS.t3991 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3151 a_5169_690.t4 a_5079_594# a_5003_950.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3152 a_20839_14914.t0 a_20450_14598.t2 VDD.t901 VDD.t736 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X3153 VSS.t2113 a_20145_994.t2 a_20450_598.t0 VSS.t2112 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X3154 a_47887_3429.t0 VDD.t1611 VSS.t3942 VSS.t3941 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3155 a_49517_6494.t0 a_48920_6293.t2 VSS.t1733 VSS.t1732 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3156 a_18043_20550.t7 a_16917_20494.t2 6MSB_0.OUTP.t24 VSS.t2877 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3157 a_31083_950.t7 a_31159_594# a_31249_690.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3158 6MSB_0.OUTP.t133 a_36477_17694.t2 a_37603_17750.t5 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3159 a_26970_17398.t1 a_26665_17794.t2 VDD.t1134 VDD.t733 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X3160 VDD.t1169 a_n2044_4040.t3 a_39799_17794.t0 VDD.t812 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X3161 a_37769_17490.t1 a_37679_17394# VSS.t4051 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3162 a_44123_14950.t2 VSS.t434 VSS.t570 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X3163 a_36108_6433.t0 a_35880_6293.t2 a_36299_6216.t0 VSS.t1677 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3164 a_11523_12150.t6 a_10818_12114.t2 6MSB_0.OUTN.t63 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3165 VDD.t589 a_48920_3493.t2 a_49148_3633.t1 VDD.t293 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3166 a_23068_12033.t0 a_22840_11893.t2 a_23259_11816.t0 VSS.t49 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3167 a_36477_9294.t0 a_35880_9093.t2 VSS.t1424 VSS.t1423 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3168 a_9800_6293.t0 a_8950_6473.t2 a_8541_6534.t2 VDD.t141 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3169 a_34847_6229.t0 VDD.t1551 VSS.t3902 VSS.t3901 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3170 a_44289_690.t2 a_44199_594# VSS.t3606 VSS.t3607 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3171 a_11689_20290.t0 a_11599_20194# VSS.t255 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3172 a_37603_20550.t5 a_37679_20194# a_37769_20290.t7 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3173 a_31249_17490.t4 a_31159_17394# a_31083_17750.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3174 a_5003_12150.t4 a_3877_12094.t2 6MSB_0.OUTP.t90 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3175 VDD.t102 a_42400_11893.t2 a_42997_12094.t1 VDD.t91 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3176 a_17338_914.t1 a_17121_894.t2 VDD.t654 VDD.t444 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3177 a_5003_950.t4 a_3877_894.t2 6MSB_0.OUTP.t114 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3178 a_9800_20293.t1 a_8950_20473.t2 a_8541_20534.t0 VDD.t762 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3179 VSS.t656 VSS.t654 VSS.t655 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3180 a_3699_6216.t0 VDD.t1525 VSS.t1540 VSS.t3883 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3181 a_18209_20290.t5 a_18119_20194# a_18043_20550.t5 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3182 a_11523_17750.t4 a_11599_17394# a_11689_17490.t6 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3183 VSS.t3054 a_18119_14594# a_18209_14690.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3184 VSS.t4039 a_24639_3394# a_24729_3490.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3185 a_29779_17416.t0 VDD.t1363 VSS.t3229 VSS.t3778 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3186 VDD.t398 a_35880_6293.t2 a_36108_6433.t1 VDD.t135 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3187 VDD.t742 a_9800_17493.t2 a_10028_17633.t1 VDD.t741 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3188 VDD.t343 a_10601_6494.t2 a_10818_6514.t1 VDD.t141 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3189 a_31249_6290.t1 a_31159_6194# VSS.t2282 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3190 VSS.t491 VSS.t490 a_18043_14950.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3191 a_11523_950.t3 a_11599_594# a_11689_690.t6 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3192 a_4298_3714.t0 a_4081_3694.t2 VSS.t1808 VSS.t1807 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X3193 6MSB_0.OUTP.t20 a_50817_26469.t2 a_51440_26253.t2 VSS.t2596 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3194 a_11523_9350.t1 a_10397_9294.t2 6MSB_0.OUTP.t103 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3195 VSS.t3102 a_11599_6194# a_11689_6290.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3196 a_48897_27610.t0 a_48540_27537.t4 VDD.t1000 VDD.t14 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3197 a_890_17398.t0 a_585_17794.t2 VSS.t3335 VSS.t3334 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X3198 a_11523_9350.t7 a_11599_8994# a_11689_9090.t4 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3199 VDD.t214 a_22840_9093.t2 a_23068_9233.t1 VDD.t156 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3200 VDD.t451 a_n2042_2484.t2 a_46319_994.t0 VDD.t4 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3201 a_5003_3750.t9 a_5079_3394# a_5169_3490.t7 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3202 a_n2648_3264.t1 a_n2946_3612.t2 VDD.t440 VDD.t286 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.1918p
+ ps=1.5u w=1.12u l=0.13u
X3203 a_51442_27857.t2 4LSB_weighted_0.VBIAS a_51768_27313.t0 VSS.t4058 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X3204 a_50218_26907.t0 VDD.t1297 VSS.t3009 VSS.t3008 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3205 a_8515_17639.t1 a_8950_17673.t3 a_8898_17807.t0 VDD.t741 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3206 VDD.t994 a_21990_20473.t3 a_22092_20560.t1 VDD.t11 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X3207 a_36681_14894.t0 a_35880_14693.t2 VSS.t2617 VSS.t2618 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X3208 a_13930_8998.t0 a_13625_9394.t2 VSS.t1298 VSS.t1297 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3209 a_48063_24737.t3 X3.t0 VDD.t1193 VDD.t813 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p ps=1.52u
+ w=0.42u l=0.13u
X3210 6MSB_0.OUTN.t46 a_36898_17714.t2 a_37603_17750.t4 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3211 VSS.t2495 a_44199_17394# a_44289_17490.t1 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3212 a_41141_9334.t0 a_41115_9239.t3 VSS.t1443 VSS.t1442 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3213 VSS.t1002 VSS.t1001 a_18043_950.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3214 VSS.t1977 X10.t3 a_n2951_2880.t0 VSS.t2315 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X3215 VDD.t300 a_n2646_2484.t8 a_13719_3794.t0 VDD.t299 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3216 VDD.t509 VDD.t1581 a_15035_3639.t2 VDD.t299 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3217 a_10219_616.t0 VDD.t1635 VSS.t2072 VSS.t3955 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3218 a_16320_20293.t0 a_15470_20473.t2 a_15061_20534.t1 VDD.t7 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3219 a_8950_14873.t0 CLK.t46 VSS.t3649 VSS.t3648 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X3220 a_49721_894.t0 a_48920_693.t2 VSS.t2245 VSS.t2246 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X3221 a_5169_17490.t3 a_5079_17394# VSS.t2913 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3222 a_11523_14950.t0 VSS.t497 VSS.t498 VSS.t348 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3223 a_5003_14950.t1 a_3877_14894.t2 6MSB_0.OUTP.t19 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3224 VDD.t1187 a_n2044_4040.t16 a_1279_20514.t2 VDD.t5 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3225 a_8898_17807.t0 a_8541_17734.t4 VDD.t1055 VDD.t741 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3226 VDD.t619 a_3280_693.t2 a_3508_833.t0 VDD.t462 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3227 a_40855_20216.t2 a_40399_20514.t3 VDD.t856 VDD.t801 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3228 VSS.t607 VSS.t606 a_18043_12150.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3229 VDD.t70 a_33490_11798.t2 a_33879_12114.t0 VDD.t66 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3230 a_5003_950.t2 VSS.t889 VSS.t1014 VSS.t1013 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X3231 a_1995_839.t0 a_2430_873.t3 a_2378_1007.t0 VDD.t462 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3232 a_37769_3490.t0 a_37679_3394# VSS.t887 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3233 VSS.t288 VSS.t285 VSS.t287 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3234 VSS.t1483 a_48920_9093.t2 a_49517_9294.t0 VSS.t1481 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3235 VDD.t648 a_15470_873.t3 a_15572_960.t1 VDD.t444 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3236 VDD.t828 a_49799_26830.t2 a_50396_26489.t1 VDD.t13 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3237 a_5003_17750.t6 a_4298_17714.t2 6MSB_0.OUTN.t131 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3238 a_15035_17639.t0 a_15470_17673.t3 a_15418_17807.t0 VDD.t748 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3239 VSS.t3318 a_30161_14894.t2 a_30378_14914.t0 VSS.t3317 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3240 VSS.t453 VSS.t452 VSS.t453 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X3241 a_10818_6514.t1 a_10601_6494.t2 VDD.t342 VDD.t141 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3242 a_18043_3750.t1 a_16917_3694.t2 6MSB_0.OUTP.t43 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3243 a_24563_14950.t5 a_23858_14914.t2 6MSB_0.OUTN.t71 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3244 a_26759_14994.t0 a_2033_24727.t7 a_26665_14994.t1 VDD.t884 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3245 a_48920_11893.t0 a_48070_12073.t2 a_47661_12134.t3 VDD.t1 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3246 a_21581_934.t0 a_21555_839.t3 VSS.t2119 VSS.t2118 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X3247 a_36108_14833.t0 a_35880_14693.t2 a_36299_14616.t0 VSS.t2614 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3248 a_49148_14833.t1 VDD.t1267 VDD.t732 VDD.t3 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X3249 a_14319_9314.t1 a_n2042_972.t15 a_14218_9017.t0 VSS.t1270 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3250 a_24729_6290.t0 a_24639_6194# VSS.t825 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3251 VSS.t1095 VSS.t1092 VSS.t1095 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X3252 VSS.t1842 a_13930_3398.t2 a_14218_3417.t2 VSS.t1841 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X3253 a_7698_11817.t1 a_7410_11798.t2 VSS.t2467 VSS.t2468 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3254 6MSB_0.OUTP.t15 a_23437_9294.t2 a_24563_9350.t6 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3255 a_2713_24685.t1 X5.t0 a_3161_24936.t0 VDD.t71 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3256 VDD.t805 a_42400_20293.t2 a_42997_20494.t1 VDD.t801 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3257 VSS.t424 VSS.t422 VSS.t424 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X3258 VDD.t148 a_40010_8998.t2 a_40399_9314.t2 VDD.t147 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3259 a_21581_17734.t2 a_22092_17760.t2 a_22840_17493.t0 VSS.t4170 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3260 a_18043_14950.t2 VSS.t533 VSS.t541 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X3261 VSS.t3387 a_2430_12073.t3 a_2532_12160.t0 VSS.t3386 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3262 a_21295_3416.t2 a_22092_3760.t3 a_21555_3639.t1 VDD.t297 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3263 VSS.t2711 a_16548_14833.t2 a_16226_14693.t0 VSS.t2710 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3264 a_44289_11890.t3 a_44199_11794# VSS.t3046 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3265 6MSB_0.OUTN.t41 a_4298_6514.t2 a_5003_6550.t6 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3266 a_42628_3633.t0 a_42400_3493.t2 a_42819_3416.t0 VSS.t1964 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3267 a_23858_20514.t0 a_23641_20494.t2 VSS.t2985 VSS.t2984 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3268 a_15470_14873.t0 CLK.t45 VSS.t2770 VSS.t3629 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X3269 a_18043_12150.t3 a_18119_11794# a_18209_11890.t6 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3270 a_49148_9233.t0 a_48920_9093.t2 a_49339_9016.t0 VSS.t1480 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3271 VSS.t1259 a_n2042_972.t9 a_585_6594.t0 VSS.t1258 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X3272 a_8541_14934.t2 a_8515_14839.t3 VSS.t3800 VSS.t4007 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3273 a_40010_14598.t0 a_39705_14994.t2 VSS.t2515 VSS.t4185 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3274 VDD.t30 a_16320_11893.t2 a_16917_12094.t1 VDD.t25 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3275 a_48349_23931.t3 a_48323_23895.t3 VDD.t1188 VDD.t760 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X3276 VSS.t2687 a_n2044_1752.t9 a_585_12194.t0 VSS.t2818 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3277 a_47887_9029.t0 VDD.t1515 VSS.t3878 VSS.t3877 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3278 a_485_25427.t1 X7.t5 VDD.t74 VDD.t73 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2086p ps=1.5u w=1u
+ l=0.13u
X3279 a_15418_17807.t0 a_15061_17734.t4 VDD.t1092 VDD.t748 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3280 a_26759_3794.t0 a_2033_24727.t3 a_26665_3794.t1 VDD.t295 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3281 a_5003_17750.t9 a_5079_17394# a_5169_17490.t7 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3282 a_44123_12150.t5 a_43418_12114.t2 6MSB_0.OUTN.t61 VSS.t1131 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3283 a_13719_17794.t0 a_1253_24711.t8 a_13625_17794.t1 VDD.t748 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3284 VSS.t52 a_22840_11893.t2 a_23437_12094.t0 VSS.t50 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X3285 VDD.t572 a_42400_3493.t2 a_42628_3633.t1 VDD.t282 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3286 a_5003_3750.t0 VSS.t908 VSS.t909 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3287 a_11523_17750.t8 a_10818_17714.t2 6MSB_0.OUTN.t27 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3288 VDD.t274 a_48920_9093.t2 a_49148_9233.t1 VDD.t2 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3289 a_46818_617.t2 VDD.t1687 a_46919_914.t1 VSS.t3987 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3290 a_29360_3493.t1 a_28510_3673.t2 a_29266_3493.t0 VSS.t1903 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3291 a_5003_17750.t4 a_3877_17694.t2 6MSB_0.OUTP.t94 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3292 a_23068_17633.t0 a_22840_17493.t2 a_23259_17416.t0 VSS.t3403 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3293 a_40010_8998.t0 a_39705_9394.t2 VSS.t1434 VSS.t1433 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3294 a_5003_6550.t4 a_3877_6494.t2 6MSB_0.OUTP.t58 VSS.t1197 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3295 VSS.t4178 a_24639_8994# a_24729_9090.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3296 VDD.t1059 a_42400_17493.t2 a_42628_17633.t0 VDD.t812 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3297 a_11523_9350.t6 a_10818_9314.t2 6MSB_0.OUTN.t50 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3298 a_14218_11817.t0 a_13930_11798.t2 VSS.t3389 VSS.t3390 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3299 a_4081_6494.t0 a_3280_6293.t2 VSS.t1545 VSS.t1546 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X3300 a_50626_23927.t0 a_50409_23971.t2 VSS.t2936 VSS.t2682 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3301 VSS.t3142 a_5079_20194# a_5169_20290.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3302 VDD.t1107 a_n2770_240.t11 a_40399_12114.t1 VDD.t91 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3303 a_4298_9314.t0 a_4081_9294.t2 VSS.t1290 VSS.t1289 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X3304 a_5169_17490.t7 a_5079_17394# a_5003_17750.t8 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3305 VDD.t768 a_3280_11893.t2 a_3508_12033.t1 VDD.t765 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3306 a_5003_9350.t9 a_5079_8994# a_5169_9090.t7 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3307 a_15061_14934.t0 a_15035_14839.t3 VSS.t2764 VSS.t2763 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3308 a_24729_14690.t7 a_24639_14594# a_24563_14950.t8 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3309 6MSB_0.OUTN.t32 a_23858_9314.t2 a_24563_9350.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3310 a_n2044_1752.t0 a_n2342_2100.t2 VSS.t2010 VSS.t2011 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.1331p ps=1.12u w=0.74u l=0.13u
X3311 VDD.t380 VDD.t1545 a_28075_6439.t2 VDD.t137 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3312 a_27258_6217.t0 a_26970_6198.t2 VSS.t1637 VSS.t1638 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3313 VSS.t1004 VSS.t1003 a_11523_950.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3314 VSS.t148 VSS.t146 a_18043_20550.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3315 VDD.t930 a_33490_20198.t2 a_33879_20514.t0 VDD.t793 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3316 a_11523_17750.t6 a_11599_17394# a_11689_17490.t5 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3317 VSS.t2748 a_9800_14693.t2 a_10397_14894.t0 VSS.t2745 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3318 VSS.t775 VSS.t774 a_18043_6550.t1 VSS.t351 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3319 a_48063_24365.t2 X4.t0 VDD.t1804 VDD.t760 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p ps=1.52u
+ w=0.42u l=0.13u
X3320 a_44123_12150.t4 a_42997_12094.t2 6MSB_0.OUTP.t88 VSS.t1165 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3321 a_26970_11798.t1 a_26665_12194.t2 VDD.t51 VDD.t50 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3322 VDD.t92 a_n2044_1752.t3 a_39799_12194.t0 VDD.t91 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3323 VDD.t177 a_n2770_240.t7 a_13719_9394.t0 VDD.t159 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3324 a_50643_950.t7 a_50719_594# a_50809_690.t4 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3325 a_34595_3639.t1 a_35030_3673.t3 a_34978_3807.t0 VDD.t290 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3326 VDD.t198 VDD.t1485 a_15035_9239.t2 VDD.t159 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3327 a_5169_3490.t6 a_5079_3394# a_5003_3750.t9 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3328 a_31249_11890.t4 a_31159_11794# a_31083_12150.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3329 VSS.t873 VSS.t870 VSS.t872 VSS.t871 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3330 a_50809_17490.t4 a_50719_17394# a_50643_17750.t6 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3331 a_36898_914.t1 a_36681_894.t2 VDD.t699 VDD.t454 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3332 a_27815_3416.t1 a_27359_3714.t3 VDD.t537 VDD.t295 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3333 a_11523_12150.t7 a_11599_11794# a_11689_11890.t4 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3334 a_14775_616.t0 a_14319_914.t3 VDD.t645 VDD.t444 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3335 VSS.t2667 a_11599_20194# a_11689_20290.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3336 VSS.t555 a_37679_14594# a_37769_14690.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3337 a_3280_17493.t0 a_2430_17673.t2 a_2021_17734.t3 VDD.t752 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3338 VDD.t19 a_9800_11893.t2 a_10028_12033.t1 VDD.t17 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3339 a_11523_950.t5 a_10818_914.t2 6MSB_0.OUTN.t109 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3340 a_50205_23947.t0 a_49608_24288.t2 VSS.t4278 VSS.t4277 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3341 a_18043_20550.t3 a_18119_20194# a_18209_20290.t4 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3342 a_11689_17490.t5 a_11599_17394# a_11523_17750.t5 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3343 6MSB_0.OUTN.t45 a_36898_9314.t2 a_37603_9350.t6 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3344 a_37769_9090.t0 a_37679_8994# VSS.t740 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3345 a_14775_6216.t1 a_14319_6514.t3 VDD.t348 VDD.t127 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3346 a_37769_6290.t5 a_37679_6194# a_37603_6550.t7 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3347 a_28327_629.t0 VDD.t1657 VSS.t3972 VSS.t3971 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3348 a_28390_629.t1 a_28101_934.t4 a_28327_629.t0 VSS.t2149 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3349 a_11523_3750.t1 a_10397_3694.t2 6MSB_0.OUTP.t31 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3350 VDD.t973 a_16320_20293.t2 a_16917_20494.t1 VDD.t7 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3351 a_21870_20229.t0 a_22092_20560.t3 a_21555_20439.t1 VSS.t3271 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3352 VSS.t395 VSS.t387 VSS.t395 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X3353 a_31083_14950.t9 a_31159_14594# a_31249_14690.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3354 VSS.t3530 VDD.t1295 a_1829_20216.t0 VSS.t3733 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3355 a_8515_12039.t0 a_8950_12073.t3 a_8898_12207.t0 VDD.t17 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3356 VSS.t1380 a_26665_9394.t2 a_26970_8998.t0 VSS.t1379 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3357 VDD.t955 VDD.t1281 a_1995_14839.t2 VDD.t817 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3358 VSS.t1091 VSS.t1084 VSS.t1090 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u
+ l=0.45u
X3359 a_13930_3398.t0 a_13625_3794.t2 VSS.t1513 VSS.t1838 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3360 a_49938_6514.t1 a_49721_6494.t2 VDD.t432 VDD.t0 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3361 VSS.t1328 a_13930_8998.t2 a_14218_9017.t2 VSS.t1327 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X3362 a_7698_17417.t0 a_7410_17398.t2 VSS.t4209 VSS.t4210 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3363 VSS.t2197 a_39705_994.t2 a_40010_598.t0 VSS.t2196 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X3364 VSS.t1955 VDD.t1605 a_40949_3416.t0 VSS.t3936 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3365 a_n2044_4040.t0 a_n2342_4060.t2 VSS.t1745 VSS.t1746 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.1331p ps=1.12u w=0.74u l=0.13u
X3366 a_27815_17416.t2 a_27359_17714.t3 VDD.t1797 VDD.t733 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3367 VSS.t1824 a_10028_3633.t2 a_9706_3493.t1 VSS.t1823 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3368 VSS.t2981 a_2430_17673.t3 a_2532_17760.t0 VSS.t2980 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3369 a_27258_14617.t1 a_26970_14598.t2 VSS.t2773 VSS.t2774 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3370 a_21295_9016.t3 a_22092_9360.t3 a_21555_9239.t0 VDD.t156 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3371 6MSB_0.OUTN.t108 a_10818_914.t2 a_11523_950.t4 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3372 a_15418_3807.t0 a_15061_3734.t4 VDD.t509 VDD.t299 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3373 VDD.t443 a_585_3794.t2 a_890_3398.t1 VDD.t303 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X3374 a_48070_14873.t0 CLK.t40 VSS.t2256 VSS.t3624 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X3375 a_37603_9350.t4 a_36477_9294.t2 6MSB_0.OUTP.t64 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3376 a_42628_9233.t1 a_42400_9093.t2 a_42819_9016.t0 VSS.t1450 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3377 a_5169_6290.t2 a_5079_6194# VSS.t4214 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3378 a_39799_6594.t0 a_4321_24727.t4 a_39705_6594.t1 VDD.t125 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3379 a_44289_17490.t3 a_44199_17394# VSS.t2497 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3380 VSS.t3457 a_21990_14873.t3 a_22092_14960.t0 VSS.t3456 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3381 a_48514_27442.t1 a_48949_27476.t3 a_48254_27219.t3 VSS.t2938 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3382 VDD.t1175 a_n2044_4040.t10 a_40399_20514.t1 VDD.t801 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3383 a_44123_14950.t1 a_42997_14894.t2 6MSB_0.OUTP.t81 VSS.t1167 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3384 VSS.t33 a_20145_12194.t2 a_20450_11798.t0 VSS.t32 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X3385 VSS.t3335 a_n2044_4040.t9 a_585_17794.t0 VSS.t3537 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3386 a_48018_17807.t0 a_47661_17734.t4 VDD.t1392 VDD.t905 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3387 VDD.t1024 a_3280_20293.t2 a_3508_20433.t1 VDD.t5 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3388 a_26759_9394.t0 a_2033_24727.t5 a_26665_9394.t1 VDD.t153 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3389 a_29588_833.t0 a_29360_693.t2 a_29779_616.t0 VSS.t2157 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3390 6MSB_0.OUTP.t22 a_23437_20494.t2 a_24563_20550.t0 VSS.t2566 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3391 a_44123_17750.t9 a_43418_17714.t2 6MSB_0.OUTN.t23 VSS.t2862 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3392 VSS.t2285 a_31159_6194# a_31249_6290.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3393 a_31083_3750.t3 a_31159_3394# a_31249_3490.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3394 VDD.t487 a_4081_3694.t2 a_4298_3714.t1 VDD.t303 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3395 VSS.t3406 a_22840_17493.t2 a_23437_17694.t0 VSS.t3404 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3396 a_8898_12207.t0 a_8541_12134.t4 VDD.t775 VDD.t17 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3397 VDD.t258 a_42400_9093.t2 a_42628_9233.t0 VDD.t147 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3398 a_5169_690.t6 a_5079_594# a_5003_950.t9 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3399 a_46818_11817.t2 a_n2770_240.t10 a_46919_12114.t1 VSS.t3368 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3400 a_22840_3493.t1 a_21990_3673.t2 a_22746_3493.t0 VSS.t1877 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3401 a_8950_17673.t1 CLK.t54 VDD.t1056 VDD.t741 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3402 a_29360_9093.t1 a_28510_9273.t2 a_29266_9093.t0 VSS.t1389 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3403 a_31083_950.t3 a_31159_594# a_31249_690.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3404 a_51453_23453.t2 a_50205_23947.t2 6MSB_0.OUTN.t4 VSS.t3328 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3405 a_36681_17694.t1 a_35880_17493.t2 VDD.t896 VDD.t893 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3406 a_18043_14950.t8 a_18119_14594# a_18209_14690.t5 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3407 a_15035_12039.t1 a_15470_12073.t3 a_15418_12207.t0 VDD.t25 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3408 a_14869_11816.t0 a_14319_12114.t3 a_14775_11816.t0 VSS.t3391 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3409 6MSB_0.OUTP.t107 a_36477_894.t2 a_37603_950.t5 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3410 a_5003_6550.t7 a_5079_6194# a_5169_6290.t4 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3411 6MSB_0.OUTP.t27 a_36477_20494.t2 a_37603_20550.t8 VSS.t2572 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3412 a_26970_20198.t1 a_26665_20594.t2 VDD.t10 VDD.t9 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3413 VDD.t1030 VSS.t326 a_39799_20594.t0 VDD.t801 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3414 a_37769_20290.t1 a_37679_20194# VSS.t2343 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3415 VDD.t764 a_16548_17633.t2 a_16509_17731.t0 VDD.t748 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3416 a_46818_11817.t1 a_46530_11798.t2 VSS.t1174 VSS.t1175 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3417 a_14218_17417.t1 a_13930_17398.t2 VSS.t2590 VSS.t2589 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3418 6MSB_0.OUTN.t99 a_23858_914.t2 a_24563_950.t6 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3419 a_50809_14690.t0 a_50719_14594# VSS.t438 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3420 a_33490_3398.t1 a_33185_3794.t2 VDD.t291 VDD.t290 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3421 a_33778_3417.t0 a_33490_3398.t2 VSS.t1923 VSS.t1924 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3422 6MSB_0.OUTP.t9 a_23437_3694.t2 a_24563_3750.t5 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3423 a_31249_20290.t4 a_31159_20194# a_31083_20550.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3424 VSS.t1846 VDD.t1581 a_14869_3416.t0 VSS.t3920 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3425 VSS.t1730 a_48070_6473.t3 a_48172_6560.t0 VSS.t1729 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3426 a_47661_14934.t0 a_47635_14839.t3 VSS.t2453 VSS.t2452 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3427 VDD.t998 a_50027_27436.t2 a_49988_27534.t0 VDD.t14 sg13_lv_pmos ad=1.4292p pd=9.04u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3428 a_37603_12150.t9 a_36898_12114.t2 6MSB_0.OUTN.t64 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3429 a_40298_617.t1 a_40010_598.t2 VSS.t2199 VSS.t2198 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3430 a_7698_3417.t1 a_n2042_2484.t16 a_7799_3714.t0 VSS.t1791 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3431 a_47635_6439.t0 a_48070_6473.t3 a_48018_6607.t0 VDD.t0 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3432 a_11523_20550.t7 a_11599_20194# a_11689_20290.t4 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3433 a_29779_20216.t0 VDD.t1345 VSS.t3730 VSS.t3729 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3434 a_20450_6198.t1 a_20145_6594.t2 VDD.t140 VDD.t139 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3435 VDD.t365 VDD.t1539 a_21555_6439.t2 VDD.t139 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3436 a_36299_3416.t0 VDD.t1603 VSS.t1932 VSS.t3935 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3437 a_18209_14690.t5 a_18119_14594# a_18043_14950.t7 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3438 a_20738_6217.t0 a_20450_6198.t2 VSS.t1609 VSS.t1610 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3439 a_18209_690.t4 a_18119_594# a_18043_950.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3440 VDD.t1783 a_9800_20293.t2 a_10028_20433.t0 VDD.t762 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3441 a_28390_14629.t1 a_28101_14934.t4 a_28327_14629.t0 VSS.t3326 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3442 a_33778_14617.t1 a_n2044_1752.t12 a_33879_14914.t0 VSS.t2824 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3443 VSS.t773 VSS.t772 a_11523_6550.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3444 a_15418_12207.t0 a_15061_12134.t4 VDD.t1125 VDD.t25 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3445 a_34595_9239.t1 a_35030_9273.t3 a_34978_9407.t0 VDD.t150 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3446 a_27359_914.t2 VDD.t1659 VDD.t674 VDD.t456 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X3447 a_44123_17750.t7 a_42997_17694.t2 6MSB_0.OUTP.t40 VSS.t2889 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3448 a_5003_12150.t9 a_5079_11794# a_5169_11890.t7 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3449 a_23259_6216.t0 VDD.t1543 VSS.t1618 VSS.t3895 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3450 a_890_20198.t0 a_585_20594.t2 VSS.t238 VSS.t2563 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X3451 a_8515_20439.t1 a_8950_20473.t3 a_8898_20607.t0 VDD.t762 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3452 a_15470_17673.t1 CLK.t53 VDD.t764 VDD.t748 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3453 VSS.t439 VSS.t437 VSS.t438 VSS.t419 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3454 a_13719_12194.t0 a_1253_24711.t6 a_13625_12194.t1 VDD.t25 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3455 VSS.t3071 a_11599_594# a_11689_690.t2 VSS.t3070 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3456 VSS.t380 VSS.t379 a_5003_17750.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3457 a_5169_9090.t6 a_5079_8994# a_5003_9350.t9 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3458 VSS.t648 VSS.t645 VSS.t647 VSS.t646 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3459 a_40010_3398.t0 a_39705_3794.t2 VSS.t1493 VSS.t1946 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3460 a_27815_9016.t1 a_27359_9314.t3 VDD.t224 VDD.t153 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3461 a_44289_3490.t5 a_44199_3394# a_44123_3750.t7 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3462 a_4298_3714.t1 a_4081_3694.t2 VDD.t486 VDD.t303 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3463 VSS.t3166 a_44199_20194# a_44289_20290.t1 VSS.t3157 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3464 6MSB_0.OUTN.t8 a_36898_20514.t2 a_37603_20550.t7 VSS.t4116 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3465 VDD.t101 a_42400_11893.t2 a_42628_12033.t1 VDD.t91 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3466 a_41141_934.t0 a_41115_839.t3 VSS.t2204 VSS.t2203 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X3467 a_11523_3750.t6 a_10818_3714.t2 6MSB_0.OUTN.t6 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3468 a_44289_17490.t5 a_44199_17394# a_44123_17750.t5 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3469 VSS.t2515 a_n2648_3264.t3 a_39705_14994.t0 VSS.t2514 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3470 6MSB_0.OUTN.t31 a_30378_9314.t2 a_31083_9350.t5 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3471 a_11523_6550.t5 a_10818_6514.t2 6MSB_0.OUTN.t81 VSS.t1219 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3472 a_26970_6198.t0 a_26665_6594.t2 VSS.t1253 VSS.t1632 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3473 6MSB_0.OUTP.t79 a_29957_12094.t2 a_31083_12150.t5 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3474 a_8541_6534.t0 a_8515_6439.t3 VSS.t1561 VSS.t1560 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X3475 a_5169_11890.t7 a_5079_11794# a_5003_12150.t8 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3476 a_41430_6229.t1 a_41141_6534.t4 a_41367_6229.t0 VSS.t1697 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3477 VSS.t1352 a_20145_9394.t2 a_20450_8998.t0 VSS.t1351 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3478 a_5169_20290.t3 a_5079_20194# VSS.t3138 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3479 6MSB_0.OUTN.t28 a_23858_3714.t2 a_24563_3750.t4 VSS.t1133 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3480 a_5003_17750.t3 a_5079_17394# a_5169_17490.t6 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3481 6MSB_0.OUTN.t67 a_30378_14914.t2 a_31083_14950.t6 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3482 a_28075_14839.t1 a_28510_14873.t3 a_28458_15007.t0 VDD.t884 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3483 a_3699_14616.t0 VDD.t1397 VSS.t3792 VSS.t3791 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3484 VDD.t677 VDD.t1657 a_28075_839.t2 VDD.t456 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X3485 a_8898_20607.t0 a_8541_20534.t4 VDD.t1012 VDD.t762 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3486 VDD.t756 a_3280_17493.t2 a_3877_17694.t1 VDD.t752 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3487 VSS.t677 VSS.t676 a_5003_9350.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3488 VDD.t880 a_22840_14693.t2 a_23437_14894.t1 VDD.t736 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3489 a_11523_12150.t9 a_11599_11794# a_11689_11890.t7 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3490 a_23259_11816.t0 VDD.t1447 VSS.t48 VSS.t3832 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3491 VSS.t1443 VDD.t1509 a_40949_9016.t0 VSS.t3872 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3492 a_26970_598.t0 a_26665_994.t2 VSS.t1771 VSS.t2139 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X3493 a_48920_3493.t1 a_48070_3673.t2 a_48826_3493.t0 VSS.t1988 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3494 a_5003_20550.t8 a_4298_20514.t2 6MSB_0.OUTN.t19 VSS.t4134 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3495 a_15035_20439.t1 a_15470_20473.t3 a_15418_20607.t0 VDD.t7 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3496 a_31083_9350.t4 a_29957_9294.t2 6MSB_0.OUTP.t28 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3497 VSS.t1325 a_10028_9233.t2 a_9706_9093.t1 VSS.t1324 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3498 a_15418_9407.t0 a_15061_9334.t4 VDD.t198 VDD.t159 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3499 6MSB_0.OUTN.t80 a_10818_6514.t2 a_11523_6550.t4 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3500 a_9800_14693.t0 a_8950_14873.t2 a_9706_14693.t0 VSS.t4010 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3501 VDD.t131 a_585_9394.t2 a_890_8998.t1 VDD.t122 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X3502 VSS.t1990 a_49148_3633.t2 a_48826_3493.t1 VSS.t1989 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3503 a_29360_11893.t1 a_28510_12073.t2 a_29266_11893.t0 VSS.t70 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3504 a_41550_6473.t1 CLK.t17 VDD.t411 VDD.t125 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3505 a_44123_6550.t3 a_44199_6194# a_44289_6290.t6 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3506 VSS.t2875 a_20145_17794.t2 a_20450_17398.t0 VSS.t2874 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3507 a_42400_17493.t0 a_41550_17673.t2 a_41141_17734.t3 VDD.t812 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3508 a_11689_6290.t4 a_11599_6194# a_11523_6550.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3509 a_35880_6293.t1 a_35030_6473.t2 a_35786_6293.t0 VSS.t1670 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3510 a_7698_617.t2 VDD.t1629 a_7799_914.t1 VSS.t3951 sg13_lv_nmos ad=0.2448p pd=2.12u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3511 VDD.t574 a_42400_3493.t2 a_42997_3694.t1 VDD.t282 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3512 a_50809_11890.t4 a_50719_11794# a_50643_12150.t6 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3513 a_21581_20534.t1 a_22092_20560.t2 a_22840_20293.t0 VSS.t3115 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3514 a_47661_14934.t2 a_48172_14960.t2 a_48920_14693.t1 VSS.t2253 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3515 a_3280_11893.t1 a_2430_12073.t2 a_2021_12134.t0 VDD.t765 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3516 VDD.t174 a_4081_9294.t2 a_4298_9314.t1 VDD.t122 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3517 a_31083_9350.t3 a_31159_8994# a_31249_9090.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3518 a_46818_17417.t1 a_n2648_3264.t10 a_46919_17714.t0 VSS.t3425 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3519 a_11689_11890.t7 a_11599_11794# a_11523_12150.t8 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3520 a_22840_9093.t1 a_21990_9273.t2 a_22746_9093.t0 VSS.t1361 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3521 6MSB_0.OUTN.t117 a_36898_3714.t2 a_37603_3750.t6 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3522 VDD.t1086 VDD.t1357 a_8255_17416.t3 VDD.t741 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3523 a_28458_15007.t0 a_28101_14934.t4 VDD.t1080 VDD.t884 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3524 VDD.t1430 VDD.t1427 a_41115_14839.t2 VDD.t810 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3525 a_39705_9394.t0 a_4321_24727.t5 VSS.t2810 VSS.t2809 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X3526 VDD.t384 a_29360_6293.t2 a_29957_6494.t1 VDD.t137 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3527 a_14869_17416.t0 a_14319_17714.t3 a_14775_17416.t1 VSS.t2556 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3528 6MSB_0.OUTP.t1 a_36477_6494.t2 a_37603_6550.t4 VSS.t1171 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3529 VDD.t317 a_7410_6198.t2 a_7799_6514.t2 VDD.t141 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3530 a_47887_629.t0 VDD.t1691 VSS.t3990 VSS.t3989 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3531 a_2021_17734.t1 a_1995_17639.t3 VDD.t808 VDD.t752 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X3532 VSS.t1642 VDD.t1545 a_27909_6216.t0 VSS.t3898 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3533 a_46818_6217.t0 a_46530_6198.t2 VSS.t1718 VSS.t1717 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3534 a_15418_20607.t0 a_15061_20534.t4 VDD.t844 VDD.t7 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3535 a_46818_17417.t0 a_46530_17398.t2 VSS.t4321 VSS.t4322 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3536 6MSB_0.OUTP.t10 a_29957_14894.t2 a_31083_14950.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3537 a_10219_14616.t0 VDD.t1403 VSS.t3720 VSS.t3719 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3538 VSS.t1895 a_26665_3794.t2 a_26970_3398.t0 VSS.t1894 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3539 a_5003_20550.t6 a_5079_20194# a_5169_20290.t5 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3540 VDD.t744 a_9800_17493.t2 a_10397_17694.t1 VDD.t741 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3541 a_21581_14934.t1 a_21555_14839.t3 VDD.t904 VDD.t736 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X3542 6MSB_0.OUTN.t123 a_23858_6514.t2 a_24563_6550.t6 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3543 VSS.t557 VSS.t556 a_31083_14950.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3544 a_11523_20550.t6 a_10818_20514.t2 6MSB_0.OUTN.t121 VSS.t2562 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3545 a_13719_20594.t0 a_1253_24711.t9 a_13625_20594.t1 VDD.t7 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3546 a_33490_8998.t1 a_33185_9394.t2 VDD.t235 VDD.t150 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3547 VSS.t1704 a_41550_6473.t3 a_41652_6560.t0 VSS.t1703 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3548 a_5003_20550.t7 a_3877_20494.t2 6MSB_0.OUTP.t76 VSS.t4124 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3549 a_23068_20433.t1 a_22840_20293.t2 a_23259_20216.t0 VSS.t4228 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3550 a_16320_14693.t1 a_15470_14873.t2 a_16226_14693.t1 VSS.t2766 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3551 a_27815_11816.t1 a_27359_12114.t3 VDD.t55 VDD.t50 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3552 VSS.t1336 VDD.t1485 a_14869_9016.t0 VSS.t3856 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3553 a_33778_9017.t0 a_33490_8998.t2 VSS.t1410 VSS.t1411 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3554 a_47661_6534.t3 a_48172_6560.t2 a_48920_6293.t1 VSS.t1727 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3555 a_51442_27857.t1 a_50396_27497.t2 6MSB_0.OUTN.t88 VSS.t3443 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3556 a_34335_17416.t0 a_35132_17760.t3 a_34595_17639.t1 VDD.t893 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3557 VDD.t142 a_n2042_972.t8 a_7199_6594.t0 VDD.t141 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3558 VSS.t1581 a_13625_6594.t2 a_13930_6198.t0 VSS.t1580 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3559 a_41115_6439.t1 a_41550_6473.t3 a_41498_6607.t0 VDD.t125 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3560 VDD.t1662 VDD.t1659 a_27359_914.t2 VDD.t456 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X3561 a_35880_3493.t0 a_35030_3673.t2 a_34621_3734.t3 VDD.t290 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3562 a_37603_17750.t6 a_36898_17714.t2 6MSB_0.OUTN.t46 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3563 a_1178_3417.t2 a_n2042_2484.t17 a_1279_3714.t1 VSS.t1793 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3564 a_37603_3750.t5 a_36477_3694.t2 6MSB_0.OUTP.t34 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3565 a_7698_9017.t1 a_n2042_972.t16 a_7799_9314.t0 VSS.t1273 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3566 a_36299_9016.t0 VDD.t1507 VSS.t1428 VSS.t3871 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3567 VDD.t803 a_42400_20293.t2 a_42628_20433.t1 VDD.t801 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3568 a_26665_12194.t0 a_2033_24727.t6 VSS.t2539 VSS.t2538 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X3569 a_48018_12207.t0 a_47661_12134.t4 VDD.t113 VDD.t1 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3570 VSS.t3011 a_5079_14594# a_5169_14690.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3571 a_34335_616.t1 a_33879_914.t3 VDD.t690 VDD.t454 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3572 VDD.t514 a_16320_3493.t2 a_16917_3694.t1 VDD.t299 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3573 a_48575_24352.t0 VDD.t1317 VSS.t3747 VSS.t3745 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X3574 a_5169_20290.t5 a_5079_20194# a_5003_20550.t5 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3575 a_48070_17673.t1 CLK.t48 VDD.t1051 VDD.t905 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3576 6MSB_0.OUTP.t98 a_49517_12094.t2 a_50643_12150.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3577 VSS.t502 VSS.t501 a_5003_14950.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3578 a_37603_6550.t9 a_37679_6194# a_37769_6290.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3579 a_8255_3416.t1 a_7799_3714.t3 VDD.t492 VDD.t301 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3580 a_48349_25055.t0 a_48860_25081.t2 a_49608_24814.t0 VSS.t2974 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X3581 a_8950_12073.t1 CLK.t38 VDD.t18 VDD.t17 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3582 a_5003_950.t1 a_3877_894.t2 6MSB_0.OUTP.t115 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3583 a_36681_12094.t1 a_35880_11893.t2 VDD.t87 VDD.t66 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3584 a_4298_9314.t1 a_4081_9294.t2 VDD.t173 VDD.t122 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3585 a_44289_9090.t5 a_44199_8994# a_44123_9350.t7 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3586 a_50643_950.t3 a_50719_594# a_50809_690.t6 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3587 a_11523_20550.t9 a_11599_20194# a_11689_20290.t7 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3588 a_33879_14914.t1 a_n2044_1752.t12 VDD.t943 VDD.t846 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X3589 a_1279_6514.t2 a_n2646_2484.t18 a_1178_6217.t1 VSS.t1532 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3590 a_40399_914.t0 a_40010_598.t2 VDD.t703 VDD.t448 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X3591 VSS.t959 VSS.t958 a_18043_3750.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3592 VDD.t1089 a_4285_25305.t2 a_4305_24905.t1 VDD.t77 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3593 VDD.t1126 a_16548_12033.t2 a_16509_12131.t0 VDD.t25 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3594 a_34595_12039.t0 a_35030_12073.t3 a_34335_11816.t2 VSS.t1102 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3595 a_18209_14690.t6 a_18119_14594# a_18043_14950.t9 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3596 VDD.t839 a_1261_25305.t2 a_1201_24910.t1 VDD.t76 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3597 6MSB_0.OUTP.t131 a_29957_17694.t2 a_31083_17750.t6 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3598 a_20450_17398.t1 a_20145_17794.t2 VDD.t969 VDD.t737 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3599 VDD.t1034 a_n2044_4040.t4 a_33279_17794.t0 VDD.t893 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X3600 a_22840_693.t0 a_21990_873.t2 a_21581_934.t2 VDD.t458 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3601 VSS.t3129 a_24639_594# a_24729_690.t0 VSS.t3128 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3602 a_8950_873.t1 CLK.t6 VDD.t633 VDD.t460 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3603 a_13625_14994.t0 a_1253_24711.t7 VSS.t3094 VSS.t3093 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X3604 a_49517_14894.t1 a_48920_14693.t2 VDD.t782 VDD.t3 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X3605 VSS.t3291 a_50719_14594# a_50809_14690.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3606 a_44123_9350.t0 VSS.t700 VSS.t701 VSS.t514 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3607 a_47635_839.t1 a_48070_873.t3 a_48018_1007.t0 VDD.t4 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3608 VDD.t495 a_8950_3673.t3 a_9052_3760.t1 VDD.t301 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3609 VDD.t662 VDD.t1651 a_21555_839.t2 VDD.t458 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X3610 a_3280_20293.t1 a_2430_20473.t2 a_2021_20534.t3 VDD.t5 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3611 a_31249_14690.t2 a_31159_14594# VSS.t4029 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3612 a_50643_3750.t3 a_50719_3394# a_50809_3490.t6 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3613 a_37769_690.t4 a_37679_594# a_37603_950.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3614 VSS.t2087 a_13930_598.t2 a_14218_617.t0 VSS.t2088 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X3615 a_14319_3714.t1 a_n2042_2484.t15 VDD.t474 VDD.t299 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X3616 a_11689_20290.t7 a_11599_20194# a_11523_20550.t8 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3617 a_23259_17416.t0 VDD.t1377 VSS.t3782 VSS.t3781 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3618 a_48920_9093.t1 a_48070_9273.t2 a_48826_9093.t0 VSS.t1473 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3619 VSS.t481 VSS.t480 a_44123_17750.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3620 VSS.t128 VSS.t126 VSS.t128 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X3621 VSS.t4193 a_33490_14598.t2 a_33778_14617.t2 VSS.t4192 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X3622 a_4285_25305.t0 X5.t1 a_4341_25535.t0 VSS.t3573 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X3623 a_15470_12073.t1 CLK.t37 VDD.t1126 VDD.t25 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3624 VSS.t1475 a_49148_9233.t2 a_48826_9093.t1 VSS.t1474 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3625 a_29360_17493.t1 a_28510_17673.t2 a_29266_17493.t0 VSS.t2291 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3626 VSS.t467 VSS.t444 a_5003_12150.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3627 VSS.t3501 a_31159_594# a_31249_690.t2 VSS.t3504 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3628 6MSB_0.OUTN.t105 a_43418_914.t2 a_44123_950.t6 VSS.t1130 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3629 a_1261_25305.t0 X5.t3 a_1317_25535.t0 VSS.t3571 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X3630 a_1995_17639.t0 a_2430_17673.t3 a_2378_17807.t0 VDD.t752 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3631 6MSB_0.OUTP.t75 a_49517_14894.t2 a_50643_14950.t8 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3632 a_50809_14690.t1 a_50719_14594# VSS.t3288 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3633 a_7698_20217.t1 a_7410_20198.t2 VSS.t3212 VSS.t3213 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3634 a_27815_20216.t2 a_27359_20514.t3 VDD.t1715 VDD.t9 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3635 a_30161_14894.t0 a_29360_14693.t2 VSS.t2951 VSS.t2952 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X3636 VDD.t260 a_42400_9093.t2 a_42997_9294.t1 VDD.t147 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3637 a_29957_3694.t1 a_29360_3493.t2 VDD.t542 VDD.t295 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X3638 VSS.t3635 a_2430_20473.t3 a_2532_20560.t0 VSS.t4207 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3639 VSS.t3173 a_17121_14894.t2 a_17338_14914.t0 VSS.t3172 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3640 a_44289_11890.t5 a_44199_11794# a_44123_12150.t7 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3641 a_3509_25305.t0 X7.t3 VDD.t72 VDD.t71 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.1918p ps=1.5u
+ w=0.84u l=0.13u
X3642 a_44289_20290.t3 a_44199_20194# VSS.t3167 VSS.t3160 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3643 6MSB_0.OUTN.t43 a_30378_3714.t2 a_31083_3750.t6 VSS.t1114 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3644 VSS.t1238 a_n2042_972.t7 a_13625_6594.t0 VSS.t1237 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3645 a_37769_3490.t2 a_37679_3394# VSS.t3283 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3646 a_44123_17750.t3 a_44199_17394# a_44289_17490.t4 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3647 a_5003_14950.t2 VSS.t425 VSS.t526 VSS.t525 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X3648 a_42819_14616.t0 VDD.t1285 VSS.t2654 VSS.t3704 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3649 VDD.t525 a_23068_3633.t2 a_23029_3731.t0 VDD.t297 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3650 VSS.t238 VSS.t236 a_585_20594.t0 VSS.t237 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X3651 a_44123_950.t4 a_42997_894.t2 6MSB_0.OUTP.t118 VSS.t1165 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3652 VSS.t1867 a_20145_3794.t2 a_20450_3398.t0 VSS.t1866 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3653 a_48920_6293.t0 a_48070_6473.t2 a_47661_6534.t2 VDD.t0 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3654 a_2430_14873.t0 CLK.t47 VSS.t2858 VSS.t3630 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X3655 a_5003_12150.t3 a_5079_11794# a_5169_11890.t4 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3656 a_44123_20550.t6 a_43418_20514.t2 6MSB_0.OUTN.t133 VSS.t2862 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3657 a_18043_6550.t8 a_18119_6194# a_18209_6290.t5 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3658 a_24729_6290.t2 a_24639_6194# VSS.t4143 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3659 a_42819_6216.t0 VDD.t1561 VSS.t1700 VSS.t3907 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3660 VSS.t4231 a_22840_20293.t2 a_23437_20494.t0 VSS.t4229 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3661 a_48920_14693.t1 a_48070_14873.t2 a_48826_14693.t0 VSS.t2252 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3662 VDD.t767 a_3280_11893.t2 a_3877_12094.t1 VDD.t765 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3663 a_31083_950.t0 VSS.t1021 VSS.t1022 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3664 VSS.t913 VSS.t912 a_5003_3750.t1 VSS.t342 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3665 VSS.t204 VSS.t132 a_51517_23976.t3 VSS.t133 sg13_hv_nmos ad=0.204p pd=1.88u as=0.114p ps=0.98u
+ w=0.6u l=0.45u
X3666 a_18209_11890.t0 a_18119_11794# VSS.t447 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3667 a_46530_11798.t0 a_46225_12194.t2 VSS.t1161 VSS.t1160 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3668 VDD.t336 a_10028_6433.t2 a_9989_6531.t0 VDD.t141 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3669 a_8950_20473.t1 CLK.t61 VDD.t763 VDD.t762 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3670 a_2378_17807.t0 a_2021_17734.t4 VDD.t792 VDD.t752 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3671 a_35880_9093.t0 a_35030_9273.t2 a_34621_9334.t2 VDD.t150 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3672 a_31083_3750.t4 a_29957_3694.t2 6MSB_0.OUTP.t54 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3673 a_36681_20494.t1 a_35880_20293.t2 VDD.t797 VDD.t793 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3674 a_1178_9017.t2 a_n2042_972.t17 a_1279_9314.t1 VSS.t1275 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3675 VDD.t288 VDD.t1521 a_1995_6439.t2 VDD.t143 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X3676 a_43418_3714.t0 a_43201_3694.t2 VSS.t1970 VSS.t1969 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3677 VDD.t845 a_16548_20433.t2 a_16509_20531.t0 VDD.t7 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3678 a_26665_17794.t0 a_2033_24727.t8 VSS.t3520 VSS.t3519 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X3679 VDD.t646 VDD.t1641 a_14775_616.t0 VDD.t444 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3680 a_14218_20217.t1 a_13930_20198.t2 VSS.t3112 VSS.t3113 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3681 6MSB_0.OUTN.t72 a_49938_14914.t2 a_50643_14950.t7 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3682 a_20239_14994.t0 a_521_25453.t7 a_20145_14994.t1 VDD.t736 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X3683 a_42400_11893.t0 a_41550_12073.t2 a_41141_12134.t2 VDD.t91 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3684 a_18209_690.t2 a_18119_594# VSS.t2639 VSS.t2643 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3685 a_50809_3490.t3 a_50719_3394# VSS.t3491 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3686 a_30161_3694.t0 a_29360_3493.t2 VSS.t1913 VSS.t1914 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X3687 a_n2852_3612.t0 X9.t3 a_n2946_3612.t1 VSS.t2312 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.2176p
+ ps=1.96u w=0.64u l=0.13u
X3688 a_22840_693.t1 a_21990_873.t2 a_22746_693.t0 VSS.t2122 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3689 VDD.t1390 VDD.t1389 a_47375_17416.t1 VDD.t905 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3690 VDD.t203 a_16320_9093.t2 a_16917_9294.t1 VDD.t159 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3691 a_30378_6514.t0 a_30161_6494.t2 VSS.t1657 VSS.t1656 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3692 a_10028_833.t0 a_9800_693.t2 a_10219_616.t0 VSS.t2073 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3693 6MSB_0.OUTP.t4 a_49517_17694.t2 a_50643_17750.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3694 a_1178_11817.t1 a_890_11798.t2 VSS.t2691 VSS.t2692 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3695 a_21389_6216.t0 a_20839_6514.t3 a_21295_6216.t0 VSS.t1612 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3696 a_18209_690.t6 a_18119_594# a_18043_950.t9 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3697 a_1735_3416.t1 a_1279_3714.t3 VDD.t453 VDD.t303 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3698 a_8255_9016.t1 a_7799_9314.t3 VDD.t179 VDD.t162 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3699 VSS.t1294 a_n2770_240.t8 a_7105_9394.t0 VSS.t3365 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3700 a_11523_14950.t2 VSS.t431 VSS.t528 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X3701 VDD.t791 VDD.t1273 a_8255_11816.t1 VDD.t17 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3702 a_5003_6550.t1 a_3877_6494.t2 6MSB_0.OUTP.t59 VSS.t1199 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3703 a_39705_3794.t0 a_4321_24727.t3 VSS.t2932 VSS.t2931 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X3704 VSS.t952 VSS.t951 a_11523_3750.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3705 VSS.t4236 a_5079_3394# a_5169_3490.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3706 a_2021_12134.t3 a_1995_12039.t3 VDD.t1436 VDD.t765 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X3707 VSS.t713 VSS.t712 a_18043_9350.t3 VSS.t147 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3708 a_51440_25469.t2 a_50205_25015.t2 6MSB_0.OUTN.t2 VSS.t2593 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3709 VSS.t1495 a_890_6198.t2 a_1178_6217.t0 VSS.t1496 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X3710 a_15350_3429.t0 a_15572_3760.t3 a_15035_3639.t0 VSS.t1847 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3711 a_44123_20550.t4 a_42997_20494.t2 6MSB_0.OUTP.t100 VSS.t2889 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3712 a_34595_17639.t0 a_35030_17673.t3 a_34335_17416.t1 VSS.t3277 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3713 a_2021_14934.t0 a_1995_14839.t3 VSS.t2604 VSS.t2603 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3714 a_33490_14598.t0 a_33185_14994.t2 VSS.t3320 VSS.t3319 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3715 VDD.t20 a_9800_11893.t2 a_10397_12094.t1 VDD.t17 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3716 a_50643_3750.t8 a_50719_3394# a_50809_3490.t5 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3717 a_26665_6594.t0 a_2033_24727.t4 VSS.t2526 VSS.t2525 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X3718 a_15470_20473.t1 CLK.t60 VDD.t845 VDD.t7 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3719 VDD.t712 a_42400_693.t2 a_42997_894.t1 VDD.t448 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3720 VDD.t607 a_n2347_1368.t2 a_n2042_972.t1 VDD.t597 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X3721 VSS.t233 VSS.t115 a_5003_20550.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3722 a_46530_598.t0 a_46225_994.t2 VSS.t1764 VSS.t2223 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X3723 a_34335_11816.t3 a_35132_12160.t3 a_34595_12039.t1 VDD.t66 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3724 a_41115_839.t1 a_41550_873.t3 a_41498_1007.t0 VDD.t448 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3725 a_5003_950.t9 a_5079_594# a_5169_690.t7 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3726 VSS.t831 VSS.t829 VSS.t830 VSS.t286 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3727 VDD.t480 a_2430_3673.t3 a_2532_3760.t1 VDD.t303 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3728 VDD.t186 a_8950_9273.t3 a_9052_9360.t1 VDD.t162 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3729 a_44289_20290.t7 a_44199_20194# a_44123_20550.t8 VSS.t3158 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3730 VSS.t2413 a_44199_14594# a_44289_14690.t0 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3731 a_50643_9350.t5 a_50719_8994# a_50809_9090.t6 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3732 a_16509_3731.t0 a_15572_3760.t2 a_16320_3493.t0 VDD.t299 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3733 a_14319_9314.t0 a_n2042_972.t15 VDD.t160 VDD.t159 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X3734 a_18209_3490.t1 a_18119_3394# VSS.t2393 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3735 a_5169_3490.t4 a_5079_3394# a_5003_3750.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3736 a_24729_14690.t1 a_24639_14594# VSS.t4156 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3737 VSS.t2036 VDD.t1621 a_1829_616.t0 VSS.t3946 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3738 a_14319_3714.t2 a_13930_3398.t2 VDD.t505 VDD.t299 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X3739 VSS.t518 VSS.t516 a_44123_14950.t1 VSS.t517 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3740 a_48070_12073.t1 CLK.t32 VDD.t114 VDD.t1 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3741 a_15035_6439.t1 a_15470_6473.t3 a_14775_6216.t3 VSS.t1593 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3742 VSS.t3068 a_11599_594# a_11689_690.t1 VSS.t3067 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3743 a_37769_17490.t6 a_37679_17394# a_37603_17750.t9 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3744 a_5003_20550.t3 a_5079_20194# a_5169_20290.t4 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3745 6MSB_0.OUTN.t13 a_43418_6514.t2 a_44123_6550.t6 VSS.t1130 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3746 VDD.t1026 a_3280_20293.t2 a_3877_20494.t1 VDD.t5 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3747 a_8830_3429.t1 a_8541_3734.t4 a_8767_3429.t0 VSS.t1821 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3748 a_29957_9294.t1 a_29360_9093.t2 VDD.t230 VDD.t153 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X3749 VSS.t864 VSS.t657 a_50643_6550.t3 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3750 a_2310_11829.t1 a_2021_12134.t4 a_2247_11829.t0 VSS.t2694 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3751 VDD.t981 a_48949_26480.t3 a_49051_26480.t1 VDD.t13 sg13_lv_pmos ad=1.4292p pd=9.04u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3752 VSS.t1662 a_33185_6594.t2 a_33490_6198.t0 VSS.t1661 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3753 a_2033_24727.t1 a_1997_24701.t2 VDD.t1742 VDD.t76 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X3754 a_21295_14616.t3 a_22092_14960.t3 a_21555_14839.t0 VDD.t736 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3755 a_20450_11798.t1 a_20145_12194.t2 VDD.t35 VDD.t34 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3756 VDD.t67 a_n2044_1752.t4 a_33279_12194.t0 VDD.t66 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3757 a_31249_3490.t2 a_31159_3394# VSS.t4257 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3758 a_37769_9090.t2 a_37679_8994# VSS.t3588 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3759 VSS.t1561 VDD.t1527 a_8349_6216.t0 VSS.t3886 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3760 VSS.t2846 a_20145_20594.t2 a_20450_20198.t0 VSS.t2845 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3761 a_42400_20293.t0 a_41550_20473.t2 a_41141_20534.t3 VDD.t801 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3762 VDD.t212 a_23068_9233.t2 a_23029_9331.t0 VDD.t156 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3763 VDD.t1690 VDD.t1687 a_46919_914.t2 VDD.t4 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X3764 a_44123_3750.t0 VSS.t940 VSS.t941 VSS.t514 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3765 a_34335_14616.t0 a_33879_14914.t3 VDD.t1754 VDD.t846 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3766 VSS.t823 a_18119_6194# a_18209_6290.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3767 a_44123_6550.t4 a_42997_6494.t2 6MSB_0.OUTP.t70 VSS.t1165 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3768 a_8950_3673.t1 CLK.t14 VDD.t495 VDD.t301 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3769 VDD.t1013 VDD.t1323 a_8255_20216.t3 VDD.t762 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3770 a_16548_14833.t1 VDD.t1407 VDD.t888 VDD.t887 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X3771 a_31083_6550.t0 VSS.t789 VSS.t790 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3772 a_43201_6494.t0 a_42400_6293.t2 VSS.t1708 VSS.t1709 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X3773 a_18209_17490.t0 a_18119_17394# VSS.t296 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3774 a_46530_17398.t0 a_46225_17794.t2 VSS.t3240 VSS.t4292 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X3775 VSS.t561 a_31159_14594# a_31249_14690.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3776 VSS.t639 VSS.t129 a_44123_12150.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3777 a_14869_20216.t0 a_14319_20514.t3 a_14775_20216.t3 VSS.t4152 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3778 a_49109_17731.t0 a_48172_17760.t2 a_48920_17493.t1 VDD.t905 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3779 a_43418_9314.t0 a_43201_9294.t2 VSS.t1458 VSS.t1457 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3780 a_2021_20534.t2 a_1995_20439.t3 VDD.t1167 VDD.t5 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X3781 a_41115_17639.t1 a_41550_17673.t3 a_41498_17807.t0 VDD.t812 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3782 a_31083_3750.t7 a_31159_3394# a_31249_3490.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3783 VDD.t1785 a_9800_20293.t2 a_10397_20494.t1 VDD.t762 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3784 a_30161_9294.t0 a_29360_9093.t2 VSS.t1399 VSS.t1400 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X3785 a_50809_9090.t3 a_50719_8994# VSS.t2897 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3786 a_1995_12039.t1 a_2430_12073.t3 a_2378_12207.t0 VDD.t765 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3787 a_1829_11816.t0 a_1279_12114.t3 a_1735_11816.t3 VSS.t4183 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3788 a_11689_11890.t3 a_11599_11794# VSS.t3484 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3789 VDD.t670 a_23641_894.t2 a_23858_914.t1 VDD.t458 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3790 a_34335_20216.t2 a_35132_20560.t3 a_34595_20439.t1 VDD.t793 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3791 VDD.t753 a_3508_17633.t2 a_3469_17731.t0 VDD.t752 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3792 VSS.t838 VSS.t837 a_24563_6550.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3793 VDD.t311 a_26970_6198.t2 a_27359_6514.t2 VDD.t137 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3794 a_1178_17417.t1 a_890_17398.t2 VSS.t3356 VSS.t3357 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3795 a_37603_20550.t9 a_36898_20514.t2 6MSB_0.OUTN.t8 VSS.t4117 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3796 a_21295_17416.t1 a_20839_17714.t3 VDD.t1007 VDD.t737 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3797 a_1735_9016.t1 a_1279_9314.t3 VDD.t134 VDD.t122 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3798 VSS.t1979 a_n2951_2880.t2 a_n2646_2484.t0 VSS.t1978 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3799 a_42400_693.t0 a_41550_873.t2 a_41141_934.t2 VDD.t448 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3800 a_41550_14873.t0 CLK.t41 VSS.t2658 VSS.t3654 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X3801 a_44123_12150.t3 a_44199_11794# a_44289_11890.t6 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3802 VSS.t4085 a_5079_8994# a_5169_9090.t1 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3803 VSS.t709 VSS.t652 a_11523_9350.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X3804 a_8515_3639.t1 a_8950_3673.t3 a_8898_3807.t0 VDD.t301 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3805 a_37769_14690.t0 a_37679_14594# VSS.t567 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3806 VSS.t673 a_50719_11794# a_50809_11890.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3807 a_44289_3490.t6 a_44199_3394# a_44123_3750.t9 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3808 VSS.t2850 a_585_14994.t2 a_890_14598.t0 VSS.t2849 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X3809 a_15350_9029.t0 a_15572_9360.t3 a_15035_9239.t0 VSS.t1334 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3810 a_11689_690.t1 a_11599_594# VSS.t3065 VSS.t3066 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3811 a_20738_3417.t1 a_n2042_2484.t14 a_20839_3714.t0 VSS.t1787 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3812 a_41498_17807.t0 a_41141_17734.t4 VDD.t1063 VDD.t812 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3813 a_5169_14690.t7 a_5079_14594# a_5003_14950.t4 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3814 a_50643_9350.t8 a_50719_8994# a_50809_9090.t5 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3815 a_49836_24954.t0 VDD.t1289 VDD.t992 VDD.t813 sg13_lv_pmos ad=79.8f pd=0.8u as=1.4292p ps=9.04u
+ w=0.42u l=0.13u
X3816 a_2378_6607.t0 a_2021_6534.t4 VDD.t288 VDD.t143 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3817 a_29549_931.t0 a_28612_960.t2 a_29360_693.t0 VDD.t456 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3818 a_2378_12207.t0 a_2021_12134.t4 VDD.t876 VDD.t765 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3819 a_31249_6290.t6 a_31159_6194# a_31083_6550.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3820 a_36898_12114.t0 a_36681_12094.t2 VSS.t1121 VSS.t1120 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3821 VDD.t167 a_2430_9273.t3 a_2532_9360.t1 VDD.t122 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3822 VDD.t617 VDD.t1621 a_1995_839.t2 VDD.t462 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X3823 a_21555_3639.t0 a_21990_3673.t3 a_21295_3416.t3 VSS.t1879 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3824 a_2430_17673.t1 CLK.t55 VDD.t753 VDD.t752 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3825 a_30161_17694.t1 a_29360_17493.t2 VDD.t1046 VDD.t733 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3826 VSS.t1062 a_24639_594# a_24729_690.t3 VSS.t3137 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3827 a_33879_3714.t0 a_n2042_2484.t12 a_33778_3417.t0 VSS.t1782 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3828 a_11689_3490.t1 a_11599_3394# VSS.t3019 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3829 a_5169_9090.t4 a_5079_8994# a_5003_9350.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3830 a_16509_9331.t0 a_15572_9360.t2 a_16320_9093.t0 VDD.t159 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3831 a_18209_9090.t1 a_18119_8994# VSS.t3506 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3832 VSS.t3997 a_50719_594# a_50809_690.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3833 VDD.t1713 VSS.t313 a_33279_20594.t0 VDD.t793 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3834 VDD.t1056 a_10028_17633.t2 a_9989_17731.t0 VDD.t741 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3835 VDD.t732 a_48070_14873.t3 a_48172_14960.t1 VDD.t3 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3836 a_40298_11817.t1 a_40010_11798.t2 VSS.t1138 VSS.t1137 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3837 6MSB_0.OUTP.t123 a_29957_20494.t2 a_31083_20550.t6 VSS.t3461 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3838 a_20450_20198.t1 a_20145_20594.t2 VDD.t12 VDD.t11 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3839 a_31083_17750.t2 VSS.t396 VSS.t402 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X3840 VDD.t112 VDD.t1467 a_47375_11816.t1 VDD.t1 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3841 a_14319_9314.t2 a_13930_8998.t2 VDD.t193 VDD.t159 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X3842 VDD.t1155 a_7410_17398.t2 a_7799_17714.t2 VDD.t741 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3843 a_34621_3734.t0 a_34595_3639.t3 VSS.t1928 VSS.t1927 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3844 a_4298_14914.t1 a_4081_14894.t2 VDD.t1711 VDD.t817 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X3845 VDD.t928 a_26970_14598.t2 a_27359_14914.t0 VDD.t884 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3846 VSS.t2471 VDD.t1273 a_8349_11816.t0 VSS.t3703 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3847 a_20839_6514.t0 a_n2646_2484.t15 a_20738_6217.t0 VSS.t1526 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3848 a_29588_17633.t0 VDD.t1363 VDD.t735 VDD.t733 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X3849 a_37769_690.t6 a_37679_594# a_37603_950.t9 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3850 VSS.t1515 a_n2646_2484.t9 a_7105_3794.t0 VSS.t1514 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3851 a_41141_14934.t2 a_41115_14839.t3 VSS.t3815 VSS.t4263 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3852 VSS.t3039 a_1201_24685.t2 a_1253_24711.t0 VSS.t3038 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X3853 a_11523_12150.t4 a_10397_12094.t2 6MSB_0.OUTP.t82 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3854 a_8830_9029.t1 a_8541_9334.t4 a_8767_9029.t0 VSS.t1313 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3855 a_44289_6290.t2 a_44199_6194# VSS.t4045 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3856 a_50643_950.t0 VSS.t1031 VSS.t1032 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3857 a_23259_20216.t0 VDD.t1339 VSS.t2983 VSS.t3756 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3858 a_2310_17429.t0 a_2021_17734.t4 a_2247_17429.t0 VSS.t2472 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X3859 VSS.t2411 a_44199_14594# a_44289_14690.t2 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3860 a_11523_3750.t2 VSS.t946 VSS.t947 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X3861 VSS.t323 VSS.t289 a_44123_20550.t3 VSS.t290 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3862 a_16548_3633.t1 VDD.t1585 VDD.t510 VDD.t299 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X3863 a_24729_14690.t3 a_24639_14594# VSS.t4159 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3864 VSS.t896 VSS.t893 VSS.t895 VSS.t894 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X3865 a_31249_9090.t2 a_31159_8994# VSS.t2505 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3866 a_29360_20293.t0 a_28510_20473.t2 a_29266_20293.t0 VSS.t2954 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3867 6MSB_0.OUTN.t35 a_17338_14914.t2 a_18043_14950.t5 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3868 a_24563_12150.t1 a_23437_12094.t2 6MSB_0.OUTP.t97 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3869 VDD.t577 a_43201_3694.t2 a_43418_3714.t1 VDD.t282 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3870 a_1997_24905.t0 a_1963_25289.t2 VSS.t3473 VSS.t3470 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X3871 a_1995_20439.t0 a_2430_20473.t3 a_2378_20607.t0 VDD.t5 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3872 a_36477_12094.t0 a_35880_11893.t2 VSS.t1109 VSS.t1108 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3873 a_49938_914.t0 a_49721_894.t2 VSS.t2248 VSS.t2247 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X3874 VSS.t2085 a_13625_994.t2 a_13930_598.t0 VSS.t2084 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X3875 VDD.t898 a_35030_17673.t3 a_35132_17760.t1 VDD.t893 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X3876 VSS.t814 a_11599_6194# a_11689_6290.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3877 a_50600_26513.t1 a_49799_26830.t2 VDD.t828 VDD.t13 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3878 VSS.t3308 a_44199_3394# a_44289_3490.t2 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3879 a_8950_9273.t1 CLK.t30 VDD.t186 VDD.t162 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X3880 a_44123_6550.t7 a_44199_6194# a_44289_6290.t4 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3881 VDD.t388 a_30161_6494.t2 a_30378_6514.t1 VDD.t137 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3882 VDD.t691 VDD.t1667 a_34335_616.t1 VDD.t454 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X3883 a_50809_6290.t1 a_50719_6194# VSS.t2796 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3884 VDD.t838 a_13930_17398.t2 a_14319_17714.t0 VDD.t748 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3885 a_37769_690.t2 a_37679_594# VSS.t4105 VSS.t4107 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3886 a_44123_20550.t3 a_44199_20194# a_44289_20290.t6 VSS.t3161 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3887 a_31083_9350.t1 a_29957_9294.t2 6MSB_0.OUTP.t29 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X3888 VSS.t3320 a_n2648_3264.t4 a_33185_14994.t0 VSS.t3417 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X3889 VDD.t468 a_33490_3398.t2 a_33879_3714.t2 VDD.t290 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3890 a_29360_17493.t0 a_28510_17673.t2 a_28101_17734.t1 VDD.t733 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X3891 a_31083_9350.t7 a_31159_8994# a_31249_9090.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3892 a_890_14598.t1 a_585_14994.t2 VDD.t958 VDD.t817 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3893 a_37769_11890.t4 a_37679_11794# a_37603_12150.t8 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3894 VDD.t704 a_40010_598.t2 a_40399_914.t0 VDD.t448 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3895 VDD.t477 a_n2042_2484.t16 a_7799_3714.t1 VDD.t301 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3896 a_1829_17416.t0 a_1279_17714.t3 a_1735_17416.t1 VSS.t3416 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3897 a_11689_6290.t7 a_11599_6194# a_11523_6550.t8 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3898 a_11689_17490.t3 a_11599_17394# VSS.t2358 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3899 VDD.t313 a_20450_6198.t2 a_20839_6514.t2 VDD.t139 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3900 VDD.t1712 a_4081_14894.t2 a_4298_14914.t1 VDD.t817 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3901 a_2378_20607.t0 a_2021_20534.t4 VDD.t1040 VDD.t5 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3902 a_11523_14950.t1 a_10397_14894.t2 6MSB_0.OUTP.t67 VSS.t1207 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3903 VDD.t1080 VDD.t1417 a_28075_14839.t2 VDD.t884 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X3904 VDD.t944 a_n2044_1752.t12 a_33879_14914.t1 VDD.t846 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3905 VDD.t291 a_n2646_2484.t5 a_33279_3794.t0 VDD.t290 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3906 a_23437_14894.t0 a_22840_14693.t2 VSS.t2699 VSS.t2698 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3907 a_29588_6433.t1 a_29360_6293.t2 a_29779_6216.t0 VSS.t1649 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X3908 6MSB_0.OUTP.t12 a_16917_14894.t2 a_18043_14950.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3909 a_34910_11829.t0 a_35132_12160.t3 a_34595_12039.t0 VSS.t1097 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X3910 a_33778_6217.t1 a_n2646_2484.t13 a_33879_6514.t0 VSS.t1523 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3911 a_n2342_2100.t0 X10.t2 VDD.t834 VDD.t597 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p ps=2.36u
+ w=0.84u l=0.13u
X3912 a_26665_20594.t0 a_2033_24727.t9 VSS.t3092 VSS.t3091 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X3913 a_40949_616.t0 a_40399_914.t3 a_40855_616.t0 VSS.t2201 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3914 a_51440_26253.t5 4LSB_weighted_0.VBIAS a_51683_26669.t2 VSS.t4059 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X3915 6MSB_0.OUTN.t87 a_50396_26489.t2 a_51440_26253.t3 VSS.t2594 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3916 a_3280_14693.t1 a_2430_14873.t2 a_3186_14693.t0 VSS.t2854 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3917 a_7410_598.t0 a_7105_994.t2 VSS.t1775 VSS.t2055 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X3918 VSS.t424 a_50719_17394# a_50809_17490.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3919 a_14218_11817.t1 a_n2770_240.t15 a_14319_12114.t0 VSS.t3378 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3920 a_8515_9239.t0 a_8950_9273.t3 a_8898_9407.t0 VDD.t162 sg13_lv_pmos ad=79.8f pd=0.8u as=54.6f
+ ps=0.68u w=0.42u l=0.13u
X3921 a_44289_9090.t6 a_44199_8994# a_44123_9350.t9 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3922 VDD.t140 a_n2042_972.t6 a_20239_6594.t0 VDD.t139 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X3923 a_14218_617.t1 a_13930_598.t2 VSS.t2087 VSS.t2086 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X3924 a_43418_3714.t1 a_43201_3694.t2 VDD.t576 VDD.t282 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3925 VSS.t2397 a_18119_3394# a_18209_3490.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3926 a_50027_26708.t1 VDD.t1297 VDD.t981 VDD.t13 sg13_lv_pmos ad=79.8f pd=0.8u as=1.4292p ps=9.04u
+ w=0.42u l=0.13u
X3927 a_20738_9017.t1 a_n2042_972.t14 a_20839_9314.t0 VSS.t1269 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3928 a_24729_6290.t1 a_24639_6194# VSS.t4141 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3929 VDD.t382 a_29360_6293.t2 a_29588_6433.t0 VDD.t137 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3930 a_46919_6514.t1 a_n2646_2484.t11 a_46818_6217.t0 VSS.t1518 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3931 a_36898_17714.t0 a_36681_17694.t2 VSS.t2725 VSS.t2724 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3932 a_49109_12131.t0 a_48172_12160.t2 a_48920_11893.t0 VDD.t1 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X3933 a_30378_6514.t1 a_30161_6494.t2 VDD.t387 VDD.t137 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X3934 a_5169_17490.t4 a_5079_17394# a_5003_17750.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3935 a_41115_12039.t1 a_41550_12073.t3 a_41498_12207.t0 VDD.t91 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X3936 a_40949_11816.t0 a_40399_12114.t3 a_40855_11816.t0 VSS.t1132 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X3937 a_21555_9239.t1 a_21990_9273.t3 a_21295_9016.t2 VSS.t1365 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3938 a_47661_6534.t0 a_47635_6439.t3 VSS.t1722 VSS.t1721 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3939 a_34595_20439.t0 a_35030_20473.t3 a_34335_20216.t3 VSS.t2553 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X3940 a_11689_9090.t1 a_11599_8994# VSS.t4267 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3941 a_33879_9314.t0 a_n2042_972.t12 a_33778_9017.t0 VSS.t1264 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X3942 VDD.t1062 a_42628_17633.t2 a_42589_17731.t0 VDD.t812 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=52.5f ps=0.67u w=0.42u l=0.13u
X3943 a_51683_26669.t2 VSS.t135 VSS.t139 VSS.t136 sg13_hv_nmos ad=57f pd=0.68u as=0.102p ps=1.28u
+ w=0.3u l=0.45u
X3944 a_40298_17417.t0 a_40010_17398.t2 VSS.t4136 VSS.t4135 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X3945 VSS.t3052 a_18119_14594# a_18209_14690.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3946 a_34621_9334.t0 a_34595_9239.t3 VSS.t1415 VSS.t1414 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X3947 VSS.t4037 a_24639_3394# a_24729_3490.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3948 VSS.t3340 VDD.t1357 a_8349_17416.t0 VSS.t3700 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3949 VDD.t766 a_3508_12033.t2 a_3469_12131.t0 VDD.t765 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3950 VSS.t697 VSS.t696 a_44123_9350.t1 VSS.t517 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X3951 a_24563_6550.t2 VSS.t824 VSS.t840 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X3952 a_15061_934.t0 a_15035_839.t3 VSS.t2091 VSS.t2090 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X3953 a_21295_11816.t1 a_20839_12114.t3 VDD.t39 VDD.t34 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X3954 a_48348_26907.t0 X2.t0 a_48254_26907.t2 VSS.t3620 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3955 a_11523_17750.t7 a_10397_17694.t2 6MSB_0.OUTP.t52 VSS.t1205 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3956 a_44289_14690.t7 a_44199_14594# a_44123_14950.t4 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3957 a_50643_6550.t0 VSS.t799 VSS.t800 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X3958 a_20145_12194.t0 a_521_25453.t6 VSS.t2305 VSS.t2304 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X3959 a_11523_9350.t2 VSS.t649 VSS.t711 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X3960 VDD.t1632 VDD.t1629 a_7799_914.t2 VDD.t460 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p ps=1.5u
+ w=1.12u l=0.13u
X3961 a_16548_9233.t1 VDD.t1489 VDD.t199 VDD.t159 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X3962 VDD.t525 a_21990_3673.t3 a_22092_3760.t1 VDD.t297 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X3963 a_41498_12207.t0 a_41141_12134.t4 VDD.t98 VDD.t91 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3964 a_50643_3750.t7 a_50719_3394# a_50809_3490.t4 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3965 VSS.t4060 4LSB_weighted_0.VBIAS a_51683_26669.t0 VSS.t4059 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X3966 a_37769_20290.t4 a_37679_20194# a_37603_20550.t6 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3967 a_31083_17750.t8 a_31159_17394# a_31249_17490.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3968 VSS.t4249 a_37679_14594# a_37769_14690.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3969 a_5003_950.t8 a_5079_594# a_5169_690.t5 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3970 a_41550_17673.t1 CLK.t49 VDD.t1062 VDD.t812 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3971 VDD.t264 a_43201_9294.t2 a_43418_9314.t1 VDD.t147 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X3972 a_2378_1007.t0 a_2021_934.t4 VDD.t617 VDD.t462 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X3973 a_4321_24727.t1 a_4285_24701.t2 VDD.t816 VDD.t77 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X3974 a_24563_17750.t1 a_23437_17694.t2 6MSB_0.OUTP.t125 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3975 VDD.t1144 a_n2648_3264.t10 a_46919_17714.t1 VDD.t905 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3976 a_18209_14690.t2 a_18119_14594# VSS.t3051 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3977 VDD.t364 VDD.t1539 a_21295_6216.t1 VDD.t139 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X3978 a_31249_690.t7 a_31159_594# a_31083_950.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X3979 a_36477_17694.t0 a_35880_17493.t2 VSS.t2719 VSS.t2718 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X3980 VSS.t4285 a_44199_8994# a_44289_9090.t2 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X3981 a_2430_12073.t1 CLK.t39 VDD.t766 VDD.t765 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X3982 a_30161_12094.t1 a_29360_11893.t2 VDD.t62 VDD.t50 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X3983 VDD.t305 a_46530_6198.t2 a_46919_6514.t2 VDD.t0 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3984 a_48157_24737.t0 X3.t0 a_48063_24737.t2 VSS.t3584 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X3985 VDD.t1143 a_46530_17398.t2 a_46919_17714.t2 VDD.t905 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X3986 a_43418_14914.t1 a_43201_14894.t2 VDD.t858 VDD.t810 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X3987 VSS.t1179 VDD.t1467 a_47469_11816.t0 VSS.t3697 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3988 VDD.t18 a_10028_12033.t2 a_9989_12131.t0 VDD.t17 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X3989 VDD.t325 a_3280_6293.t2 a_3877_6494.t1 VDD.t143 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3990 VSS.t2091 VDD.t1641 a_14869_616.t0 VSS.t3958 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X3991 a_31083_12150.t2 VSS.t454 VSS.t632 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X3992 a_890_598.t1 a_585_994.t2 VDD.t463 VDD.t462 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X3993 a_50643_14950.t9 a_49938_14914.t2 6MSB_0.OUTN.t72 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X3994 VDD.t789 a_7410_11798.t2 a_7799_12114.t0 VDD.t17 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3995 a_51683_26669.t0 VSS.t135 VSS.t137 VSS.t136 sg13_hv_nmos ad=57f pd=0.68u as=0.102p ps=1.28u
+ w=0.3u l=0.45u
X3996 VSS.t4025 a_4081_14894.t2 a_4298_14914.t0 VSS.t4024 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X3997 VDD.t151 a_33490_8998.t2 a_33879_9314.t2 VDD.t150 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X3998 a_14775_3416.t2 a_15572_3760.t3 a_15035_3639.t1 VDD.t299 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X3999 a_31249_17490.t5 a_31159_17394# a_31083_17750.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4000 a_29588_12033.t1 VDD.t1453 VDD.t58 VDD.t50 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4001 VDD.t708 a_42628_833.t2 a_42589_931.t0 VDD.t448 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4002 VDD.t479 a_n2042_2484.t17 a_1279_3714.t2 VDD.t303 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4003 VDD.t133 a_n2042_972.t2 a_46319_6594.t0 VDD.t0 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4004 a_48638_24352.t0 a_48860_23938.t3 a_48323_23895.t0 VSS.t2520 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4005 a_17121_14894.t0 a_16320_14693.t2 VSS.t2715 VSS.t2716 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4006 VSS.t57 a_23641_12094.t2 a_23858_12114.t0 VSS.t56 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4007 VDD.t164 a_n2042_972.t16 a_7799_9314.t1 VDD.t162 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4008 a_n2042_2484.t1 a_n2347_2880.t2 VDD.t287 VDD.t286 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4009 a_40298_3417.t1 a_n2042_2484.t11 a_40399_3714.t0 VSS.t1781 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4010 VSS.t781 VSS.t780 a_5003_6550.t3 VSS.t116 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X4011 VSS.t3594 a_5079_594# a_5169_690.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4012 VSS.t1018 VSS.t1017 a_31083_950.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4013 a_18209_20290.t0 a_18119_20194# VSS.t120 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4014 a_8830_6229.t0 a_9052_6560.t3 a_8515_6439.t1 VSS.t1558 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X4015 a_3161_25540.t0 X7.t4 VDD.t75 VDD.t71 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2226p ps=1.535u
+ w=0.84u l=0.13u
X4016 VDD.t235 a_n2770_240.t4 a_33279_9394.t0 VDD.t150 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4017 a_43201_894.t1 a_42400_693.t2 VDD.t712 VDD.t448 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4018 6MSB_0.OUTP.t32 a_50626_25035.t2 a_51440_25469.t2 VSS.t2596 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4019 a_41115_20439.t0 a_41550_20473.t3 a_41498_20607.t0 VDD.t801 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X4020 a_46919_14914.t1 a_n2044_1752.t10 a_46818_14617.t1 VSS.t2819 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4021 a_34910_17429.t0 a_35132_17760.t3 a_34595_17639.t0 VSS.t3273 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4022 a_15061_14934.t2 a_15572_14960.t2 a_16320_14693.t1 VSS.t2767 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4023 a_2021_6534.t1 a_1995_6439.t3 VDD.t289 VDD.t143 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4024 VDD.t439 a_n2342_4060.t2 a_n2044_4040.t1 VDD.t434 sg13_lv_pmos ad=0.4256p pd=3u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4025 a_18043_9350.t5 a_17338_9314.t2 6MSB_0.OUTN.t91 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4026 a_47375_3416.t1 a_46919_3714.t3 VDD.t584 VDD.t293 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4027 a_48540_26473.t2 a_48514_26437.t3 VSS.t3230 VSS.t3109 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X4028 a_14218_17417.t2 a_n2648_3264.t15 a_14319_17714.t1 VSS.t3435 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4029 VSS.t3708 VDD.t1415 a_34429_14616.t0 VSS.t3707 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4030 VDD.t83 a_35030_12073.t3 a_35132_12160.t1 VDD.t66 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4031 VSS.t2169 a_33185_994.t2 a_33490_598.t0 VSS.t2168 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X4032 a_44123_950.t1 a_42997_894.t2 6MSB_0.OUTP.t119 VSS.t1167 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4033 a_43418_9314.t1 a_43201_9294.t2 VDD.t263 VDD.t147 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4034 a_44123_950.t7 a_44199_594# a_44289_690.t4 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4035 a_4305_24905.t0 a_4285_25305.t2 VSS.t3345 VSS.t3343 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X4036 VDD.t1023 a_3508_20433.t2 a_3469_20531.t0 VDD.t5 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4037 VSS.t3510 a_18119_8994# a_18209_9090.t2 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4038 a_1279_6514.t1 a_n2646_2484.t18 VDD.t285 VDD.t143 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4039 a_48575_24750.t0 VDD.t1293 VSS.t3746 VSS.t3745 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4040 a_1178_20217.t1 a_890_20198.t2 VSS.t3188 VSS.t3187 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X4041 a_40399_6514.t0 a_n2646_2484.t12 a_40298_6217.t0 VSS.t1520 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4042 a_21295_20216.t3 a_20839_20514.t3 VDD.t1072 VDD.t11 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4043 VDD.t1114 a_13930_11798.t2 a_14319_12114.t2 VDD.t25 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X4044 a_34335_6216.t1 a_33879_6514.t3 VDD.t393 VDD.t135 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4045 a_50809_3490.t0 a_50719_3394# VSS.t993 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4046 a_20450_598.t1 a_20145_994.t2 VDD.t459 VDD.t458 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4047 a_1995_3639.t0 a_2430_3673.t3 a_1735_3416.t2 VSS.t1796 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X4048 a_31083_3750.t1 a_29957_3694.t2 6MSB_0.OUTP.t55 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4049 a_15470_3673.t0 CLK.t13 VSS.t1855 VSS.t3678 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4050 a_40949_17416.t0 a_40399_17714.t3 a_40855_17416.t1 VSS.t4138 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4051 a_29360_11893.t0 a_28510_12073.t2 a_28101_12134.t3 VDD.t50 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4052 VSS.t2778 a_37679_6194# a_37769_6290.t1 VSS.t2335 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4053 a_31083_3750.t2 VSS.t881 VSS.t969 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4054 a_41498_20607.t0 a_41141_20534.t4 VDD.t807 VDD.t801 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4055 a_37603_14950.t7 a_37679_14594# a_37769_14690.t4 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4056 VDD.t859 a_43201_14894.t2 a_43418_14914.t1 VDD.t810 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X4057 6MSB_0.OUTN.t90 a_17338_9314.t2 a_18043_9350.t4 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4058 VSS.t1350 a_n2770_240.t6 a_20145_9394.t0 VSS.t3363 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4059 VDD.t847 a_35880_14693.t2 a_36108_14833.t1 VDD.t846 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4060 a_34621_12134.t3 a_35132_12160.t2 a_35880_11893.t1 VSS.t1101 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4061 a_29588_833.t1 VDD.t1665 VDD.t678 VDD.t456 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4062 a_14319_914.t0 a_13930_598.t2 VDD.t643 VDD.t444 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4063 a_42400_14693.t0 a_41550_14873.t2 a_42306_14693.t0 VSS.t2652 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4064 VSS.t4176 a_24639_8994# a_24729_9090.t1 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4065 a_28075_3639.t0 a_28510_3673.t3 a_28458_3807.t0 VDD.t295 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X4066 VSS.t1076 VSS.t1073 VSS.t1075 VSS.t1074 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u
+ l=0.45u
X4067 a_2430_20473.t1 CLK.t62 VDD.t1023 VDD.t5 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4068 a_33879_14914.t2 a_33490_14598.t2 VDD.t1752 VDD.t846 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.4032p ps=2.96u w=1.12u l=0.13u
X4069 VDD.t396 a_35030_6473.t3 a_35132_6560.t1 VDD.t135 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4070 a_30161_20494.t1 a_29360_20293.t2 VDD.t1719 VDD.t9 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4071 a_40010_17398.t1 a_39705_17794.t2 VDD.t1169 VDD.t812 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X4072 a_15061_3734.t1 a_15035_3639.t3 VDD.t508 VDD.t299 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4073 VSS.t875 a_5079_3394# a_5169_3490.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4074 VDD.t763 a_10028_20433.t2 a_9989_20531.t0 VDD.t762 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4075 a_31083_20550.t2 VSS.t274 VSS.t276 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X4076 a_20145_17794.t0 a_521_25453.t8 VSS.t2309 VSS.t2308 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4077 a_50643_9350.t3 a_49517_9294.t2 6MSB_0.OUTP.t51 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4078 a_17121_6494.t1 a_16320_6293.t2 VDD.t355 VDD.t127 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4079 VSS.t2799 a_50719_6194# a_50809_6290.t2 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4080 VDD.t1042 a_7410_20198.t2 a_7799_20514.t0 VDD.t762 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4081 a_679_17794.t0 a_653_546.t8 a_585_17794.t1 VDD.t752 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4082 VDD.t212 a_21990_9273.t3 a_22092_9360.t1 VDD.t156 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4083 a_29588_20433.t0 VDD.t1345 VDD.t989 VDD.t9 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4084 a_44289_17490.t6 a_44199_17394# a_44123_17750.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4085 a_50643_9350.t7 a_50719_8994# a_50809_9090.t4 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4086 a_8950_873.t0 CLK.t6 VSS.t2070 VSS.t3685 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4087 a_3893_25535.t0 X7.t3 VSS.t99 VSS.t98 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.1331p ps=1.12u
+ w=0.64u l=0.13u
X4088 VDD.t1308 VDD.t1307 a_40855_17416.t0 VDD.t812 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4089 VSS.t885 VSS.t884 VSS.t885 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4090 a_1201_24685.t0 a_1201_24910.t2 VSS.t3039 VSS.t102 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.14642p ps=1.155u w=0.55u l=0.13u
X4091 a_3280_693.t1 a_2430_873.t2 a_3186_693.t0 VSS.t2038 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4092 a_2310_20229.t1 a_2021_20534.t4 a_2247_20229.t0 VSS.t3208 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X4093 a_5169_11890.t5 a_5079_11794# a_5003_12150.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4094 a_50817_26469.t1 a_50600_26513.t2 VDD.t830 VDD.t13 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X4095 a_37603_12150.t0 VSS.t604 VSS.t605 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4096 VSS.t2447 a_8950_12073.t3 a_9052_12160.t0 VSS.t2446 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4097 a_16917_14894.t1 a_16320_14693.t2 VDD.t889 VDD.t887 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4098 VDD.t99 a_42628_12033.t2 a_42589_12131.t0 VDD.t91 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4099 a_26759_994.t0 a_2033_24727.t2 a_26665_994.t1 VDD.t456 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4100 VSS.t3739 VDD.t1389 a_47469_17416.t0 VSS.t3738 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4101 VSS.t110 4LSB_weighted_0.VBIAS a_51768_27313.t1 VSS.t4058 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X4102 a_24563_14950.t3 a_24639_14594# a_24729_14690.t4 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4103 VDD.t678 a_28510_873.t3 a_28612_960.t1 VDD.t456 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4104 VSS.t171 VSS.t164 a_51683_26669.t3 VSS.t165 sg13_hv_nmos ad=0.102p pd=1.28u as=57f ps=0.68u
+ w=0.3u l=0.45u
X4105 a_49721_14894.t0 a_48920_14693.t2 VSS.t2458 VSS.t2457 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4106 VSS.t935 VSS.t934 a_44123_3750.t1 VSS.t517 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4107 VDD.t794 a_35030_20473.t3 a_35132_20560.t1 VDD.t793 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X4108 a_14775_9016.t3 a_15572_9360.t3 a_15035_9239.t1 VDD.t159 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4109 VSS.t3411 a_23641_17694.t2 a_23858_17714.t0 VSS.t3410 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4110 VSS.t537 VSS.t536 VSS.t537 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4111 VDD.t166 a_n2042_972.t17 a_1279_9314.t2 VDD.t122 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4112 a_40298_9017.t1 a_n2042_972.t11 a_40399_9314.t1 VSS.t1263 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4113 VDD.t410 VDD.t1557 a_41115_6439.t2 VDD.t125 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X4114 VSS.t310 VSS.t309 a_11523_17750.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4115 VDD.t1017 a_13930_20198.t2 a_14319_20514.t0 VDD.t7 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4116 a_2310_6229.t1 a_2532_6560.t3 a_1995_6439.t0 VSS.t1500 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X4117 a_51453_23453.t4 a_50626_23927.t2 6MSB_0.OUTP.t39 VSS.t2299 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4118 VSS.t786 VSS.t785 a_31083_6550.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4119 a_n2248_4060.t0 X10.t5 a_n2342_4060.t1 VSS.t2582 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.2176p
+ ps=1.96u w=0.64u l=0.13u
X4120 VSS.t2266 a_18119_6194# a_18209_6290.t0 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4121 a_29360_20293.t1 a_28510_20473.t2 a_28101_20534.t0 VDD.t9 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4122 a_31083_12150.t8 a_31159_11794# a_31249_11890.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4123 a_24563_3750.t3 a_24639_3394# a_24729_3490.t6 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4124 a_3508_14833.t0 VDD.t1397 VDD.t962 VDD.t817 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4125 a_41550_12073.t1 CLK.t33 VDD.t99 VDD.t91 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4126 a_24563_14950.t0 VSS.t505 VSS.t506 VSS.t354 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4127 6MSB_0.OUTN.t68 a_30378_12114.t2 a_31083_12150.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4128 VDD.t1105 a_n2770_240.t10 a_46919_12114.t2 VDD.t1 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4129 a_40855_3416.t1 a_40399_3714.t3 VDD.t567 VDD.t282 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4130 a_1829_20216.t0 a_1279_20514.t3 a_1735_20216.t1 VSS.t3531 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4131 a_11689_20290.t3 a_11599_20194# VSS.t2669 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4132 a_31249_17490.t6 a_31159_17394# a_31083_17750.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4133 a_47375_9016.t1 a_46919_9314.t3 VDD.t269 VDD.t2 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4134 VSS.t1462 a_n2770_240.t2 a_46225_9394.t0 VSS.t2331 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4135 a_44123_6550.t1 a_42997_6494.t2 6MSB_0.OUTP.t71 VSS.t1167 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4136 a_3469_6531.t0 a_2532_6560.t2 a_3280_6293.t0 VDD.t143 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4137 a_11523_17750.t3 a_11599_17394# a_11689_17490.t4 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4138 VSS.t537 a_18119_14594# a_18209_14690.t3 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4139 a_5169_6290.t1 a_5079_6194# VSS.t4212 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4140 a_28510_6473.t0 CLK.t19 VSS.t1648 VSS.t3672 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4141 VSS.t3307 a_44199_3394# a_44289_3490.t1 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4142 VDD.t111 a_46530_11798.t2 a_46919_12114.t0 VDD.t1 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4143 a_1279_6514.t0 a_890_6198.t2 VDD.t284 VDD.t143 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4144 VSS.t2648 a_43201_14894.t2 a_43418_14914.t0 VSS.t2647 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4145 a_50809_9090.t0 a_50719_8994# VSS.t655 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4146 VSS.t1691 a_40010_6198.t2 a_40298_6217.t2 VSS.t1690 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4147 a_46530_6198.t0 a_46225_6594.t2 VSS.t1247 VSS.t1714 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X4148 a_39799_14994.t0 a_4321_24727.t7 a_39705_14994.t1 VDD.t810 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4149 a_1995_9239.t1 a_2430_9273.t3 a_1735_9016.t3 VSS.t1278 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X4150 a_26970_3398.t1 a_26665_3794.t2 VDD.t296 VDD.t295 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4151 a_37603_14950.t5 a_36898_14914.t2 6MSB_0.OUTN.t57 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4152 VDD.t831 a_50600_26513.t2 a_50817_26469.t1 VDD.t13 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4153 a_49148_14833.t0 a_48920_14693.t2 a_49339_14616.t0 VSS.t2456 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4154 a_15470_9273.t0 CLK.t29 VSS.t1343 VSS.t3662 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4155 VSS.t1436 a_39705_9394.t2 a_40010_8998.t0 VSS.t1435 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4156 VSS.t2284 a_31159_6194# a_31249_6290.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4157 a_31249_11890.t5 a_31159_11794# a_31083_12150.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4158 a_31083_9350.t2 VSS.t732 VSS.t738 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4159 a_13930_11798.t0 a_13625_12194.t2 VSS.t18 VSS.t17 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X4160 VDD.t570 a_41550_3673.t3 a_41652_3760.t1 VDD.t282 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4161 a_29779_3416.t0 VDD.t1597 VSS.t1905 VSS.t3931 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4162 VSS.t166 VSS.t164 a_51683_26669.t1 VSS.t165 sg13_hv_nmos ad=0.102p pd=1.28u as=57f ps=0.68u
+ w=0.3u l=0.45u
X4163 a_13930_6198.t1 a_13625_6594.t2 VDD.t128 VDD.t127 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4164 a_11689_3490.t3 a_11599_3394# VSS.t3022 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4165 a_34621_17734.t0 a_35132_17760.t2 a_35880_17493.t1 VSS.t3276 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4166 VSS.t2940 a_48949_27476.t3 a_49051_27563.t0 VSS.t3006 sg13_lv_nmos ad=2.02352p pd=12.38u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4167 a_28101_6534.t1 a_28075_6439.t3 VDD.t379 VDD.t137 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4168 a_44289_3490.t4 a_44199_3394# a_44123_3750.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4169 a_29957_17694.t1 a_29360_17493.t2 VDD.t1045 VDD.t733 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2014p ps=1.53u w=1.12u l=0.13u
X4170 a_28510_14873.t0 CLK.t43 VSS.t2945 VSS.t3650 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4171 VSS.t2947 a_29588_14833.t2 a_29266_14693.t1 VSS.t2946 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4172 a_28075_9239.t1 a_28510_9273.t3 a_28458_9407.t0 VDD.t153 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X4173 a_5169_20290.t6 a_5079_20194# a_5003_20550.t2 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4174 a_36898_20514.t0 a_36681_20494.t2 VSS.t2482 VSS.t2481 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4175 a_10028_14833.t1 VDD.t1403 VDD.t1220 VDD.t912 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X4176 a_16739_6216.t0 VDD.t1537 VSS.t1591 VSS.t3891 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4177 a_50643_9350.t6 a_49938_9314.t2 6MSB_0.OUTN.t94 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4178 a_18043_950.t6 a_17338_914.t2 6MSB_0.OUTN.t106 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4179 VDD.t823 VDD.t1367 a_14775_17416.t2 VDD.t748 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4180 VSS.t3553 a_24639_11794# a_24729_11890.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4181 a_10397_3694.t1 a_9800_3493.t2 VDD.t497 VDD.t301 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4182 VDD.t802 a_42628_20433.t2 a_42589_20531.t0 VDD.t801 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4183 VDD.t1022 a_20145_14994.t2 a_20450_14598.t1 VDD.t736 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4184 a_15061_9334.t1 a_15035_9239.t3 VDD.t197 VDD.t159 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4185 a_31249_6290.t4 a_31159_6194# a_31083_6550.t2 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4186 a_18043_3750.t5 a_17338_3714.t2 6MSB_0.OUTN.t127 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4187 a_40298_20217.t1 a_40010_20198.t2 VSS.t2629 VSS.t2630 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4188 VSS.t589 VSS.t588 a_24563_12150.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4189 VSS.t707 a_5079_8994# a_5169_9090.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4190 a_10601_6494.t1 a_9800_6293.t2 VDD.t339 VDD.t141 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4191 a_21581_934.t3 a_22092_960.t2 a_22840_693.t1 VSS.t2123 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4192 a_47950_3429.t1 a_47661_3734.t4 a_47887_3429.t0 VSS.t1987 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X4193 a_7698_14617.t1 a_n2044_1752.t16 a_7799_14914.t0 VSS.t2832 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4194 a_37603_14950.t9 a_37679_14594# a_37769_14690.t7 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4195 VSS.t1110 a_35880_11893.t2 a_36477_12094.t0 VSS.t1108 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4196 a_11523_3750.t8 a_11599_3394# a_11689_3490.t5 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4197 VSS.t3108 VDD.t1323 a_8349_20216.t0 VSS.t3752 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4198 a_2033_24727.t0 a_1997_24701.t2 VSS.t4167 VSS.t4166 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X4199 a_11523_20550.t4 a_10397_20494.t2 6MSB_0.OUTP.t60 VSS.t4128 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4200 a_37603_14950.t4 a_36477_14894.t2 6MSB_0.OUTP.t84 VSS.t1170 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4201 VSS.t725 VSS.t724 VSS.t725 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4202 a_17121_17694.t1 a_16320_17493.t2 VDD.t965 VDD.t748 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4203 VSS.t637 VSS.t635 VSS.t636 VSS.t415 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4204 VDD.t625 a_4081_894.t2 a_4298_914.t1 VDD.t462 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4205 a_51442_27857.t4 a_50817_27517.t2 6MSB_0.OUTP.t68 VSS.t3075 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4206 a_27815_616.t1 a_27359_914.t3 VDD.t675 VDD.t456 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4207 VSS.t1034 VSS.t1033 a_50643_950.t1 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4208 6MSB_0.OUTP.t104 a_16917_894.t2 a_18043_950.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4209 VSS.t1722 VDD.t1563 a_47469_6216.t0 VSS.t3908 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4210 VSS.t3249 a_8950_17673.t3 a_9052_17760.t0 VSS.t3248 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4211 VSS.t2601 a_1261_25305.t2 a_1201_24910.t0 VSS.t2600 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4212 a_37603_17750.t0 VSS.t329 VSS.t331 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4213 VSS.t1511 a_n2646_2484.t7 a_20145_3794.t0 VSS.t1510 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4214 6MSB_0.OUTN.t126 a_17338_3714.t2 a_18043_3750.t4 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4215 VSS.t4002 a_7105_14994.t2 a_7410_14598.t0 VSS.t4001 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4216 a_31249_14690.t0 a_31159_14594# VSS.t552 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4217 a_31083_20550.t8 a_31159_20194# a_31249_20290.t5 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4218 a_48070_3673.t1 CLK.t8 VDD.t587 VDD.t293 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4219 a_24563_20550.t1 a_23437_20494.t2 6MSB_0.OUTP.t23 VSS.t2569 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4220 a_41550_20473.t1 CLK.t56 VDD.t802 VDD.t801 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X4221 VSS.t3027 a_11599_14594# a_11689_14690.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4222 a_37769_14690.t7 a_37679_14594# a_37603_14950.t8 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4223 a_585_994.t0 a_653_546.t2 VSS.t2522 VSS.t2521 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4224 VDD.t1191 X5.t3 a_1261_25305.t1 VDD.t76 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X4225 a_36477_20494.t0 a_35880_20293.t2 VSS.t2478 VSS.t2477 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4226 a_28101_14934.t1 a_28075_14839.t3 VSS.t3325 VSS.t3324 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X4227 VSS.t1604 a_17121_6494.t2 a_17338_6514.t0 VSS.t1603 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4228 VDD.t504 a_13625_3794.t2 a_13930_3398.t1 VDD.t299 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4229 VSS.t3737 a_50027_27436.t2 a_49705_27296.t1 VSS.t3736 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4230 VSS.t500 VSS.t499 a_11523_14950.t1 VSS.t339 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4231 a_890_8998.t0 a_585_9394.t2 VSS.t1241 VSS.t1240 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X4232 a_24563_17750.t8 a_24639_17394# a_24729_17490.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4233 6MSB_0.OUTN.t59 a_4298_14914.t2 a_5003_14950.t8 VSS.t1210 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4234 a_30378_12114.t0 a_30161_12094.t2 VSS.t83 VSS.t82 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4235 a_35030_6473.t1 CLK.t18 VDD.t396 VDD.t135 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X4236 a_37603_6550.t3 a_37679_6194# a_37769_6290.t6 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4237 a_40010_11798.t1 a_39705_12194.t2 VDD.t92 VDD.t91 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4238 a_50643_950.t5 a_49938_914.t2 6MSB_0.OUTN.t113 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4239 a_9989_17731.t0 a_9052_17760.t2 a_9800_17493.t1 VDD.t741 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4240 a_21555_14839.t1 a_21990_14873.t3 a_21295_14616.t2 VSS.t3455 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4241 6MSB_0.OUTN.t77 a_23858_12114.t2 a_24563_12150.t6 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4242 VSS.t3098 a_11599_6194# a_11689_6290.t0 VSS.t2349 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4243 a_51440_26253.t1 a_50396_26489.t2 6MSB_0.OUTN.t87 VSS.t2595 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4244 VDD.t559 a_35880_3493.t2 a_36477_3694.t1 VDD.t290 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4245 a_50643_3750.t1 a_49517_3694.t2 6MSB_0.OUTP.t7 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4246 a_29549_14931.t0 a_28612_14960.t2 a_29360_14693.t1 VDD.t884 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4247 a_679_12194.t0 a_653_546.t6 a_585_12194.t1 VDD.t765 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4248 a_31249_20290.t5 a_31159_20194# a_31083_20550.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4249 a_44289_11890.t7 a_44199_11794# a_44123_12150.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4250 a_24563_9350.t3 a_24639_8994# a_24729_9090.t6 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4251 a_18043_950.t8 a_18119_594# a_18209_690.t5 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4252 VDD.t1095 a_890_17398.t2 a_1279_17714.t0 VDD.t752 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4253 VDD.t97 VDD.t1461 a_40855_11816.t1 VDD.t91 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4254 a_31249_690.t5 a_31159_594# a_31083_950.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4255 VSS.t1036 a_5079_594# a_5169_690.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4256 6MSB_0.OUTN.t48 a_30378_17714.t2 a_31083_17750.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4257 VSS.t1184 a_48070_12073.t3 a_48172_12160.t0 VSS.t1183 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4258 a_40855_9016.t1 a_40399_9314.t3 VDD.t254 VDD.t147 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4259 a_51442_27857.t0 VSS.t159 VSS.t161 VSS.t160 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4260 a_23068_17633.t1 VDD.t1377 VDD.t1216 VDD.t737 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X4261 VDD.t370 a_22840_6293.t2 a_23437_6494.t1 VDD.t139 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4262 a_40010_6198.t1 a_39705_6594.t2 VDD.t126 VDD.t125 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4263 a_48254_27219.t2 a_49051_27563.t3 a_48514_27442.t2 VDD.t14 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4264 6MSB_0.OUTP.t14 a_23437_9294.t2 a_24563_9350.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4265 a_21990_6473.t0 CLK.t20 VSS.t1622 VSS.t3671 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4266 VSS.t973 VSS.t972 a_37603_3750.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X4267 VSS.t2757 a_13625_14994.t2 a_13930_14598.t0 VSS.t2756 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4268 VSS.t4283 a_44199_8994# a_44289_9090.t1 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4269 VSS.t1043 VSS.t1041 VSS.t1043 VSS.t1042 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X4270 6MSB_0.OUTN.t112 a_49938_914.t2 a_50643_950.t4 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4271 a_34910_20229.t0 a_35132_20560.t3 a_34595_20439.t0 VSS.t2549 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4272 VDD.t473 a_n2042_2484.t14 a_20839_3714.t1 VDD.t297 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4273 a_26970_8998.t1 a_26665_9394.t2 VDD.t220 VDD.t153 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4274 a_20145_994.t0 a_521_25453.t2 VSS.t3475 VSS.t3474 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4275 a_44123_950.t3 a_44199_594# a_44289_690.t6 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4276 a_41498_6607.t0 a_41141_6534.t4 VDD.t410 VDD.t125 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4277 a_34621_3734.t1 a_34595_3639.t3 VDD.t553 VDD.t290 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4278 a_14218_20217.t2 a_n2044_4040.t14 a_14319_20514.t1 VSS.t3547 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4279 6MSB_0.OUTN.t53 a_10818_14914.t2 a_11523_14950.t9 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4280 VSS.t2003 a_49721_3694.t2 a_49938_3714.t0 VSS.t2002 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4281 a_13930_17398.t0 a_13625_17794.t2 VSS.t2328 VSS.t2327 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X4282 VDD.t257 a_41550_9273.t3 a_41652_9360.t1 VDD.t147 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4283 VDD.t707 VDD.t1677 a_41115_839.t2 VDD.t448 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X4284 a_16509_17731.t0 a_15572_17760.t2 a_16320_17493.t0 VDD.t748 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4285 6MSB_0.OUTP.t18 a_3877_14894.t2 a_5003_14950.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4286 VSS.t624 VSS.t623 a_11523_12150.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4287 a_29957_12094.t0 a_29360_11893.t2 VSS.t79 VSS.t78 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4288 a_11689_9090.t3 a_11599_8994# VSS.t4271 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4289 a_29779_9016.t0 VDD.t1501 VSS.t1391 VSS.t3867 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4290 a_16320_693.t0 a_15470_873.t2 a_15061_934.t3 VDD.t444 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4291 a_33879_3714.t1 a_n2042_2484.t12 VDD.t468 VDD.t290 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4292 a_44289_9090.t4 a_44199_8994# a_44123_9350.t2 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4293 a_3508_6433.t1 VDD.t1525 VDD.t321 VDD.t143 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4294 a_21581_6534.t1 a_21555_6439.t3 VDD.t364 VDD.t139 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4295 VSS.t3653 a_35030_14873.t3 a_35132_14960.t0 VSS.t4203 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4296 a_42628_14833.t1 VDD.t1285 VDD.t862 VDD.t810 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X4297 a_40949_20216.t0 a_40399_20514.t3 a_40855_20216.t1 VSS.t2631 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4298 a_8255_17416.t0 a_9052_17760.t3 a_8515_17639.t1 VDD.t741 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4299 VSS.t89 a_33185_12194.t2 a_33490_11798.t0 VSS.t88 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X4300 a_18043_6550.t6 a_17338_6514.t2 6MSB_0.OUTN.t38 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4301 a_11689_690.t0 a_11599_594# VSS.t1039 VSS.t3063 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4302 a_7799_3714.t0 a_n2042_2484.t16 a_7698_3417.t0 VSS.t1790 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4303 VSS.t3296 a_24639_17394# a_24729_17490.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4304 a_10397_9294.t1 a_9800_9093.t2 VDD.t187 VDD.t162 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4305 a_20839_6514.t1 a_n2646_2484.t15 VDD.t313 VDD.t139 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4306 a_21990_873.t1 CLK.t4 VDD.t663 VDD.t458 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4307 VSS.t448 VSS.t446 VSS.t447 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4308 a_31249_11890.t6 a_31159_11794# a_31083_12150.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4309 VSS.t1507 a_n2646_2484.t3 a_46225_3794.t0 VSS.t1506 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4310 VSS.t334 VSS.t332 a_24563_17750.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4311 a_47950_9029.t1 a_47661_9334.t4 a_47887_9029.t0 VSS.t1472 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X4312 VDD.t717 a_46225_994.t2 a_46530_598.t1 VDD.t4 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X4313 a_10397_894.t0 a_9800_693.t2 VSS.t2075 VSS.t2074 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4314 VSS.t2720 a_35880_17493.t2 a_36477_17694.t0 VSS.t2718 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4315 a_11523_12150.t3 a_11599_11794# a_11689_11890.t6 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4316 a_11523_9350.t8 a_11599_8994# a_11689_9090.t5 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4317 a_27909_11816.t0 a_27359_12114.t3 a_27815_11816.t0 VSS.t66 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4318 VSS.t3135 a_24639_594# a_24729_690.t2 VSS.t3134 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4319 a_49721_17694.t1 a_48920_17493.t2 VDD.t907 VDD.t905 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4320 VSS.t1251 a_n2042_972.t4 a_33185_6594.t0 VSS.t1250 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4321 VSS.t417 VSS.t414 VSS.t416 VSS.t415 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4322 a_679_6594.t0 a_653_546.t4 a_585_6594.t1 VDD.t143 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X4323 VDD.t723 a_48070_873.t3 a_48172_960.t1 VDD.t4 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4324 6MSB_0.OUTP.t110 a_10397_894.t2 a_11523_950.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4325 a_40010_20198.t1 a_39705_20594.t2 VDD.t1030 VDD.t801 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X4326 VDD.t735 a_29588_17633.t2 a_29549_17731.t0 VDD.t733 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4327 VSS.t3014 a_5079_14594# a_5169_14690.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4328 a_37603_9350.t0 VSS.t698 VSS.t699 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4329 6MSB_0.OUTP.t44 a_16917_6494.t2 a_18043_6550.t0 VSS.t1212 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4330 VSS.t796 VSS.t795 a_50643_6550.t1 VSS.t374 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4331 a_8255_6216.t3 a_9052_6560.t3 a_8515_6439.t0 VDD.t141 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4332 VSS.t1948 a_39705_3794.t2 a_40010_3398.t0 VSS.t1947 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4333 a_20145_20594.t0 a_521_25453.t9 VSS.t2311 VSS.t2310 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4334 a_679_20594.t0 a_653_546.t9 a_585_20594.t1 VDD.t5 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X4335 VDD.t375 a_26665_6594.t2 a_26970_6198.t1 VDD.t137 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4336 VSS.t1599 a_16320_6293.t2 a_16917_6494.t0 VSS.t1597 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4337 VDD.t857 VDD.t1277 a_40855_20216.t2 VDD.t801 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4338 a_44289_20290.t4 a_44199_20194# a_44123_20550.t2 VSS.t3154 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4339 a_48070_9273.t1 CLK.t24 VDD.t272 VDD.t2 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4340 VSS.t2115 a_20450_598.t2 a_20738_617.t0 VSS.t2116 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4341 a_10028_833.t1 VDD.t1635 VDD.t633 VDD.t460 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4342 a_18209_3490.t6 a_18119_3394# a_18043_3750.t9 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4343 VDD.t990 a_n2044_4040.t8 a_7199_17794.t0 VDD.t741 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4344 a_29957_12094.t1 a_29360_11893.t2 VDD.t60 VDD.t50 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4345 VSS.t1578 a_10601_6494.t2 a_10818_6514.t0 VSS.t1577 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4346 a_49608_24814.t1 a_48758_24994.t2 a_48349_25055.t1 VDD.t813 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4347 VDD.t888 a_15470_14873.t3 a_15572_14960.t1 VDD.t887 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X4348 VDD.t178 a_13625_9394.t2 a_13930_8998.t1 VDD.t159 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4349 VDD.t430 a_48920_6293.t2 a_49517_6494.t1 VDD.t0 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4350 a_50643_3750.t6 a_49938_3714.t2 6MSB_0.OUTN.t114 VSS.t1229 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4351 VDD.t1124 VDD.t1441 a_14775_11816.t1 VDD.t25 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4352 a_30378_17714.t0 a_30161_17694.t2 VSS.t3194 VSS.t3193 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4353 a_5169_14690.t2 a_5079_14594# VSS.t3013 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4354 a_50643_6550.t4 a_49938_6514.t2 6MSB_0.OUTN.t1 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4355 6MSB_0.OUTN.t125 a_23858_17714.t2 a_24563_17750.t9 VSS.t1135 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4356 VSS.t4216 a_5079_6194# a_5169_6290.t2 VSS.t2905 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4357 a_40010_598.t0 a_39705_994.t2 VSS.t1761 VSS.t2195 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X4358 a_24729_11890.t2 a_24639_11794# VSS.t3555 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4359 VDD.t245 a_35880_9093.t2 a_36477_9294.t1 VDD.t150 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4360 a_8541_17734.t3 a_8515_17639.t3 VDD.t1086 VDD.t741 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4361 a_28510_17673.t1 CLK.t51 VDD.t735 VDD.t733 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X4362 a_10397_3694.t0 a_9800_3493.t2 VSS.t1831 VSS.t1830 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4363 a_4285_24701.t1 a_4305_24905.t2 VDD.t815 VDD.t77 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.1918p
+ ps=1.5u w=0.84u l=0.13u
X4364 VSS.t4004 a_7410_14598.t2 a_7698_14617.t2 VSS.t4003 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4365 a_8515_839.t0 a_8950_873.t3 a_8255_616.t3 VSS.t2068 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X4366 VSS.t247 VSS.t245 a_11523_20550.t3 VSS.t246 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4367 VSS.t2987 a_23641_20494.t2 a_23858_20514.t0 VSS.t2986 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4368 VSS.t3237 a_48070_17673.t3 a_48172_17760.t0 VSS.t3236 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4369 VSS.t3030 a_11599_14594# a_11689_14690.t2 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4370 VSS.t563 VSS.t554 a_37603_14950.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4371 VSS.t63 a_26970_11798.t2 a_27258_11817.t0 VSS.t64 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4372 a_15287_6229.t0 VDD.t1533 VSS.t3890 VSS.t3889 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4373 VDD.t310 a_n2646_2484.t13 a_33879_6514.t1 VDD.t135 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4374 a_17121_12094.t1 a_16320_11893.t2 VDD.t30 VDD.t25 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4375 VSS.t2651 a_46225_14994.t2 a_46530_14598.t0 VSS.t2650 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4376 VSS.t748 VSS.t747 a_37603_9350.t3 VSS.t301 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X4377 VDD.t510 a_16548_3633.t2 a_16509_3731.t0 VDD.t299 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4378 VSS.t2685 a_50409_25015.t2 a_50626_25035.t0 VSS.t2684 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4379 a_34910_3429.t0 a_35132_3760.t3 a_34595_3639.t0 VSS.t1926 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4380 a_4081_14894.t0 a_3280_14693.t2 VSS.t4019 VSS.t4020 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4381 6MSB_0.OUTP.t89 a_42997_12094.t2 a_44123_12150.t5 VSS.t1166 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4382 6MSB_0.OUTN.t0 a_49938_6514.t2 a_50643_6550.t5 VSS.t1228 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4383 VDD.t494 VDD.t1575 a_8515_3639.t2 VDD.t301 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X4384 VDD.t680 a_29360_693.t2 a_29588_833.t1 VDD.t456 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4385 VDD.t644 a_13930_598.t2 a_14319_914.t0 VDD.t444 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4386 a_585_14994.t0 a_653_546.t7 VSS.t2535 VSS.t2534 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4387 a_50809_14690.t3 a_50719_14594# VSS.t3293 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4388 VDD.t158 a_n2042_972.t14 a_20839_9314.t1 VDD.t156 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4389 a_46919_6514.t0 a_n2646_2484.t11 VDD.t305 VDD.t0 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4390 6MSB_0.OUTN.t75 a_43418_14914.t2 a_44123_14950.t9 VSS.t1130 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4391 a_34621_9334.t1 a_34595_9239.t3 VDD.t240 VDD.t150 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4392 a_21870_6229.t0 a_22092_6560.t3 a_21555_6439.t1 VSS.t1611 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4393 a_31249_20290.t7 a_31159_20194# a_31083_20550.t9 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4394 VSS.t1488 a_49721_9294.t2 a_49938_9314.t0 VSS.t1487 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4395 a_36898_3714.t0 a_36681_3694.t2 VSS.t1943 VSS.t1942 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4396 a_11689_14690.t2 a_11599_14594# VSS.t3029 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4397 a_47635_3639.t0 a_48070_3673.t3 a_47375_3416.t3 VSS.t1992 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4398 a_890_3398.t0 a_585_3794.t2 VSS.t1517 VSS.t1751 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X4399 a_48323_23895.t1 a_48758_23938.t3 a_48706_23974.t0 VDD.t760 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X4400 a_11523_20550.t3 a_11599_20194# a_11689_20290.t6 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4401 a_29957_17694.t0 a_29360_17493.t2 VSS.t3225 VSS.t3224 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4402 a_24563_12150.t9 a_24639_11794# a_24729_11890.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4403 a_36299_11816.t0 VDD.t1459 VSS.t1106 VSS.t3840 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4404 a_2310_6229.t0 a_2021_6534.t4 a_2247_6229.t0 VSS.t1499 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X4405 a_37769_3490.t1 a_37679_3394# VSS.t3281 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4406 a_36069_3731.t0 a_35132_3760.t2 a_35880_3493.t0 VDD.t290 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4407 a_27909_3416.t0 a_27359_3714.t3 a_27815_3416.t0 VSS.t1899 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4408 VDD.t517 a_17121_3694.t2 a_17338_3714.t1 VDD.t299 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4409 VDD.t849 a_35880_14693.t2 a_36477_14894.t1 VDD.t846 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4410 a_33879_9314.t1 a_n2042_972.t12 VDD.t151 VDD.t150 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4411 a_14869_616.t0 a_14319_914.t3 a_14775_616.t1 VSS.t2089 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4412 a_23641_3694.t0 a_22840_3493.t2 VSS.t1885 VSS.t1886 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4413 a_4081_3694.t1 a_3280_3493.t2 VDD.t482 VDD.t303 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4414 a_15061_17734.t2 a_15035_17639.t3 VDD.t823 VDD.t748 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4415 a_9989_12131.t0 a_9052_12160.t2 a_9800_11893.t0 VDD.t17 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4416 VSS.t3581 a_31159_11794# a_31249_11890.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4417 VDD.t1145 a_40010_17398.t2 a_40399_17714.t2 VDD.t812 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X4418 a_23858_6514.t0 a_23641_6494.t2 VSS.t1629 VSS.t1628 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4419 VSS.t2077 a_9800_693.t2 a_10397_894.t0 VSS.t2076 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4420 VSS.t2759 a_13930_14598.t2 a_14218_14617.t0 VSS.t2760 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4421 VSS.t1142 VDD.t1461 a_40949_11816.t0 VSS.t3841 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4422 a_34595_6439.t1 a_35030_6473.t3 a_34335_6216.t2 VSS.t1674 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4423 a_51516_24785.t4 4LSB_weighted_0.VBIAS VSS.t4069 VSS.t4064 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X4424 a_7799_9314.t0 a_n2042_972.t16 a_7698_9017.t0 VSS.t1272 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4425 a_14869_6216.t0 a_14319_6514.t3 a_14775_6216.t0 VSS.t1585 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4426 a_23029_6531.t0 a_22092_6560.t2 a_22840_6293.t0 VDD.t139 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4427 a_48540_27537.t0 a_48514_27442.t3 VSS.t3110 VSS.t3109 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X4428 VSS.t3200 a_33185_17794.t2 a_33490_17398.t0 VSS.t3199 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4429 VDD.t875 a_890_11798.t2 a_1279_12114.t0 VDD.t765 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4430 VSS.t1815 a_7410_3398.t2 a_7698_3417.t2 VSS.t1814 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4431 VSS.t297 VSS.t295 VSS.t296 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4432 a_20738_14617.t1 a_20450_14598.t2 VSS.t2729 VSS.t2730 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4433 a_23068_12033.t1 VDD.t1447 VDD.t42 VDD.t34 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4434 VSS.t4308 a_49608_24814.t2 a_50205_25015.t0 VSS.t4279 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4435 a_34621_20534.t0 a_35132_20560.t2 a_35880_20293.t0 VSS.t2552 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4436 VDD.t457 a_n2042_2484.t5 a_26759_994.t0 VDD.t456 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4437 6MSB_0.OUTP.t8 a_23437_3694.t2 a_24563_3750.t0 VSS.t1220 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4438 a_29957_20494.t1 a_29360_20293.t2 VDD.t1717 VDD.t9 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4439 a_47375_616.t1 a_46919_914.t3 VDD.t720 VDD.t4 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4440 VDD.t549 a_33185_3794.t2 a_33490_3398.t1 VDD.t290 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4441 a_27909_17416.t0 a_27359_17714.t3 a_27815_17416.t3 VSS.t4315 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4442 VDD.t1284 VDD.t1283 a_14775_20216.t2 VDD.t7 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4443 6MSB_0.OUTP.t80 a_42997_14894.t2 a_44123_14950.t0 VSS.t1164 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4444 6MSB_0.OUTP.t56 a_10397_6494.t2 a_11523_6550.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4445 a_1735_6216.t2 a_2532_6560.t3 a_1995_6439.t1 VDD.t143 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4446 a_34621_14934.t3 a_34595_14839.t3 VDD.t1426 VDD.t846 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X4447 a_41498_1007.t0 a_41141_934.t4 VDD.t707 VDD.t448 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4448 VSS.t4069 4LSB_weighted_0.VBIAS a_51516_24785.t2 VSS.t4063 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X4449 VDD.t360 a_20145_6594.t2 a_20450_6198.t1 VDD.t139 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4450 VSS.t1498 a_n2646_2484.t2 a_n2347_2880.t0 VSS.t1497 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4451 a_16509_12131.t0 a_15572_12160.t2 a_16320_11893.t0 VDD.t25 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4452 VSS.t1571 a_9800_6293.t2 a_10397_6494.t0 VSS.t1569 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4453 a_47375_17416.t2 a_48172_17760.t3 a_47635_17639.t1 VDD.t905 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4454 a_7410_14598.t0 a_7105_14994.t2 VSS.t3422 VSS.t4000 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X4455 VSS.t3566 a_18119_11794# a_18209_11890.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4456 VSS.t4102 a_37679_594# a_37769_690.t0 VSS.t4101 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4457 VSS.t4234 a_5079_3394# a_5169_3490.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4458 a_17121_20494.t1 a_16320_20293.t2 VDD.t973 VDD.t7 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4459 a_46530_14598.t1 a_46225_14994.t2 VDD.t809 VDD.t3 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4460 a_18209_9090.t6 a_18119_8994# a_18043_9350.t9 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4461 6MSB_0.OUTN.t5 a_50205_23947.t2 a_51453_23453.t4 VSS.t3329 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4462 a_39705_12194.t0 a_4321_24727.t6 VSS.t2930 VSS.t2929 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X4463 a_5003_9350.t6 a_4298_9314.t2 6MSB_0.OUTN.t92 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4464 a_23068_3633.t1 a_22840_3493.t2 a_23259_3416.t0 VSS.t1882 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4465 a_17338_3714.t1 a_17121_3694.t2 VDD.t516 VDD.t299 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4466 a_8255_11816.t3 a_9052_12160.t3 a_8515_12039.t0 VDD.t17 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4467 a_585_9394.t0 a_653_546.t5 VSS.t3210 VSS.t3209 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4468 a_37603_20550.t0 VSS.t229 VSS.t231 VSS.t230 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4469 VSS.t2423 a_8950_20473.t3 a_9052_20560.t0 VSS.t2422 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4470 VSS.t1538 a_2430_6473.t3 a_2532_6560.t0 VSS.t1537 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4471 a_23437_6494.t0 a_22840_6293.t2 VSS.t1625 VSS.t1624 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4472 a_50809_690.t5 a_50719_594# a_50643_950.t7 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4473 a_21807_3429.t0 VDD.t1587 VSS.t3925 VSS.t3924 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4474 VDD.t467 a_n2042_2484.t11 a_40399_3714.t1 VDD.t282 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4475 a_24729_17490.t2 a_24639_17394# VSS.t3299 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4476 a_31083_14950.t7 a_31159_14594# a_31249_14690.t4 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4477 a_31083_12150.t6 a_30378_12114.t2 6MSB_0.OUTN.t68 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4478 a_10028_6433.t1 a_9800_6293.t2 a_10219_6216.t0 VSS.t1568 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4479 a_49339_14616.t0 VDD.t1267 VSS.t2455 VSS.t3818 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4480 VDD.t381 a_29588_6433.t2 a_29549_6531.t0 VDD.t137 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4481 VSS.t857 VSS.t856 a_44123_6550.t3 VSS.t130 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X4482 a_11689_14690.t7 a_11599_14594# a_11523_14950.t4 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4483 6MSB_0.OUTP.t87 a_16917_12094.t2 a_18043_12150.t5 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4484 VSS.t2427 a_3508_12033.t2 a_3186_11893.t0 VSS.t2426 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4485 a_18209_11890.t1 a_18119_11794# VSS.t3564 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4486 a_10397_9294.t0 a_9800_9093.t2 VSS.t1321 VSS.t1320 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4487 a_47950_6229.t0 a_48172_6560.t3 a_47635_6439.t1 VSS.t1689 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4488 a_3877_14894.t1 a_3280_14693.t2 VDD.t1706 VDD.t817 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4489 a_21870_14629.t1 a_21581_14934.t4 a_21807_14629.t0 VSS.t3452 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X4490 a_48829_27232.t1 a_49051_27563.t3 a_48514_27442.t1 VSS.t3186 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4491 a_46919_14914.t2 a_n2044_1752.t10 VDD.t778 VDD.t3 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4492 a_49721_12094.t1 a_48920_11893.t2 VDD.t118 VDD.t1 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4493 a_2430_6473.t0 CLK.t23 VSS.t1538 VSS.t3668 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4494 a_24563_20550.t8 a_24639_20194# a_24729_20290.t5 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4495 VSS.t4313 a_26970_17398.t2 a_27258_17417.t2 VSS.t4314 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4496 6MSB_0.OUTP.t48 a_3877_9294.t2 a_5003_9350.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4497 VDD.t655 a_17121_894.t2 a_17338_914.t1 VDD.t444 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4498 VDD.t58 a_29588_12033.t2 a_29549_12131.t0 VDD.t50 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4499 a_47635_12039.t0 a_48070_12073.t3 a_47375_11816.t3 VSS.t1182 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4500 VDD.t199 a_16548_9233.t2 a_16509_9331.t0 VDD.t159 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4501 a_8255_616.t2 a_9052_960.t3 a_8515_839.t1 VDD.t460 sg13_lv_pmos ad=0.1428p pd=1.52u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4502 a_49721_3694.t0 a_48920_3493.t2 VSS.t1998 VSS.t1999 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4503 a_37603_3750.t0 VSS.t936 VSS.t937 VSS.t330 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4504 a_9989_20531.t0 a_9052_20560.t2 a_9800_20293.t1 VDD.t762 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4505 a_34910_9029.t0 a_35132_9360.t3 a_34595_9239.t0 VSS.t1413 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4506 VDD.t337 a_9800_6293.t2 a_10028_6433.t0 VDD.t141 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4507 VDD.t1154 a_n2648_3264.t15 a_14319_17714.t2 VDD.t748 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X4508 VDD.t1054 a_n2044_4040.t2 a_46319_17794.t0 VDD.t905 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X4509 a_7799_14914.t0 a_n2044_1752.t16 a_7698_14617.t0 VSS.t2831 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4510 VDD.t185 VDD.t1479 a_8515_9239.t2 VDD.t162 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X4511 a_49938_6514.t0 a_49721_6494.t2 VSS.t1737 VSS.t1736 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4512 6MSB_0.OUTP.t41 a_42997_17694.t2 a_44123_17750.t9 VSS.t2890 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4513 a_33490_17398.t1 a_33185_17794.t2 VDD.t1034 VDD.t893 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X4514 VSS.t430 VSS.t429 VSS.t430 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4515 a_27359_12114.t1 a_n2770_240.t13 a_27258_11817.t1 VSS.t3373 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4516 a_5169_6290.t3 a_5079_6194# VSS.t4216 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4517 VDD.t648 a_16548_833.t2 a_16509_931.t0 VDD.t444 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4518 a_49109_6531.t0 a_48172_6560.t2 a_48920_6293.t0 VDD.t0 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4519 VDD.t1029 a_890_20198.t2 a_1279_20514.t0 VDD.t5 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4520 a_36681_6494.t0 a_35880_6293.t2 VSS.t1680 VSS.t1681 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4521 a_40399_6514.t1 a_n2646_2484.t12 VDD.t307 VDD.t125 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4522 6MSB_0.OUTN.t102 a_30378_20514.t2 a_31083_20550.t4 VSS.t2884 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4523 a_23068_20433.t0 VDD.t1339 VDD.t994 VDD.t11 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4524 VDD.t773 a_n2044_1752.t8 a_7199_12194.t0 VDD.t17 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4525 a_47661_934.t1 a_47635_839.t3 VDD.t721 VDD.t4 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4526 a_10818_14914.t1 a_10601_14894.t2 VDD.t917 VDD.t912 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X4527 a_44289_14690.t2 a_44199_14594# VSS.t2415 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4528 VSS.t3394 VDD.t1441 a_14869_11816.t0 VSS.t3696 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4529 a_36898_9314.t0 a_36681_9294.t2 VSS.t1430 VSS.t1429 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4530 a_17121_894.t1 a_16320_693.t2 VDD.t652 VDD.t444 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4531 a_1735_616.t1 a_1279_914.t3 VDD.t615 VDD.t462 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4532 a_41115_3639.t0 a_41550_3673.t3 a_40855_3416.t3 VSS.t1961 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4533 a_8255_14616.t2 a_7799_14914.t3 VDD.t1701 VDD.t912 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4534 a_47635_9239.t0 a_48070_9273.t3 a_47375_9016.t2 VSS.t1477 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4535 a_31249_690.t0 a_31159_594# VSS.t899 VSS.t3494 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4536 a_24563_3750.t7 a_24639_3394# a_24729_3490.t4 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4537 a_27909_9016.t0 a_27359_9314.t3 a_27815_9016.t0 VSS.t1384 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4538 a_36069_9331.t0 a_35132_9360.t2 a_35880_9093.t0 VDD.t150 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4539 a_5003_950.t5 a_4298_914.t2 6MSB_0.OUTN.t101 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4540 a_36299_17416.t0 VDD.t1385 VSS.t2723 VSS.t3790 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4541 a_47661_17734.t3 a_47635_17639.t3 VDD.t1390 VDD.t905 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X4542 VDD.t196 a_17121_9294.t2 a_17338_9314.t1 VDD.t159 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4543 a_23641_9294.t0 a_22840_9093.t2 VSS.t1371 VSS.t1372 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4544 a_37769_9090.t1 a_37679_8994# VSS.t3586 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4545 VSS.t2792 a_31159_17394# a_31249_17490.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4546 a_4081_9294.t1 a_3280_9093.t2 VDD.t170 VDD.t122 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4547 a_41550_873.t1 CLK.t1 VDD.t708 VDD.t448 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4548 VSS.t2449 a_46530_14598.t2 a_46818_14617.t0 VSS.t2450 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4549 a_31083_12150.t0 VSS.t602 VSS.t603 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4550 VSS.t7 a_10028_12033.t2 a_9706_11893.t0 VSS.t6 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4551 a_29957_894.t0 a_29360_693.t2 VSS.t2159 VSS.t2158 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4552 VSS.t3741 VDD.t1307 a_40949_17416.t0 VSS.t3740 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4553 VSS.t430 a_5079_14594# a_5169_14690.t3 VSS.t2907 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4554 a_10397_14894.t1 a_9800_14693.t2 VDD.t913 VDD.t912 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4555 a_8541_12134.t1 a_8515_12039.t3 VDD.t791 VDD.t17 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4556 a_28510_12073.t1 CLK.t35 VDD.t58 VDD.t50 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4557 a_18043_950.t7 a_18119_594# a_18209_690.t4 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4558 6MSB_0.OUTN.t82 a_17338_12114.t2 a_18043_12150.t4 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4559 a_13930_20198.t0 a_13625_20594.t2 VSS.t261 VSS.t4295 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X4560 VSS.t1305 a_7410_8998.t2 a_7698_9017.t2 VSS.t1304 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4561 VDD.t676 VDD.t1657 a_27815_616.t1 VDD.t456 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4562 VSS.t3609 a_44199_594# a_44289_690.t2 VSS.t3608 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4563 a_7199_994.t0 a_2713_24910.t2 a_7105_994.t1 VDD.t460 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4564 a_16509_20531.t0 a_15572_20560.t2 a_16320_20293.t0 VDD.t7 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4565 a_43201_14894.t0 a_42400_14693.t2 VSS.t2662 VSS.t2663 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4566 a_34847_11829.t0 VDD.t1455 VSS.t3839 VSS.t3838 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4567 a_14319_14914.t1 a_n2044_1752.t15 a_14218_14617.t1 VSS.t2829 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4568 a_35880_693.t1 a_35030_873.t2 a_35786_693.t0 VSS.t2178 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4569 VDD.t633 a_8950_873.t3 a_9052_960.t1 VDD.t460 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4570 6MSB_0.OUTN.t100 a_4298_914.t2 a_5003_950.t4 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4571 a_8898_3807.t0 a_8541_3734.t4 VDD.t494 VDD.t301 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4572 VSS.t1800 a_3508_3633.t2 a_3186_3493.t1 VSS.t1799 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4573 a_23068_833.t0 a_22840_693.t2 a_23259_616.t0 VSS.t2129 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4574 a_11689_690.t3 a_11599_594# VSS.t3071 VSS.t3072 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4575 a_37769_3490.t6 a_37679_3394# a_37603_3750.t9 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4576 a_22840_11893.t1 a_21990_12073.t2 a_22746_11893.t0 VSS.t42 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4577 VSS.t980 a_44199_3394# a_44289_3490.t3 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4578 a_36108_3633.t1 VDD.t1603 VDD.t555 VDD.t290 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4579 a_8255_20216.t1 a_9052_20560.t3 a_8515_20439.t1 VDD.t762 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4580 VDD.t236 a_33185_9394.t2 a_33490_8998.t1 VDD.t150 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4581 VSS.t1777 a_n2042_2484.t9 a_585_994.t0 VSS.t1776 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X4582 a_14218_3417.t1 a_n2042_2484.t15 a_14319_3714.t0 VSS.t1789 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4583 a_11689_3490.t0 a_11599_3394# VSS.t949 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4584 VSS.t3147 a_24639_20194# a_24729_20290.t0 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4585 VDD.t911 a_49721_17694.t2 a_49938_17714.t1 VDD.t905 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X4586 a_24729_6290.t6 a_24639_6194# a_24563_6550.t9 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4587 VSS.t1810 a_4081_3694.t2 a_4298_3714.t0 VSS.t1809 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4588 a_48514_27442.t2 a_48949_27476.t3 a_48897_27610.t0 VDD.t14 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X4589 VSS.t213 VSS.t211 a_24563_20550.t1 VSS.t212 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4590 a_23068_6433.t1 VDD.t1543 VDD.t366 VDD.t139 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4591 VSS.t828 a_31159_6194# a_31249_6290.t3 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4592 VSS.t2479 a_35880_20293.t2 a_36477_20494.t0 VSS.t2477 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4593 VDD.t440 X10.t4 a_n2946_3612.t0 VDD.t286 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X4594 VDD.t808 VDD.t1353 a_1735_17416.t2 VDD.t752 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4595 a_21938_15007.t0 a_21581_14934.t4 VDD.t1159 VDD.t736 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4596 a_27359_3714.t1 a_n2042_2484.t13 a_27258_3417.t0 VSS.t1784 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4597 VDD.t433 a_49721_6494.t2 a_49938_6514.t1 VDD.t0 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4598 VSS.t2962 a_18119_17394# a_18209_17490.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4599 a_24729_14690.t5 a_24639_14594# a_24563_14950.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4600 a_50205_25015.t1 a_49608_24814.t2 VDD.t1790 VDD.t813 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2014p ps=1.53u w=1.12u l=0.13u
X4601 a_15061_12134.t1 a_15035_12039.t3 VDD.t1124 VDD.t25 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4602 VSS.t4083 a_5079_8994# a_5169_9090.t0 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4603 VDD.t918 a_10601_14894.t2 a_10818_14914.t1 VDD.t912 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X4604 VDD.t96 a_40010_11798.t2 a_40399_12114.t0 VDD.t91 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4605 a_49799_26830.t0 a_48949_26480.t2 a_49705_26830.t0 VSS.t0 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4606 VDD.t989 a_29588_20433.t2 a_29549_20531.t0 VDD.t9 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4607 VSS.t321 VSS.t318 VSS.t320 VSS.t319 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4608 a_21807_14629.t0 VDD.t1409 VSS.t3808 VSS.t3807 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4609 a_17338_9314.t1 a_17121_9294.t2 VDD.t195 VDD.t159 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4610 a_n2951_2880.t0 X9.t2 VSS.t4244 VSS.t4242 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p ps=1.78u
+ w=0.55u l=0.13u
X4611 a_39705_17794.t0 a_4321_24727.t8 VSS.t2517 VSS.t2516 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X4612 a_33279_14994.t0 a_3545_25331.t7 a_33185_14994.t1 VDD.t846 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4613 VSS.t458 VSS.t457 VSS.t458 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4614 a_23068_9233.t0 a_22840_9093.t2 a_23259_9016.t0 VSS.t1368 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4615 a_2021_6534.t2 a_2532_6560.t2 a_3280_6293.t1 VSS.t1535 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4616 a_23858_17714.t1 a_23641_17694.t2 VDD.t1132 VDD.t737 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X4617 VSS.t2007 X8.t1 a_n2951_1728.t0 VSS.t2315 sg13_lv_nmos ad=0.14642p pd=1.155u as=0.1045p
+ ps=0.93u w=0.55u l=0.13u
X4618 VSS.t2006 a_n2347_2880.t2 a_n2042_2484.t0 VSS.t2005 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4619 VSS.t185 VSS.t179 a_51516_24785.t3 VSS.t180 sg13_hv_nmos ad=0.102p pd=1.28u as=57f ps=0.68u
+ w=0.3u l=0.45u
X4620 a_4081_17694.t1 a_3280_17493.t2 VDD.t756 VDD.t752 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4621 a_21807_9029.t0 VDD.t1491 VSS.t3862 VSS.t3861 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4622 VDD.t149 a_n2042_972.t11 a_40399_9314.t0 VDD.t147 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4623 VDD.t1067 VSS.t251 a_7199_20594.t0 VDD.t762 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4624 a_31083_17750.t5 a_30378_17714.t2 6MSB_0.OUTN.t48 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4625 VSS.t2381 a_3508_17633.t2 a_3186_17493.t0 VSS.t2380 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4626 a_18209_17490.t1 a_18119_17394# VSS.t2960 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4627 VSS.t1773 a_n2042_2484.t6 a_20145_994.t0 VSS.t1772 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4628 a_41430_6229.t0 a_41652_6560.t3 a_41115_6439.t0 VSS.t1694 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4629 6MSB_0.OUTP.t127 a_16917_17694.t2 a_18043_17750.t4 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4630 a_24563_14950.t2 VSS.t542 VSS.t543 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X4631 a_23437_17694.t1 a_22840_17493.t2 VDD.t1128 VDD.t737 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2014p ps=1.53u w=1.12u l=0.13u
X4632 VSS.t2696 a_23068_14833.t2 a_22746_14693.t0 VSS.t2695 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4633 a_30378_20514.t0 a_30161_20494.t2 VSS.t4097 VSS.t4096 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4634 a_1735_616.t2 a_2532_960.t3 a_1995_839.t0 VDD.t462 sg13_lv_pmos ad=0.1428p pd=1.52u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4635 VDD.t562 a_36681_3694.t2 a_36898_3714.t1 VDD.t290 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4636 a_47635_17639.t0 a_48070_17673.t3 a_47375_17416.t0 VSS.t3235 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4637 a_51516_24785.t0 VSS.t140 VSS.t142 VSS.t141 sg13_hv_nmos ad=57f pd=0.68u as=0.102p ps=1.28u
+ w=0.3u l=0.45u
X4638 6MSB_0.OUTN.t25 a_23858_20514.t2 a_24563_20550.t9 VSS.t3465 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4639 a_11689_17490.t6 a_11599_17394# a_11523_17750.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4640 a_49721_9294.t0 a_48920_9093.t2 VSS.t1483 VSS.t1484 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4641 a_23437_894.t1 a_22840_693.t2 VDD.t665 VDD.t458 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4642 a_28510_20473.t1 CLK.t58 VDD.t989 VDD.t9 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X4643 VSS.t3284 a_37679_3394# a_37769_3490.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4644 a_8541_20534.t3 a_8515_20439.t3 VDD.t1013 VDD.t762 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4645 VDD.t1084 a_585_17794.t2 a_890_17398.t1 VDD.t752 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4646 a_27359_17714.t1 a_n2648_3264.t13 a_27258_17417.t0 VSS.t3430 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4647 a_37603_6550.t7 a_37679_6194# a_37769_6290.t4 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4648 a_51516_24785.t3 4LSB_weighted_0.VBIAS VSS.t4070 VSS.t4066 sg13_hv_nmos ad=57f pd=0.68u as=57f
+ ps=0.68u w=0.3u l=0.45u
X4649 a_50643_12150.t8 a_49938_12114.t2 6MSB_0.OUTN.t85 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4650 a_47375_11816.t2 a_48172_12160.t3 a_47635_12039.t1 VDD.t1 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4651 VDD.t373 a_23641_6494.t2 a_23858_6514.t1 VDD.t139 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4652 a_42589_6531.t0 a_41652_6560.t2 a_42400_6293.t0 VDD.t125 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4653 a_34429_616.t0 a_33879_914.t3 a_34335_616.t0 VSS.t2173 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4654 a_44289_6290.t1 a_44199_6194# VSS.t4043 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4655 VSS.t80 a_29360_11893.t2 a_29957_12094.t0 VSS.t78 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4656 a_14218_3417.t0 a_13930_3398.t2 VSS.t1842 VSS.t1843 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4657 a_24563_9350.t1 a_23437_9294.t2 6MSB_0.OUTP.t15 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4658 a_40399_6514.t2 a_40010_6198.t2 VDD.t406 VDD.t125 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4659 a_18209_3490.t7 a_18119_3394# a_18043_3750.t8 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4660 a_51768_27313.t0 VSS.t143 VSS.t145 VSS.t144 sg13_hv_nmos ad=57f pd=0.68u as=0.102p ps=1.28u
+ w=0.3u l=0.45u
X4661 VSS.t2558 VDD.t1367 a_14869_17416.t0 VSS.t3772 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4662 a_17338_12114.t0 a_17121_12094.t2 VSS.t27 VSS.t26 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4663 a_18209_11890.t3 a_18119_11794# VSS.t3567 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4664 VSS.t2161 a_29360_693.t2 a_29957_894.t0 VSS.t2160 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4665 a_2021_934.t2 a_2532_960.t2 a_3280_693.t1 VSS.t2039 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4666 a_5003_3750.t6 a_4298_3714.t2 6MSB_0.OUTN.t14 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4667 a_50643_17750.t4 a_50719_17394# a_50809_17490.t6 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4668 a_24563_9350.t7 a_24639_8994# a_24729_9090.t4 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4669 a_41115_9239.t0 a_41550_9273.t3 a_40855_9016.t3 VSS.t1447 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X4670 a_8349_3416.t0 a_7799_3714.t3 a_8255_3416.t0 VSS.t1817 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4671 a_585_3794.t0 a_653_546.t3 VSS.t3220 VSS.t3219 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4672 VDD.t1056 a_8950_17673.t3 a_9052_17760.t1 VDD.t741 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X4673 a_5003_6550.t5 a_4298_6514.t2 6MSB_0.OUTN.t41 VSS.t1211 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4674 a_42997_14894.t1 a_42400_14693.t2 VDD.t864 VDD.t810 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4675 VSS.t1150 a_42628_12033.t2 a_42306_11893.t1 VSS.t1149 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4676 a_31083_17750.t0 VSS.t356 VSS.t358 VSS.t357 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4677 VSS.t3245 a_10028_17633.t2 a_9706_17493.t1 VSS.t3244 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4678 a_49799_27296.t1 a_48949_27476.t2 a_49705_27296.t0 VSS.t3035 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4679 a_29588_12033.t0 a_29360_11893.t2 a_29779_11816.t0 VSS.t77 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4680 VDD.t435 X9.t4 a_n2946_4060.t1 VDD.t434 sg13_lv_pmos ad=0.1918p pd=1.5u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X4681 VDD.t79 X7.t1 a_1997_24701.t1 VDD.t76 sg13_lv_pmos ad=0.2856p pd=2.36u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X4682 6MSB_0.OUTN.t20 a_17338_17714.t2 a_18043_17750.t5 VSS.t1224 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4683 VSS.t2008 a_n2951_1728.t2 a_n2646_1728.t0 VSS.t1978 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4684 VDD.t296 a_n2646_2484.t6 a_26759_3794.t0 VDD.t295 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4685 a_44123_6550.t2 VSS.t834 VSS.t855 VSS.t415 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4686 VSS.t3422 a_n2648_3264.t8 a_7105_14994.t0 VSS.t3421 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4687 a_49148_6433.t1 VDD.t1567 VDD.t426 VDD.t0 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4688 a_29957_20494.t0 a_29360_20293.t2 VSS.t4092 VSS.t4091 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4689 VDD.t1133 a_23641_17694.t2 a_23858_17714.t1 VDD.t737 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X4690 a_27258_6217.t1 a_n2646_2484.t14 a_27359_6514.t1 VSS.t1525 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4691 a_34847_17429.t0 VDD.t1375 VSS.t3789 VSS.t3788 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4692 VSS.t572 VSS.t478 VSS.t572 VSS.t130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4693 6MSB_0.OUTP.t16 a_3877_3694.t2 a_5003_3750.t0 VSS.t1196 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4694 a_48706_25128.t0 a_48349_25055.t4 VDD.t814 VDD.t813 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4695 a_15061_20534.t3 a_15035_20439.t3 VDD.t1284 VDD.t7 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4696 VSS.t1288 a_3508_9233.t2 a_3186_9093.t1 VSS.t1287 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4697 VDD.t855 a_40010_20198.t2 a_40399_20514.t0 VDD.t801 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X4698 a_8898_9407.t0 a_8541_9334.t4 VDD.t185 VDD.t162 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4699 a_37769_9090.t6 a_37679_8994# a_37603_9350.t9 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4700 6MSB_0.OUTN.t40 a_4298_6514.t2 a_5003_6550.t4 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4701 VDD.t700 a_36681_894.t2 a_36898_914.t1 VDD.t454 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4702 a_22840_17493.t0 a_21990_17673.t2 a_22746_17493.t0 VSS.t4169 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4703 VDD.t1115 a_n2770_240.t15 a_14319_12114.t1 VDD.t25 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4704 VDD.t107 a_n2044_1752.t2 a_46319_12194.t0 VDD.t1 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4705 a_36108_9233.t0 VDD.t1507 VDD.t242 VDD.t150 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4706 VSS.t746 a_44199_8994# a_44289_9090.t3 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4707 a_20738_617.t1 a_20450_598.t2 VSS.t2115 VSS.t2114 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X4708 a_36898_3714.t1 a_36681_3694.t2 VDD.t561 VDD.t290 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4709 VSS.t1805 a_3280_3493.t2 a_3877_3694.t0 VSS.t1804 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4710 a_3469_17731.t0 a_2532_17760.t2 a_3280_17493.t0 VDD.t752 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4711 a_50643_12150.t7 a_49517_12094.t2 6MSB_0.OUTP.t98 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4712 a_33490_11798.t1 a_33185_12194.t2 VDD.t67 VDD.t66 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4713 6MSB_0.OUTN.t51 a_10818_9314.t2 a_11523_9350.t6 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4714 a_11689_9090.t0 a_11599_8994# VSS.t650 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4715 a_14218_9017.t1 a_n2042_972.t15 a_14319_9314.t1 VSS.t1271 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4716 VDD.t635 a_9800_693.t2 a_10028_833.t1 VDD.t460 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4717 VSS.t3575 X5.t0 a_2713_24685.t0 VSS.t3574 sg13_lv_nmos ad=0.187p pd=1.78u as=0.1045p ps=0.93u
+ w=0.55u l=0.13u
X4718 VSS.t4079 a_33185_20594.t2 a_33490_20198.t0 VSS.t4078 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4719 VDD.t952 a_n2044_1752.t16 a_7799_14914.t1 VDD.t912 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4720 a_11523_950.t2 VSS.t1037 VSS.t1045 VSS.t249 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X4721 a_23029_14931.t0 a_22092_14960.t2 a_22840_14693.t1 VDD.t736 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4722 a_47375_14616.t1 a_46919_14914.t3 VDD.t779 VDD.t3 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4723 a_8830_11829.t1 a_9052_12160.t3 a_8515_12039.t1 VSS.t4184 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4724 VDD.t409 VDD.t1557 a_40855_6216.t1 VDD.t125 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4725 VSS.t1292 a_4081_9294.t2 a_4298_9314.t0 VSS.t1291 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4726 VSS.t121 VSS.t118 VSS.t120 VSS.t119 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4727 a_37603_17750.t2 VSS.t405 VSS.t411 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X4728 a_50643_14950.t0 VSS.t521 VSS.t522 VSS.t377 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4729 VSS.t2753 a_10601_14894.t2 a_10818_14914.t0 VSS.t2752 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4730 a_23858_6514.t1 a_23641_6494.t2 VDD.t372 VDD.t139 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4731 a_24729_690.t1 a_24639_594# VSS.t3129 VSS.t3130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4732 VSS.t2250 a_49721_894.t2 a_49938_914.t0 VSS.t2249 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4733 VDD.t436 a_n2946_4060.t2 a_n2648_4040.t1 VDD.t434 sg13_lv_pmos ad=0.4256p pd=3u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4734 VSS.t3562 a_49836_24166.t2 a_49514_24288.t1 VSS.t3561 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4735 a_16548_14833.t0 a_16320_14693.t2 a_16739_14616.t0 VSS.t2712 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4736 VSS.t572 a_44199_14594# a_44289_14690.t3 VSS.t2410 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4737 a_47661_12134.t1 a_47635_12039.t3 VDD.t112 VDD.t1 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X4738 a_27359_9314.t0 a_n2042_972.t13 a_27258_9017.t0 VSS.t1266 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4739 a_27909_20216.t0 a_27359_20514.t3 a_27815_20216.t3 VSS.t4080 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4740 VSS.t443 VSS.t440 VSS.t442 VSS.t441 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4741 VSS.t1897 a_26970_3398.t2 a_27258_3417.t2 VSS.t1898 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4742 a_24729_690.t7 a_24639_594# a_24563_950.t8 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4743 a_13719_6594.t0 a_1253_24711.t4 a_13625_6594.t1 VDD.t127 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4744 VSS.t2395 a_18119_3394# a_18209_3490.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4745 VSS.t404 VSS.t399 VSS.t404 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4746 VSS.t695 VSS.t694 a_37603_9350.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4747 a_34335_3416.t2 a_35132_3760.t3 a_34595_3639.t1 VDD.t290 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4748 a_18043_6550.t2 VSS.t815 VSS.t821 VSS.t119 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4749 a_2247_3429.t0 VDD.t1569 VSS.t3914 VSS.t3913 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4750 a_16320_6293.t1 a_15470_6473.t2 a_16226_6293.t0 VSS.t1589 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4751 VSS.t1072 a_37679_594# a_37769_690.t3 VSS.t4106 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4752 a_4285_24701.t0 X7.t0 a_4341_24931.t0 VSS.t107 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X4753 VSS.t2070 a_8950_873.t3 a_9052_960.t0 VSS.t2069 sg13_lv_nmos ad=3.46165p pd=22.395u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X4754 a_1963_25289.t0 X5.t2 VSS.t3472 VSS.t104 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.14642p
+ ps=1.155u w=0.55u l=0.13u
X4755 VDD.t1222 a_36108_14833.t2 a_36069_14931.t0 VDD.t846 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=52.5f ps=0.67u w=0.42u l=0.13u
X4756 VSS.t1553 a_7105_6594.t2 a_7410_6198.t0 VSS.t1552 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X4757 VDD.t538 VDD.t1593 a_27815_3416.t1 VDD.t295 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4758 VDD.t693 a_36108_833.t2 a_36069_931.t0 VDD.t454 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4759 VDD.t510 a_15470_3673.t3 a_15572_3760.t1 VDD.t299 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4760 VDD.t121 a_49721_12094.t2 a_49938_12114.t1 VDD.t1 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4761 VDD.t249 a_36681_9294.t2 a_36898_9314.t1 VDD.t150 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4762 VSS.t1064 VSS.t901 a_31083_950.t3 VSS.t278 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p ps=1.03u
+ w=0.65u l=0.45u
X4763 VSS.t2022 a_n2347_1368.t2 a_n2042_972.t0 VSS.t2021 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X4764 6MSB_0.OUTP.t111 a_10397_894.t2 a_11523_950.t5 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4765 a_1649_24936.t0 a_1201_24910.t2 VDD.t1001 VDD.t76 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2226p
+ ps=1.535u w=0.84u l=0.13u
X4766 a_37603_9350.t5 a_36898_9314.t2 6MSB_0.OUTN.t45 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4767 VDD.t349 VDD.t1533 a_14775_6216.t1 VDD.t127 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4768 VSS.t1936 a_35030_3673.t3 a_35132_3760.t0 VSS.t1935 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4769 a_18209_3490.t4 a_18119_3394# a_18043_3750.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4770 a_24729_20290.t2 a_24639_20194# VSS.t3149 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4771 VSS.t3590 a_37679_8994# a_37769_9090.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4772 VDD.t1436 VDD.t1435 a_1735_11816.t2 VDD.t765 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4773 VSS.t622 VSS.t618 VSS.t621 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4774 a_24563_9350.t5 a_23858_9314.t2 6MSB_0.OUTN.t32 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4775 a_50643_17750.t9 a_49938_17714.t2 6MSB_0.OUTN.t55 VSS.t1231 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4776 a_10601_894.t0 a_9800_693.t2 VSS.t2077 VSS.t2078 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X4777 VSS.t3226 a_29360_17493.t2 a_29957_17694.t0 VSS.t3224 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4778 a_14218_9017.t0 a_13930_8998.t2 VSS.t1328 VSS.t1329 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4779 VSS.t823 VSS.t818 VSS.t823 VSS.t147 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4780 VSS.t1622 a_21990_6473.t3 a_22092_6560.t0 VSS.t1621 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4781 a_48063_24365.t0 a_48860_23938.t3 a_48323_23895.t1 VDD.t760 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4782 VSS.t3359 a_26970_20198.t2 a_27258_20217.t0 VSS.t3360 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4783 a_5003_17750.t8 a_5079_17394# a_5169_17490.t5 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4784 a_49938_12114.t0 a_49721_12094.t2 VSS.t1193 VSS.t1192 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4785 VSS.t2141 a_26665_994.t2 a_26970_598.t0 VSS.t2140 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X4786 a_16320_3493.t0 a_15470_3673.t2 a_15061_3734.t3 VDD.t299 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4787 a_17338_17714.t0 a_17121_17694.t2 VSS.t2869 VSS.t2868 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4788 a_18209_17490.t3 a_18119_17394# VSS.t2964 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4789 a_24563_14950.t8 a_24639_14594# a_24729_14690.t6 VSS.t3122 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4790 a_21389_11816.t0 a_20839_12114.t3 a_21295_11816.t0 VSS.t38 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4791 a_18209_9090.t7 a_18119_8994# a_18043_9350.t8 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4792 a_1829_3416.t0 a_1279_3714.t3 a_1735_3416.t0 VSS.t1767 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4793 a_43201_17694.t1 a_42400_17493.t2 VDD.t1058 VDD.t812 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4794 a_8349_9016.t0 a_7799_9314.t3 a_8255_9016.t0 VSS.t1302 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4795 a_50643_3750.t2 VSS.t987 VSS.t988 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4796 a_10219_3416.t0 VDD.t1579 VSS.t1824 VSS.t3919 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4797 6MSB_0.OUTN.t3 a_50205_25015.t2 a_51440_25469.t4 VSS.t2594 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4798 VDD.t1183 a_n2044_4040.t14 a_14319_20514.t2 VDD.t7 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4799 6MSB_0.OUTP.t101 a_42997_20494.t2 a_44123_20550.t6 VSS.t2890 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4800 a_33490_20198.t1 a_33185_20594.t2 VDD.t1713 VDD.t793 sg13_lv_pmos ad=0.252p pd=1.57u
+ as=0.2226p ps=1.535u w=1.12u l=0.13u
X4801 VDD.t1216 a_23068_17633.t2 a_23029_17731.t0 VDD.t737 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=52.5f ps=0.67u w=0.42u l=0.13u
X4802 a_23858_12114.t1 a_23641_12094.t2 VDD.t48 VDD.t34 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4803 6MSB_0.OUTN.t44 a_36898_9314.t2 a_37603_9350.t4 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4804 VDD.t126 a_n2042_972.t3 a_39799_6594.t0 VDD.t125 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4805 VDD.t1070 VDD.t1375 a_34595_17639.t2 VDD.t893 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X4806 VSS.t3256 a_42628_17633.t2 a_42306_17493.t0 VSS.t3255 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4807 a_4081_12094.t1 a_3280_11893.t2 VDD.t767 VDD.t765 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4808 VDD.t721 VDD.t1691 a_47375_616.t1 VDD.t4 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4809 a_31249_690.t3 a_31159_594# VSS.t3501 VSS.t3500 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4810 VSS.t1008 VSS.t1007 a_24563_950.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4811 VDD.t1165 a_1963_25289.t2 a_1997_24905.t1 VDD.t76 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4812 a_50409_25015.t0 a_49608_24814.t2 VSS.t4308 VSS.t4275 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X4813 a_29588_17633.t1 a_29360_17493.t2 a_29779_17416.t0 VSS.t3223 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4814 a_42628_6433.t1 VDD.t1561 VDD.t411 VDD.t125 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X4815 VSS.t658 a_50719_6194# a_50809_6290.t3 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4816 a_24563_12150.t4 a_23437_12094.t2 6MSB_0.OUTP.t96 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4817 VDD.t220 a_n2770_240.t5 a_26759_9394.t0 VDD.t153 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4818 a_23437_12094.t1 a_22840_11893.t2 VDD.t44 VDD.t34 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4819 a_36299_20216.t0 VDD.t1349 VSS.t2475 VSS.t3711 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4820 VSS.t2032 a_890_598.t2 a_1178_617.t0 VSS.t2031 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4821 a_7799_3714.t1 a_n2042_2484.t16 VDD.t476 VDD.t301 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4822 VSS.t4219 a_31159_20194# a_31249_20290.t2 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4823 a_50643_17750.t6 a_50719_17394# a_50809_17490.t5 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4824 a_18043_950.t3 a_18119_594# a_18209_690.t6 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4825 a_11689_11890.t4 a_11599_11794# a_11523_12150.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4826 a_37603_950.t1 a_36477_894.t2 6MSB_0.OUTP.t107 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4827 a_50027_26708.t0 a_49799_26830.t2 a_50218_26907.t0 VSS.t2574 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4828 VSS.t2633 VDD.t1277 a_40949_20216.t0 VSS.t3706 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4829 a_37769_14690.t3 a_37679_14594# VSS.t4250 VSS.t2338 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4830 VSS.t3402 a_15470_12073.t3 a_15572_12160.t0 VSS.t3401 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4831 VSS.t1285 a_3280_9093.t2 a_3877_9294.t0 VSS.t1284 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4832 a_42997_894.t1 a_42400_693.t2 VDD.t710 VDD.t448 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4833 a_50643_17750.t7 a_49517_17694.t2 6MSB_0.OUTP.t4 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4834 VDD.t873 a_585_12194.t2 a_890_11798.t1 VDD.t765 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X4835 a_36898_9314.t1 a_36681_9294.t2 VDD.t248 VDD.t150 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X4836 a_11523_17750.t5 a_11599_17394# a_11689_17490.t7 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4837 a_37603_12150.t1 a_36477_12094.t2 6MSB_0.OUTP.t93 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4838 a_24563_950.t5 a_23858_914.t2 6MSB_0.OUTN.t99 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4839 a_49517_12094.t0 a_48920_11893.t2 VSS.t1189 VSS.t1188 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4840 VSS.t996 VSS.t985 VSS.t996 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4841 a_8830_17429.t0 a_9052_17760.t3 a_8515_17639.t0 VSS.t3241 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4842 a_24563_3750.t1 a_23437_3694.t2 6MSB_0.OUTP.t9 VSS.t1223 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4843 a_50809_6290.t7 a_50719_6194# a_50643_6550.t8 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4844 VDD.t992 a_49836_24954.t2 a_49797_25052.t0 VDD.t813 sg13_lv_pmos ad=1.4292p pd=9.04u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4845 a_51517_23976.t0 VSS.t186 VSS.t188 VSS.t187 sg13_hv_nmos ad=0.114p pd=0.98u as=0.204p ps=1.88u
+ w=0.6u l=0.45u
X4846 VSS.t2852 a_890_14598.t2 a_1178_14617.t2 VSS.t2851 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4847 a_50643_12150.t4 a_50719_11794# a_50809_11890.t6 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4848 VDD.t18 a_8950_12073.t3 a_9052_12160.t1 VDD.t17 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4849 a_47375_6216.t3 a_48172_6560.t3 a_47635_6439.t0 VDD.t0 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4850 VSS.t4187 a_39705_14994.t2 a_40010_14598.t0 VSS.t4186 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X4851 VSS.t1870 a_20450_3398.t2 a_20738_3417.t2 VSS.t1869 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4852 a_50809_17490.t5 a_50719_17394# a_50643_17750.t5 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4853 VSS.t2513 a_n2648_3264.t2 a_46225_14994.t0 VSS.t2512 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4854 VSS.t1382 a_26970_8998.t2 a_27258_9017.t2 VSS.t1381 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4855 VSS.t372 VSS.t369 VSS.t371 VSS.t370 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4856 a_7799_914.t1 VDD.t1629 a_7698_617.t1 VSS.t3950 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X4857 VSS.t101 a_485_25427.t2 a_521_25453.t0 VSS.t3049 sg13_lv_nmos ad=0.1371p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X4858 a_20839_914.t0 a_20450_598.t2 VDD.t658 VDD.t458 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4859 a_n2646_2484.t0 a_n2951_2880.t2 VSS.t1977 VSS.t1976 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X4860 a_49836_24954.t1 a_49608_24814.t2 a_50027_24737.t0 VSS.t4274 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X4861 VSS.t3508 a_18119_8994# a_18209_9090.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4862 a_34335_9016.t3 a_35132_9360.t3 a_34595_9239.t1 VDD.t150 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4863 a_28458_3807.t0 a_28101_3734.t4 VDD.t539 VDD.t295 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4864 VSS.t1888 a_23068_3633.t2 a_22746_3493.t1 VSS.t1887 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4865 a_2247_9029.t0 VDD.t1473 VSS.t3850 VSS.t3849 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4866 a_21990_873.t0 CLK.t4 VSS.t2126 VSS.t3687 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X4867 VDD.t74 a_485_25427.t2 a_521_25453.t1 VDD.t73 sg13_lv_pmos ad=0.2086p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4868 VDD.t1167 VDD.t1295 a_1735_20216.t2 VDD.t5 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4869 VDD.t49 a_23641_12094.t2 a_23858_12114.t1 VDD.t34 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4870 VDD.t381 a_28510_6473.t3 a_28612_6560.t1 VDD.t137 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4871 VSS.t2839 a_18119_20194# a_18209_20290.t1 VSS.t2260 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4872 a_34595_14839.t1 a_35030_14873.t3 a_34978_15007.t0 VDD.t846 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X4873 a_34429_14616.t0 a_33879_14914.t3 a_34335_14616.t3 VSS.t4195 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4874 VDD.t321 a_3508_6433.t2 a_3469_6531.t0 VDD.t143 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4875 a_42589_17731.t0 a_41652_17760.t2 a_42400_17493.t0 VDD.t812 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4876 VDD.t225 VDD.t1497 a_27815_9016.t1 VDD.t153 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X4877 VSS.t1892 a_23641_3694.t2 a_23858_3714.t0 VSS.t1891 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X4878 a_48758_24994.t1 CLK.t64 VDD.t992 VDD.t813 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.4292p
+ ps=9.04u w=1.12u l=0.13u
X4879 VDD.t986 a_29360_14693.t2 a_29957_14894.t1 VDD.t884 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X4880 a_8541_12134.t3 a_9052_12160.t2 a_9800_11893.t1 VSS.t2444 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4881 a_47950_11829.t0 a_48172_12160.t3 a_47635_12039.t0 VSS.t1177 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X4882 a_28101_934.t0 a_28075_839.t3 VSS.t2148 VSS.t2147 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X4883 a_39705_20594.t0 a_4321_24727.t9 VSS.t2973 VSS.t2972 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X4884 a_3469_12131.t0 a_2532_12160.t2 a_3280_11893.t1 VDD.t765 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4885 VDD.t199 a_15470_9273.t3 a_15572_9360.t1 VDD.t159 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4886 6MSB_0.OUTN.t7 a_10818_3714.t2 a_11523_3750.t6 VSS.t1218 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4887 a_13625_9394.t0 a_1253_24711.t5 VSS.t3518 VSS.t3517 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X4888 a_27258_11817.t2 a_n2770_240.t13 a_27359_12114.t1 VSS.t3374 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X4889 a_31083_9350.t6 a_30378_9314.t2 6MSB_0.OUTN.t31 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4890 6MSB_0.OUTP.t57 a_10397_6494.t2 a_11523_6550.t5 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4891 a_31083_950.t2 VSS.t897 VSS.t1066 VSS.t275 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4892 a_5169_690.t2 a_5079_594# VSS.t3596 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4893 VDD.t616 VDD.t1621 a_1735_616.t1 VDD.t462 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4894 VSS.t2977 a_48758_23938.t3 a_48860_23938.t0 VSS.t3458 sg13_lv_nmos ad=3.46352p pd=12.58u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4895 a_23858_20514.t1 a_23641_20494.t2 VDD.t995 VDD.t11 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X4896 a_7799_14914.t2 a_7410_14598.t2 VDD.t1699 VDD.t912 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4897 a_18209_9090.t4 a_18119_8994# a_18043_9350.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4898 VSS.t1421 a_35030_9273.t3 a_35132_9360.t0 VSS.t1420 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4899 VSS.t880 VSS.t879 VSS.t880 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4900 a_4081_20494.t1 a_3280_20293.t2 VDD.t1026 VDD.t5 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4901 a_37603_12150.t2 VSS.t459 VSS.t465 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X4902 a_29360_6293.t0 a_28510_6473.t2 a_28101_6534.t2 VDD.t137 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4903 a_31083_20550.t5 a_30378_20514.t2 6MSB_0.OUTN.t102 VSS.t2885 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4904 6MSB_0.OUTP.t25 a_16917_20494.t2 a_18043_20550.t8 VSS.t2878 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4905 VSS.t3180 a_3508_20433.t2 a_3186_20293.t0 VSS.t3179 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4906 a_18209_20290.t1 a_18119_20194# VSS.t2837 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4907 VSS.t294 VSS.t292 VSS.t293 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4908 a_37769_17490.t5 a_37679_17394# a_37603_17750.t7 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4909 VSS.t814 VSS.t809 VSS.t814 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4910 VDD.t586 VDD.t1611 a_47635_3639.t2 VDD.t293 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X4911 a_23437_20494.t1 a_22840_20293.t2 VDD.t1764 VDD.t11 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X4912 a_49938_17714.t0 a_49721_17694.t2 VSS.t2741 VSS.t2740 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4913 a_16320_9093.t0 a_15470_9273.t2 a_15061_9334.t2 VDD.t159 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4914 a_46530_3398.t1 a_46225_3794.t2 VDD.t294 VDD.t293 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4915 a_50600_27497.t1 a_49799_27296.t2 VDD.t1735 VDD.t14 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4916 a_1829_9016.t0 a_1279_9314.t3 a_1735_9016.t0 VSS.t1249 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X4917 a_44289_690.t7 a_44199_594# a_44123_950.t8 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4918 a_11689_20290.t4 a_11599_20194# a_11523_20550.t2 VSS.t2348 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4919 a_21389_17416.t0 a_20839_17714.t3 a_21295_17416.t0 VSS.t3081 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4920 a_5169_11890.t1 a_5079_11794# VSS.t3522 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4921 a_10219_9016.t0 VDD.t1483 VSS.t1325 VSS.t3855 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4922 VDD.t461 a_n2042_2484.t8 a_7199_994.t0 VDD.t460 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X4923 VSS.t933 VSS.t932 a_37603_3750.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4924 VSS.t2798 a_50719_6194# a_50809_6290.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4925 6MSB_0.OUTP.t91 a_3877_12094.t2 a_5003_12150.t6 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4926 6MSB_0.OUTN.t30 a_30378_9314.t2 a_31083_9350.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4927 a_50643_9350.t4 VSS.t654 VSS.t758 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X4928 a_18043_14950.t7 a_18119_14594# a_18209_14690.t4 VSS.t2258 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4929 a_18043_12150.t6 a_17338_12114.t2 6MSB_0.OUTN.t82 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4930 VDD.t395 VDD.t1551 a_34595_6439.t2 VDD.t135 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X4931 a_49339_3416.t0 VDD.t1615 VSS.t1990 VSS.t3943 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X4932 a_24563_3750.t9 a_24639_3394# a_24729_3490.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4933 a_50205_23947.t1 a_49608_24288.t2 VDD.t1773 VDD.t760 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2014p ps=1.53u w=1.12u l=0.13u
X4934 VDD.t825 a_585_20594.t2 a_890_20198.t1 VDD.t5 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p ps=1.57u
+ w=1.12u l=0.13u
X4935 a_27359_20514.t1 a_n2044_4040.t12 a_27258_20217.t1 VSS.t3542 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4936 a_31249_3490.t3 a_31159_3394# VSS.t4259 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4937 a_31249_6290.t5 a_31159_6194# a_31083_6550.t7 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4938 VSS.t2148 VDD.t1657 a_27909_616.t0 VSS.t3970 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4939 VSS.t769 VSS.t768 a_24563_6550.t1 VSS.t333 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X4940 VSS.t3725 VDD.t1283 a_14869_20216.t0 VSS.t3724 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X4941 a_43201_3694.t1 a_42400_3493.t2 VDD.t574 VDD.t282 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4942 a_24563_17750.t4 a_23437_17694.t2 6MSB_0.OUTP.t124 VSS.t1221 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4943 a_5169_6290.t0 a_5079_6194# VSS.t802 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4944 a_11523_6550.t9 a_11599_6194# a_11689_6290.t7 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4945 VDD.t763 a_8950_20473.t3 a_9052_20560.t1 VDD.t762 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X4946 a_14319_14914.t0 a_13930_14598.t2 VDD.t921 VDD.t887 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4947 a_37603_950.t6 a_36898_914.t2 6MSB_0.OUTN.t110 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4948 a_9989_3731.t0 a_9052_3760.t2 a_9800_3493.t0 VDD.t301 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4949 VSS.t553 VSS.t551 VSS.t552 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X4950 a_7799_9314.t1 a_n2042_972.t16 VDD.t163 VDD.t162 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X4951 a_33185_12194.t0 a_3545_25331.t6 VSS.t2677 VSS.t2676 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X4952 VSS.t1981 a_46530_3398.t2 a_46818_3417.t2 VSS.t1980 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4953 a_7799_3714.t2 a_7410_3398.t2 VDD.t490 VDD.t301 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X4954 a_37603_3750.t4 a_36898_3714.t2 6MSB_0.OUTN.t117 VSS.t1203 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4955 a_31083_20550.t0 VSS.t223 VSS.t225 VSS.t224 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4956 VSS.t1434 a_n2770_240.t3 a_39705_9394.t0 VSS.t4182 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X4957 a_30161_6494.t1 a_29360_6293.t2 VDD.t384 VDD.t137 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4958 VSS.t3732 a_10028_20433.t2 a_9706_20293.t1 VSS.t4303 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4959 VSS.t3353 a_15470_17673.t3 a_15572_17760.t0 VSS.t3352 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4960 VDD.t902 a_20450_14598.t2 a_20839_14914.t0 VDD.t736 sg13_lv_pmos ad=0.2184p pd=1.51u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X4961 a_37603_6550.t1 a_36477_6494.t2 6MSB_0.OUTP.t1 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4962 a_8515_6439.t1 a_8950_6473.t3 a_8255_6216.t2 VSS.t1565 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X4963 6MSB_0.OUTN.t118 a_17338_20514.t2 a_18043_20550.t7 VSS.t2880 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4964 a_44123_17750.t5 a_44199_17394# a_44289_17490.t7 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4965 a_44289_690.t1 a_44199_594# VSS.t3603 VSS.t3604 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X4966 a_24563_3750.t6 a_23858_3714.t2 6MSB_0.OUTN.t28 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4967 a_37603_17750.t1 a_36477_17694.t2 6MSB_0.OUTP.t133 VSS.t1172 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4968 a_35880_14693.t0 a_35030_14873.t2 a_34621_14934.t0 VDD.t846 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X4969 VDD.t996 a_23641_20494.t2 a_23858_20514.t1 VDD.t11 sg13_lv_pmos ad=0.3808p pd=2.92u as=0.2156p
+ ps=1.505u w=1.12u l=0.13u
X4970 a_49517_17694.t0 a_48920_17493.t2 VSS.t2738 VSS.t2737 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X4971 a_24563_6550.t5 a_23858_6514.t2 6MSB_0.OUTN.t123 VSS.t1136 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4972 VSS.t1664 a_33490_6198.t2 a_33778_6217.t2 VSS.t1665 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4973 a_48540_27537.t2 a_49051_27563.t2 a_49799_27296.t1 VSS.t3007 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4974 6MSB_0.OUTP.t83 a_10397_12094.t2 a_11523_12150.t6 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4975 a_5003_12150.t8 a_5079_11794# a_5169_11890.t6 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4976 VSS.t763 VSS.t666 VSS.t763 VSS.t423 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X4977 a_7199_3794.t0 a_2713_24910.t3 a_7105_3794.t1 VDD.t301 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X4978 VDD.t1792 a_49608_24814.t2 a_50205_25015.t1 VDD.t813 sg13_lv_pmos ad=0.2083p pd=1.5u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X4979 a_34847_20229.t0 VDD.t1287 VSS.t3766 VSS.t3765 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X4980 a_15061_934.t2 a_15572_960.t2 a_16320_693.t1 VSS.t2095 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X4981 6MSB_0.OUTN.t78 a_4298_12114.t2 a_5003_12150.t4 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4982 a_43201_12094.t1 a_42400_11893.t2 VDD.t102 VDD.t91 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X4983 a_5169_17490.t6 a_5079_17394# a_5003_17750.t9 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4984 a_18043_12150.t0 VSS.t596 VSS.t597 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X4985 VSS.t1672 a_36108_6433.t2 a_35786_6293.t1 VSS.t1671 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X4986 a_40855_6216.t3 a_41652_6560.t3 a_41115_6439.t1 VDD.t125 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X4987 a_22840_20293.t0 a_21990_20473.t2 a_22746_20293.t1 VSS.t3114 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X4988 VDD.t42 a_23068_12033.t2 a_23029_12131.t0 VDD.t34 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X4989 VSS.t1354 a_20450_8998.t2 a_20738_9017.t2 VSS.t1355 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X4990 6MSB_0.OUTN.t116 a_36898_3714.t2 a_37603_3750.t5 VSS.t1200 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X4991 a_3469_20531.t0 a_2532_20560.t2 a_3280_20293.t1 VDD.t5 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X4992 VDD.t82 VDD.t1455 a_34595_12039.t2 VDD.t66 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X4993 a_1279_14914.t0 a_n2044_1752.t17 a_1178_14617.t0 VSS.t2833 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4994 a_20839_12114.t1 a_n2770_240.t14 a_20738_11817.t1 VSS.t3375 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X4995 a_33490_598.t1 a_33185_994.t2 VDD.t455 VDD.t454 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X4996 a_37769_3490.t4 a_37679_3394# a_37603_3750.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X4997 a_21938_3807.t0 a_21581_3734.t4 VDD.t524 VDD.t297 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X4998 a_51440_26253.t4 a_50817_26469.t2 6MSB_0.OUTP.t20 VSS.t2597 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X4999 a_37603_20550.t2 VSS.t285 VSS.t304 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X5000 VSS.t1123 a_36681_12094.t2 a_36898_12114.t0 VSS.t1122 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5001 VSS.t1363 a_23068_9233.t2 a_22746_9093.t1 VSS.t1362 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5002 a_28458_9407.t0 a_28101_9334.t4 VDD.t226 VDD.t153 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5003 VSS.t3305 a_44199_3394# a_44289_3490.t0 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5004 VSS.t1685 a_36681_6494.t2 a_36898_6514.t0 VSS.t1684 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5005 a_44123_9350.t5 a_43418_9314.t2 6MSB_0.OUTN.t128 VSS.t1129 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5006 VDD.t667 a_22840_693.t2 a_23437_894.t1 VDD.t458 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5007 VDD.t493 VDD.t1575 a_8255_3416.t1 VDD.t301 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5008 a_50643_12150.t6 a_50719_11794# a_50809_11890.t5 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5009 a_24729_6290.t4 a_24639_6194# a_24563_6550.t2 VSS.t3119 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5010 VSS.t1093 VSS.t1092 a_50643_950.t3 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5011 a_22840_17493.t1 a_21990_17673.t2 a_21581_17734.t3 VDD.t737 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X5012 VSS.t2282 a_31159_6194# a_31249_6290.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5013 a_13625_994.t0 a_1253_24711.t2 VSS.t3514 VSS.t3513 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X5014 VDD.t1044 VDD.t1293 a_48063_24737.t3 VDD.t813 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5015 a_8541_17734.t0 a_9052_17760.t2 a_9800_17493.t0 VSS.t3246 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5016 a_41141_17734.t1 a_41115_17639.t3 VDD.t1308 VDD.t812 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X5017 a_47950_17429.t0 a_48172_17760.t3 a_47635_17639.t0 VSS.t4318 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5018 VSS.t1376 a_23641_9294.t2 a_23858_9314.t0 VSS.t1375 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5019 VSS.t284 VSS.t277 VSS.t284 VSS.t278 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5020 VSS.t487 VSS.t422 a_50643_17750.t3 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5021 a_28101_14934.t3 a_28612_14960.t2 a_29360_14693.t0 VSS.t2942 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5022 VSS.t4190 a_40010_14598.t2 a_40298_14617.t2 VSS.t4191 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X5023 a_11523_12150.t8 a_11599_11794# a_11689_11890.t5 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5024 a_11689_3490.t2 a_11599_3394# VSS.t3021 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5025 a_30161_894.t0 a_29360_693.t2 VSS.t2161 VSS.t2162 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X5026 a_27258_17417.t1 a_n2648_3264.t13 a_27359_17714.t1 VSS.t3431 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5027 6MSB_0.OUTN.t62 a_10818_12114.t2 a_11523_12150.t4 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5028 VSS.t731 VSS.t726 VSS.t731 VSS.t127 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5029 a_27359_17714.t2 a_26970_17398.t2 VDD.t1795 VDD.t733 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.4032p ps=2.96u w=1.12u l=0.13u
X5030 VDD.t1159 VDD.t1409 a_21555_14839.t2 VDD.t736 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X5031 a_22840_6293.t0 a_21990_6473.t2 a_21581_6534.t3 VDD.t139 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X5032 6MSB_0.OUTP.t62 a_42997_9294.t2 a_44123_9350.t0 VSS.t1164 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5033 a_41550_6473.t0 CLK.t17 VSS.t1704 VSS.t3674 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5034 a_47375_616.t2 a_48172_960.t3 a_47635_839.t1 VDD.t4 sg13_lv_pmos ad=0.1428p pd=1.52u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5035 6MSB_0.OUTP.t66 a_10397_14894.t2 a_11523_14950.t0 VSS.t1204 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5036 a_7799_14914.t1 a_n2044_1752.t16 VDD.t951 VDD.t912 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5037 a_50809_11890.t5 a_50719_11794# a_50643_12150.t5 VSS.t2368 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5038 a_8515_12039.t1 a_8950_12073.t3 a_8255_11816.t2 VSS.t2445 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5039 a_46530_8998.t1 a_46225_9394.t2 VDD.t265 VDD.t2 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5040 VDD.t271 VDD.t1515 a_47635_9239.t2 VDD.t2 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X5041 a_44289_6290.t3 a_44199_6194# VSS.t4047 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5042 a_47950_629.t1 a_47661_934.t4 a_47887_629.t0 VSS.t2233 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5043 a_51440_26253.t0 VSS.t172 VSS.t173 VSS.t168 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5044 a_653_546.t0 a_2713_24685.t2 VSS.t3088 VSS.t3087 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.2812p
+ ps=2.24u w=0.74u l=0.13u
X5045 6MSB_0.OUTP.t95 a_3877_17694.t2 a_5003_17750.t6 VSS.t1198 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5046 a_5169_17490.t1 a_5079_17394# VSS.t2909 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5047 a_14775_17416.t0 a_15572_17760.t3 a_15035_17639.t0 VDD.t748 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5048 a_18043_17750.t9 a_17338_17714.t2 6MSB_0.OUTN.t20 VSS.t1225 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5049 6MSB_0.OUTP.t129 a_23437_14894.t2 a_24563_14950.t5 VSS.t1222 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5050 a_13930_14598.t1 a_13625_14994.t2 VDD.t919 VDD.t887 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5051 VDD.t885 a_n2648_3264.t5 a_26759_14994.t0 VDD.t884 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X5052 a_24563_9350.t9 a_24639_8994# a_24729_9090.t7 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5053 VDD.t782 a_48920_14693.t2 a_49148_14833.t1 VDD.t3 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5054 a_31249_9090.t3 a_31159_8994# VSS.t2507 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5055 a_49339_9016.t0 VDD.t1519 VSS.t1475 VSS.t3879 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5056 a_39799_994.t0 a_4321_24727.t2 a_39705_994.t1 VDD.t448 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X5057 a_42589_12131.t0 a_41652_12160.t2 a_42400_11893.t0 VDD.t91 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5058 a_44123_950.t5 a_43418_914.t2 6MSB_0.OUTN.t105 VSS.t1131 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5059 a_5003_20550.t5 a_5079_20194# a_5169_20290.t7 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5060 VSS.t4093 a_29360_20293.t2 a_29957_20494.t0 VSS.t4091 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5061 a_5169_14690.t0 a_5079_14594# VSS.t427 VSS.t2900 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5062 a_41141_6534.t1 a_41115_6439.t3 VDD.t409 VDD.t125 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5063 a_18209_20290.t3 a_18119_20194# VSS.t2841 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5064 a_46919_14914.t0 a_46530_14598.t2 VDD.t777 VDD.t3 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5065 a_43201_9294.t1 a_42400_9093.t2 VDD.t260 VDD.t147 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5066 a_17338_20514.t0 a_17121_20494.t2 VSS.t2926 VSS.t2925 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5067 a_43201_20494.t1 a_42400_20293.t2 VDD.t805 VDD.t801 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5068 a_31083_950.t6 a_30378_914.t2 6MSB_0.OUTN.t96 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5069 a_9989_9331.t0 a_9052_9360.t2 a_9800_9093.t0 VDD.t162 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5070 a_37603_6550.t6 a_36898_6514.t2 6MSB_0.OUTN.t10 VSS.t1201 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5071 a_13625_3794.t0 a_1253_24711.t3 VSS.t2543 VSS.t2542 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X5072 VDD.t994 a_23068_20433.t2 a_23029_20531.t0 VDD.t11 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5073 a_16739_14616.t0 VDD.t1407 VSS.t2711 VSS.t3801 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5074 a_31083_3750.t5 a_30378_3714.t2 6MSB_0.OUTN.t43 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5075 VDD.t820 VDD.t1287 a_34595_20439.t2 VDD.t793 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X5076 a_33185_17794.t0 a_3545_25331.t8 VSS.t2989 VSS.t2988 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X5077 a_7799_9314.t2 a_7410_8998.t2 VDD.t180 VDD.t162 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5078 VSS.t2486 a_42628_20433.t2 a_42306_20293.t0 VSS.t2485 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5079 a_4298_12114.t0 a_4081_12094.t2 VSS.t2435 VSS.t2434 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5080 VSS.t1466 a_46530_8998.t2 a_46818_9017.t2 VSS.t1465 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X5081 VSS.t878 VSS.t876 VSS.t877 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X5082 a_14319_14914.t2 a_n2044_1752.t15 VDD.t922 VDD.t887 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5083 VSS.t24 a_16320_11893.t2 a_16917_12094.t0 VSS.t22 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X5084 a_29588_20433.t1 a_29360_20293.t2 a_29779_20216.t0 VSS.t4090 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X5085 VSS.t1959 a_42628_3633.t2 a_42306_3493.t1 VSS.t1958 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5086 a_2009_25540.t0 X5.t2 VDD.t1165 VDD.t76 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2226p ps=1.535u
+ w=0.84u l=0.13u
X5087 a_15035_12039.t0 a_15470_12073.t3 a_14775_11816.t3 VSS.t3400 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5088 a_37769_11890.t6 a_37679_11794# a_37603_12150.t6 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5089 6MSB_0.OUTN.t104 a_43418_914.t2 a_44123_950.t4 VSS.t1128 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5090 a_48018_3807.t0 a_47661_3734.t4 VDD.t586 VDD.t293 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5091 a_44289_11890.t1 a_44199_11794# VSS.t3042 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5092 VDD.t475 a_n2042_2484.t15 a_14319_3714.t1 VDD.t299 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5093 VDD.t749 a_n2044_4040.t7 a_13719_17794.t0 VDD.t748 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X5094 a_23641_12094.t0 a_22840_11893.t2 VSS.t52 VSS.t53 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1331p
+ ps=1.12u w=0.64u l=0.13u
X5095 VSS.t808 VSS.t806 VSS.t807 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X5096 a_15470_873.t1 CLK.t5 VDD.t648 VDD.t444 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X5097 6MSB_0.OUTP.t53 a_10397_17694.t2 a_11523_17750.t8 VSS.t1206 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5098 a_7199_9394.t0 a_2713_24910.t5 a_7105_9394.t1 VDD.t162 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X5099 6MSB_0.OUTP.t108 a_29957_894.t2 a_31083_950.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5100 a_5003_3750.t2 VSS.t870 VSS.t923 VSS.t922 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X5101 6MSB_0.OUTN.t130 a_4298_17714.t2 a_5003_17750.t4 VSS.t1208 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5102 a_653_546.t1 a_2713_24685.t2 VDD.t1011 VDD.t71 sg13_lv_pmos ad=0.252p pd=1.57u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X5103 a_18043_17750.t0 VSS.t335 VSS.t337 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5104 VSS.t4029 a_31159_14594# a_31249_14690.t1 VSS.t2276 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5105 a_34978_6607.t0 a_34621_6534.t4 VDD.t395 VDD.t135 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5106 a_41550_873.t0 CLK.t1 VSS.t2210 VSS.t3690 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5107 VSS.t1972 a_43201_3694.t2 a_43418_3714.t0 VSS.t1971 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5108 a_3280_3493.t1 a_2430_3673.t2 a_3186_3493.t0 VSS.t1794 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5109 6MSB_0.OUTN.t42 a_30378_3714.t2 a_31083_3750.t4 VSS.t1112 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5110 VDD.t692 VDD.t1667 a_34595_839.t2 VDD.t454 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p ps=1.54u
+ w=0.42u l=0.13u
X5111 a_11523_20550.t8 a_11599_20194# a_11689_20290.t5 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5112 a_37603_14950.t3 a_37679_14594# a_37769_14690.t6 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5113 VDD.t991 a_7105_17794.t2 a_7410_17398.t1 VDD.t741 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5114 a_27359_3714.t0 a_n2042_2484.t13 VDD.t470 VDD.t295 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5115 a_8830_20229.t0 a_9052_20560.t3 a_8515_20439.t0 VSS.t3105 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5116 a_16917_6494.t1 a_16320_6293.t2 VDD.t353 VDD.t127 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X5117 a_15061_3734.t0 a_15035_3639.t3 VSS.t1846 VSS.t1845 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5118 VSS.t2937 a_50409_23971.t2 a_50626_23927.t0 VSS.t2684 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5119 a_20839_17714.t1 a_n2648_3264.t14 a_20738_17417.t1 VSS.t3432 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X5120 a_21938_9407.t0 a_21581_9334.t4 VDD.t211 VDD.t156 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5121 a_37769_9090.t4 a_37679_8994# a_37603_9350.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5122 VSS.t4281 a_44199_8994# a_44289_9090.t0 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5123 VSS.t1659 a_30161_6494.t2 a_30378_6514.t0 VSS.t1658 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5124 VSS.t388 VSS.t387 a_24563_17750.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5125 VSS.t2727 a_36681_17694.t2 a_36898_17714.t0 VSS.t2726 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5126 VDD.t452 VDD.t1569 a_1735_3416.t1 VDD.t303 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5127 VDD.t184 VDD.t1479 a_8255_9016.t1 VDD.t162 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5128 a_50643_950.t2 VSS.t1084 VSS.t1085 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X5129 a_41141_6534.t3 a_41652_6560.t2 a_42400_6293.t1 VSS.t1701 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5130 VSS.t114 VSS.t111 VSS.t113 VSS.t112 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X5131 VSS.t1493 a_n2646_2484.t4 a_39705_3794.t0 VSS.t1492 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5132 a_31249_14690.t1 a_31159_14594# VSS.t4027 VSS.t2275 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5133 a_10601_14894.t0 a_9800_14693.t2 VSS.t2748 VSS.t2747 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X5134 a_44123_12150.t7 a_44199_11794# a_44289_11890.t4 VSS.t2406 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5135 VDD.t1188 VDD.t1317 a_48063_24365.t2 VDD.t760 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5136 a_3508_14833.t1 a_3280_14693.t2 a_3699_14616.t0 VSS.t4015 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X5137 a_11689_9090.t2 a_11599_8994# VSS.t4269 VSS.t2352 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5138 a_1178_6217.t1 a_890_6198.t2 VSS.t1495 VSS.t1494 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X5139 a_29957_3694.t0 a_29360_3493.t2 VSS.t1912 VSS.t1911 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5140 VSS.t875 VSS.t874 VSS.t875 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5141 6MSB_0.OUTN.t60 a_43418_12114.t2 a_44123_12150.t4 VSS.t1128 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5142 a_5169_6290.t7 a_5079_6194# a_5003_6550.t8 VSS.t2904 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5143 VSS.t3230 VDD.t1311 a_48348_26907.t0 VSS.t3727 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5144 6MSB_0.OUTN.t26 a_10818_17714.t2 a_11523_17750.t7 VSS.t1216 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5145 a_44289_17490.t4 a_44199_17394# a_44123_17750.t6 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5146 VSS.t1253 a_n2042_972.t5 a_26665_6594.t0 VSS.t1252 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5147 a_42589_20531.t0 a_41652_20560.t2 a_42400_20293.t0 VDD.t801 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5148 a_34621_934.t2 a_35132_960.t2 a_35880_693.t1 VSS.t2179 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5149 VDD.t555 a_36108_3633.t2 a_36069_3731.t0 VDD.t290 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5150 a_3545_25331.t1 a_3509_25305.t2 VDD.t1088 VDD.t71 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X5151 a_40399_14914.t0 a_n2044_1752.t11 a_40298_14617.t0 VSS.t2821 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X5152 a_5169_11890.t4 a_5079_11794# a_5003_12150.t9 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5153 a_40855_616.t3 a_41652_960.t3 a_41115_839.t1 VDD.t448 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5154 VDD.t750 a_13625_17794.t2 a_13930_17398.t1 VDD.t748 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5155 a_31083_6550.t9 a_31159_6194# a_31249_6290.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5156 a_51440_25469.t1 a_50205_25015.t2 6MSB_0.OUTN.t3 VSS.t2595 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5157 a_27359_17714.t0 a_n2648_3264.t13 VDD.t1149 VDD.t733 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2184p ps=1.51u w=1.12u l=0.13u
X5158 VSS.t2232 VDD.t1691 a_47469_616.t0 VSS.t3988 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5159 VSS.t4276 a_49608_24288.t2 a_50205_23947.t0 VSS.t4279 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5160 a_8515_17639.t0 a_8950_17673.t3 a_8255_17416.t1 VSS.t3247 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5161 a_28075_14839.t0 a_28510_14873.t3 a_27815_14616.t0 VSS.t2943 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5162 a_26970_11798.t0 a_26665_12194.t2 VSS.t59 VSS.t58 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X5163 VDD.t474 a_13930_3398.t2 a_14319_3714.t2 VDD.t299 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5164 a_1178_617.t1 a_890_598.t2 VSS.t2032 VSS.t2033 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X5165 VDD.t598 X8.t1 a_n2857_1728.t0 VDD.t597 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X5166 a_7410_6198.t0 a_7105_6594.t2 VSS.t1257 VSS.t1551 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X5167 a_21555_839.t1 a_21990_873.t3 a_21295_616.t2 VSS.t2124 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X5168 a_44123_3750.t6 a_43418_3714.t2 6MSB_0.OUTN.t16 VSS.t1129 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5169 VSS.t256 VSS.t248 VSS.t255 VSS.t249 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X5170 a_37769_20290.t7 a_37679_20194# a_37603_20550.t4 VSS.t2334 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5171 a_47469_3416.t0 a_46919_3714.t3 a_47375_3416.t0 VSS.t1983 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5172 VSS.t3216 VDD.t1293 a_48157_24737.t0 VSS.t3699 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5173 a_44123_6550.t5 a_43418_6514.t2 6MSB_0.OUTN.t13 VSS.t1131 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5174 a_50809_14690.t6 a_50719_14594# a_50643_14950.t2 VSS.t2364 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5175 a_22840_11893.t0 a_21990_12073.t2 a_21581_12134.t3 VDD.t34 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X5176 a_10028_14833.t0 a_9800_14693.t2 a_10219_14616.t0 VSS.t2744 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X5177 a_41141_12134.t1 a_41115_12039.t3 VDD.t97 VDD.t91 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5178 a_21389_20216.t0 a_20839_20514.t3 a_21295_20216.t2 VSS.t3312 sg13_lv_nmos ad=60.89999f
+ pd=0.71u as=0.1428p ps=1.52u w=0.42u l=0.13u
X5179 VDD.t1382 VDD.t1379 a_27815_17416.t2 VDD.t733 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5180 VSS.t3613 a_37679_11794# a_37769_11890.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5181 VSS.t671 VSS.t670 a_50643_12150.t3 VSS.t423 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5182 a_31083_6550.t6 a_30378_6514.t2 6MSB_0.OUTN.t36 VSS.t1113 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5183 a_1997_24701.t0 X7.t1 a_2381_24931.t0 VSS.t106 sg13_lv_nmos ad=0.2176p pd=1.96u as=0.1216p
+ ps=1.02u w=0.64u l=0.13u
X5184 a_34429_6216.t0 a_33879_6514.t3 a_34335_6216.t0 VSS.t1666 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5185 VDD.t1077 a_33185_14994.t2 a_33490_14598.t1 VDD.t846 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5186 VSS.t601 VSS.t600 a_37603_12150.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X5187 a_4298_17714.t0 a_4081_17694.t2 VSS.t2389 VSS.t2388 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5188 a_27359_12114.t0 a_26970_11798.t2 VDD.t53 VDD.t50 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5189 VSS.t1190 a_48920_11893.t2 a_49517_12094.t0 VSS.t1188 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5190 VDD.t312 a_n2646_2484.t14 a_27359_6514.t0 VDD.t137 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5191 VSS.t723 VSS.t721 VSS.t722 VSS.t123 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X5192 6MSB_0.OUTP.t46 a_42997_3694.t2 a_44123_3750.t0 VSS.t1164 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5193 a_50027_24737.t0 VDD.t1289 VSS.t3713 VSS.t3712 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5194 VSS.t2866 a_16320_17493.t2 a_16917_17694.t0 VSS.t2864 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5195 a_2021_934.t0 a_1995_839.t3 VSS.t2036 VSS.t2035 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X5196 a_28390_3429.t0 a_28612_3760.t3 a_28075_3639.t1 VSS.t1868 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5197 a_15035_17639.t1 a_15470_17673.t3 a_14775_17416.t3 VSS.t3351 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5198 VSS.t1456 a_42628_9233.t2 a_42306_9093.t1 VSS.t1455 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5199 a_48018_9407.t0 a_47661_9334.t4 VDD.t271 VDD.t2 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5200 6MSB_0.OUTN.t12 a_43418_6514.t2 a_44123_6550.t4 VSS.t1128 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5201 a_24563_20550.t4 a_23437_20494.t2 6MSB_0.OUTP.t22 VSS.t2567 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5202 a_44289_17490.t1 a_44199_17394# VSS.t2493 VSS.t2405 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5203 VDD.t659 a_20450_598.t2 a_20839_914.t0 VDD.t458 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5204 VSS.t1967 a_42400_3493.t2 a_42997_3694.t0 VSS.t1965 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5205 a_50643_14950.t2 VSS.t437 VSS.t579 VSS.t419 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p
+ ps=1.98u w=0.65u l=0.45u
X5206 VDD.t161 a_n2042_972.t15 a_14319_9314.t0 VDD.t159 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5207 a_11523_950.t9 a_11599_594# a_11689_690.t7 VSS.t2353 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5208 a_23641_17694.t0 a_22840_17493.t2 VSS.t3406 VSS.t3407 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X5209 6MSB_0.OUTP.t72 a_29957_6494.t2 a_31083_6550.t0 VSS.t1116 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5210 a_5003_9350.t2 VSS.t645 VSS.t665 VSS.t664 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X5211 a_28101_6534.t0 a_28075_6439.t3 VSS.t1642 VSS.t1641 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5212 VSS.t1750 a_n2946_3612.t2 a_n2648_3264.t0 VSS.t1742 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5213 6MSB_0.OUTP.t38 a_50626_23927.t2 a_51453_23453.t2 VSS.t2296 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5214 a_44289_14690.t0 a_44199_14594# VSS.t435 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5215 a_14775_11816.t2 a_15572_12160.t3 a_15035_12039.t1 VDD.t25 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5216 a_3280_9093.t1 a_2430_9273.t2 a_3186_9093.t0 VSS.t1276 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5217 VSS.t1460 a_43201_9294.t2 a_43418_9314.t0 VSS.t1459 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5218 VDD.t405 a_39705_6594.t2 a_40010_6198.t1 VDD.t125 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5219 VSS.t2796 a_50719_6194# a_50809_6290.t0 VSS.t2365 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5220 VSS.t2612 a_15470_20473.t3 a_15572_20560.t0 VSS.t2611 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5221 a_44123_20550.t8 a_44199_20194# a_44289_20290.t5 VSS.t3157 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5222 VSS.t1652 a_29360_6293.t2 a_29957_6494.t0 VSS.t1650 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5223 VSS.t2030 a_n2966_249.t2 a_n2770_240.t0 VSS.t2029 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X5224 VSS.t1062 VSS.t1059 VSS.t1062 VSS.t1061 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X5225 a_29549_3731.t0 a_28612_3760.t2 a_29360_3493.t0 VDD.t295 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5226 a_37603_20550.t1 a_36477_20494.t2 6MSB_0.OUTP.t27 VSS.t2573 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5227 a_15061_9334.t0 a_15035_9239.t3 VSS.t1336 VSS.t1335 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5228 a_27359_9314.t1 a_n2042_972.t13 VDD.t154 VDD.t153 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5229 a_33185_994.t0 a_3545_25331.t2 VSS.t3062 VSS.t3061 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X5230 a_27359_3714.t2 a_26970_3398.t2 VDD.t535 VDD.t295 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5231 a_28075_6439.t0 a_28510_6473.t3 a_27815_6216.t2 VSS.t1646 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5232 a_5169_20290.t4 a_5079_20194# a_5003_20550.t6 VSS.t2906 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5233 a_43418_12114.t0 a_43201_12094.t2 VSS.t1157 VSS.t1156 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5234 a_n2042_972.t1 a_n2347_1368.t2 VDD.t605 VDD.t597 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5235 6MSB_0.OUTN.t65 a_36898_12114.t2 a_37603_12150.t9 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5236 VDD.t132 VDD.t1473 a_1735_9016.t1 VDD.t122 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5237 a_42997_6494.t0 a_42400_6293.t2 VSS.t1707 VSS.t1706 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5238 VSS.t453 a_24639_11794# a_24729_11890.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5239 a_29360_693.t0 a_28510_873.t2 a_28101_934.t3 VDD.t456 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X5240 a_41367_3429.t0 VDD.t1605 VSS.t3938 VSS.t3937 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5241 VDD.t426 a_49148_6433.t2 a_49109_6531.t0 VDD.t0 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5242 VSS.t532 VSS.t529 VSS.t532 VSS.t246 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5243 VSS.t707 VSS.t662 VSS.t707 VSS.t116 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5244 a_29957_9294.t0 a_29360_9093.t2 VSS.t1398 VSS.t1397 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5245 VSS.t1716 a_46225_6594.t2 a_46530_6198.t0 VSS.t1715 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X5246 VSS.t105 a_2713_25289.t2 a_2713_24910.t0 VSS.t3469 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X5247 6MSB_0.OUTN.t22 a_43418_17714.t2 a_44123_17750.t7 VSS.t2859 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5248 a_36108_17633.t0 VDD.t1385 VDD.t898 VDD.t893 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X5249 a_3280_6293.t0 a_2430_6473.t2 a_2021_6534.t3 VDD.t143 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X5250 VDD.t26 a_n2044_1752.t7 a_13719_12194.t0 VDD.t25 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X5251 a_22840_20293.t1 a_21990_20473.t2 a_21581_20534.t0 VDD.t11 sg13_lv_pmos ad=0.19115p pd=1.565u
+ as=0.34p ps=2.68u w=1u l=0.13u
X5252 VSS.t2709 a_26665_14994.t2 a_26970_14598.t0 VSS.t2708 sg13_lv_nmos ad=0.2812p pd=2.24u
+ as=0.1665p ps=1.19u w=0.74u l=0.13u
X5253 VDD.t242 a_36108_9233.t2 a_36069_9331.t0 VDD.t150 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5254 a_8767_629.t0 VDD.t1627 VSS.t3954 VSS.t3953 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5255 a_41141_20534.t2 a_41115_20439.t3 VDD.t857 VDD.t801 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5256 VDD.t1780 a_46225_17794.t2 a_46530_17398.t1 VDD.t905 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5257 a_14775_14616.t1 a_14319_14914.t3 VDD.t923 VDD.t887 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5258 a_23437_894.t0 a_22840_693.t2 VSS.t2131 VSS.t2130 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5259 a_34978_1007.t0 a_34621_934.t4 VDD.t692 VDD.t454 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5260 a_8541_20534.t1 a_9052_20560.t2 a_9800_20293.t0 VSS.t2420 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5261 a_35030_12073.t0 CLK.t34 VSS.t1104 VSS.t3622 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5262 a_31249_14690.t3 a_31159_14594# VSS.t4030 VSS.t2279 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5263 VDD.t774 a_7105_12194.t2 a_7410_11798.t1 VDD.t17 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5264 VDD.t1775 a_49608_24288.t2 a_50205_23947.t1 VDD.t760 sg13_lv_pmos ad=0.2083p pd=1.5u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X5265 a_27258_20217.t2 a_n2044_4040.t12 a_27359_20514.t1 VSS.t3543 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5266 a_26970_17398.t0 a_26665_17794.t2 VSS.t3413 VSS.t3412 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X5267 VSS.t532 a_11599_14594# a_11689_14690.t3 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5268 a_31083_12150.t1 a_29957_12094.t2 6MSB_0.OUTP.t79 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5269 VDD.t160 a_13930_8998.t2 a_14319_9314.t2 VDD.t159 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5270 a_27359_20514.t0 a_26970_20198.t2 VDD.t1096 VDD.t9 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5271 VSS.t630 VSS.t452 a_24563_12150.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5272 a_42997_12094.t0 a_42400_11893.t2 VSS.t1153 VSS.t1152 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5273 a_21555_17639.t0 a_21990_17673.t3 a_21938_17807.t0 VDD.t737 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X5274 a_40949_3416.t0 a_40399_3714.t3 a_40855_3416.t0 VSS.t1952 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5275 a_16548_3633.t0 a_16320_3493.t2 a_16739_3416.t0 VSS.t1856 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X5276 a_8830_11829.t0 a_8541_12134.t4 a_8767_11829.t0 VSS.t2442 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5277 a_47469_9016.t0 a_46919_9314.t3 a_47375_9016.t0 VSS.t1468 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5278 a_890_6198.t1 a_585_6594.t2 VDD.t144 VDD.t143 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5279 a_31083_14950.t5 a_30378_14914.t2 6MSB_0.OUTN.t67 VSS.t1115 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5280 a_16917_6494.t0 a_16320_6293.t2 VSS.t1598 VSS.t1597 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5281 a_27815_14616.t3 a_28612_14960.t3 a_28075_14839.t1 VDD.t884 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5282 a_42628_14833.t0 a_42400_14693.t2 a_42819_14616.t0 VSS.t2659 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X5283 VSS.t2171 a_33490_598.t2 a_33778_617.t0 VSS.t2172 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X5284 VSS.t849 VSS.t845 VSS.t848 VSS.t275 sg13_hv_nmos ad=0.221p pd=1.98u as=0 ps=0 w=0.65u l=0.45u
X5285 VSS.t2128 a_23068_833.t2 a_22746_693.t1 VSS.t2127 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5286 a_8950_3673.t0 CLK.t14 VSS.t1828 VSS.t3677 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5287 VSS.t4051 a_37679_17394# a_37769_17490.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5288 a_23641_14894.t1 a_22840_14693.t2 VDD.t880 VDD.t736 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5289 6MSB_0.OUTP.t116 a_49517_894.t2 a_50643_950.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5290 6MSB_0.OUTP.t77 a_3877_20494.t2 a_5003_20550.t8 VSS.t4125 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5291 a_5169_20290.t1 a_5079_20194# VSS.t3140 VSS.t2902 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5292 a_14775_20216.t0 a_15572_20560.t3 a_15035_20439.t1 VDD.t7 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5293 VDD.t512 a_16320_3493.t2 a_16548_3633.t1 VDD.t299 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5294 VDD.t75 a_2713_25289.t2 a_2713_24910.t1 VDD.t71 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5295 a_18043_20550.t9 a_17338_20514.t2 6MSB_0.OUTN.t118 VSS.t2881 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5296 VSS.t364 VSS.t362 a_37603_17750.t1 VSS.t363 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X5297 a_44289_11890.t6 a_44199_11794# a_44123_12150.t8 VSS.t2409 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5298 VSS.t2736 a_48920_17493.t2 a_49517_17694.t0 VSS.t2737 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5299 a_21990_14873.t0 CLK.t44 VSS.t3457 VSS.t3651 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5300 a_1279_914.t0 a_890_598.t2 VDD.t613 VDD.t462 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5301 a_21870_629.t0 a_22092_960.t3 a_21555_839.t1 VSS.t2120 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X5302 a_5003_14950.t4 a_5079_14594# a_5169_14690.t6 VSS.t2901 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5303 a_5003_12150.t5 a_4298_12114.t2 6MSB_0.OUTN.t78 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5304 VDD.t27 a_13625_12194.t2 a_13930_11798.t1 VDD.t25 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5305 a_34621_12134.t0 a_34595_12039.t3 VSS.t1099 VSS.t1098 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5306 a_28390_9029.t0 a_28612_9360.t3 a_28075_9239.t0 VSS.t1385 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5307 a_31249_3490.t0 a_31159_3394# VSS.t882 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5308 a_2021_12134.t1 a_2532_12160.t2 a_3280_11893.t0 VSS.t3384 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5309 a_27359_12114.t2 a_n2770_240.t13 VDD.t54 VDD.t50 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5310 VSS.t1453 a_42400_9093.t2 a_42997_9294.t0 VSS.t1451 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5311 a_8541_3734.t1 a_8515_3639.t3 VDD.t493 VDD.t301 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5312 a_29360_693.t1 a_28510_873.t2 a_29266_693.t0 VSS.t2150 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5313 a_33185_20594.t0 a_3545_25331.t9 VSS.t2991 VSS.t2990 sg13_lv_nmos ad=0.1045p pd=0.93u
+ as=0.187p ps=1.78u w=0.55u l=0.13u
X5314 a_1178_14617.t1 a_n2044_1752.t17 a_1279_14914.t0 VSS.t2834 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5315 VSS.t3618 a_37679_11794# a_37769_11890.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5316 a_21581_6534.t0 a_21555_6439.t3 VSS.t1614 VSS.t1613 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5317 a_15350_11829.t1 a_15061_12134.t4 a_15287_11829.t0 VSS.t3395 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5318 a_20738_11817.t2 a_n2770_240.t14 a_20839_12114.t1 VSS.t3376 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5319 VSS.t1243 a_585_9394.t2 a_890_8998.t0 VSS.t1242 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X5320 a_23641_894.t1 a_22840_693.t2 VDD.t667 VDD.t458 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5321 a_1279_14914.t2 a_890_14598.t2 VDD.t960 VDD.t817 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5322 a_31083_14950.t4 a_29957_14894.t2 6MSB_0.OUTP.t10 VSS.t1117 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5323 VSS.t1755 a_n2042_2484.t7 a_13625_994.t0 VSS.t1754 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5324 a_7410_17398.t1 a_7105_17794.t2 VDD.t990 VDD.t741 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5325 a_10601_17694.t1 a_9800_17493.t2 VDD.t744 VDD.t741 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5326 a_29549_9331.t0 a_28612_9360.t2 a_29360_9093.t0 VDD.t153 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5327 VSS.t1502 VDD.t1521 a_1829_6216.t0 VSS.t3880 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5328 VDD.t982 a_28510_14873.t3 a_28612_14960.t1 VDD.t884 sg13_lv_pmos ad=1.8612p pd=11.92u
+ as=0.3864p ps=2.93u w=1.12u l=0.13u
X5329 a_20839_3714.t2 a_20450_3398.t2 VDD.t520 VDD.t297 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5330 6MSB_0.OUTP.t61 a_10397_20494.t2 a_11523_20550.t6 VSS.t4129 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5331 VDD.t8 VSS.t259 a_13719_20594.t0 VDD.t7 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p ps=1.22u
+ w=0.84u l=0.13u
X5332 a_27359_9314.t2 a_26970_8998.t2 VDD.t222 VDD.t153 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5333 a_24563_950.t7 a_24639_594# a_24729_690.t4 VSS.t3120 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5334 VDD.t56 VDD.t1449 a_27815_11816.t1 VDD.t50 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5335 a_16917_894.t1 a_16320_693.t2 VDD.t650 VDD.t444 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X5336 a_7799_914.t2 VDD.t1629 VDD.t629 VDD.t460 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p ps=1.51u
+ w=1.12u l=0.13u
X5337 VSS.t158 VSS.t156 a_51442_27857.t1 VSS.t157 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X5338 6MSB_0.OUTN.t18 a_4298_20514.t2 a_5003_20550.t7 VSS.t4131 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5339 a_43418_17714.t0 a_43201_17694.t2 VSS.t4289 VSS.t4288 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5340 a_50643_14950.t5 a_50719_14594# a_50809_14690.t7 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5341 a_18043_20550.t0 VSS.t217 VSS.t219 VSS.t218 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5342 6MSB_0.OUTN.t47 a_36898_17714.t2 a_37603_17750.t6 VSS.t1202 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5343 VSS.t395 a_24639_17394# a_24729_17490.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5344 a_31249_14690.t7 a_31159_14594# a_31083_14950.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5345 a_37769_11890.t2 a_37679_11794# VSS.t3615 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5346 a_41367_9029.t0 VDD.t1509 VSS.t3874 VSS.t3873 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5347 VDD.t1068 a_7105_20594.t2 a_7410_20198.t1 VDD.t762 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5348 a_21581_14934.t0 a_21555_14839.t3 VSS.t2733 VSS.t2732 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5349 VSS.t59 a_n2044_1752.t5 a_26665_12194.t0 VSS.t2814 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5350 a_27909_616.t0 a_27359_914.t3 a_27815_616.t0 VSS.t2145 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5351 a_20239_3794.t0 a_521_25453.t3 a_20145_3794.t1 VDD.t297 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X5352 a_11523_12150.t5 a_10818_12114.t2 6MSB_0.OUTN.t62 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5353 VDD.t411 a_42628_6433.t2 a_42589_6531.t0 VDD.t125 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5354 a_48829_27232.t0 a_48540_27537.t4 a_48766_27232.t0 VSS.t3034 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5355 a_20839_20514.t1 a_n2044_4040.t13 a_20738_20217.t1 VSS.t3544 sg13_lv_nmos ad=0.1368p pd=1.1u
+ as=0.1404p ps=1.11u w=0.72u l=0.13u
X5356 a_5003_12150.t0 VSS.t586 VSS.t587 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5357 VSS.t2484 a_36681_20494.t2 a_36898_20514.t0 VSS.t2483 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5358 VSS.t4159 a_24639_14594# a_24729_14690.t2 VSS.t3124 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5359 VSS.t975 a_37679_3394# a_37769_3490.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5360 a_29588_3633.t1 VDD.t1597 VDD.t540 VDD.t295 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X5361 VSS.t268 VSS.t126 a_24563_20550.t3 VSS.t127 sg13_hv_nmos ad=0.221p pd=1.98u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5362 a_33490_8998.t0 a_33185_9394.t2 VSS.t1406 VSS.t1405 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X5363 a_31083_950.t9 a_31159_594# a_31249_690.t7 VSS.t2278 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5364 a_50809_14690.t7 a_50719_14594# a_50643_14950.t4 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5365 a_8767_11829.t0 VDD.t1273 VSS.t3694 VSS.t3693 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5366 a_16917_12094.t0 a_16320_11893.t2 VSS.t23 VSS.t22 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5367 VSS.t842 a_24639_6194# a_24729_6290.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5368 VDD.t449 a_n2042_2484.t3 a_39799_994.t0 VDD.t448 sg13_lv_pmos ad=0.2226p pd=1.535u as=0.1596p
+ ps=1.22u w=0.84u l=0.13u
X5369 a_41115_839.t0 a_41550_873.t3 a_40855_616.t2 VSS.t2208 sg13_lv_nmos ad=81f pd=0.81u as=0.1296p
+ ps=1.52u w=0.42u l=0.13u
X5370 VSS.t1148 a_41550_12073.t3 a_41652_12160.t0 VSS.t1147 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5371 a_n2044_1752.t1 a_n2342_2100.t2 VDD.t600 VDD.t597 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.1918p
+ ps=1.5u w=1.12u l=0.13u
X5372 a_35030_17673.t0 CLK.t50 VSS.t3279 VSS.t3646 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5373 a_8541_3734.t2 a_9052_3760.t2 a_9800_3493.t1 VSS.t1825 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5374 a_44289_20290.t6 a_44199_20194# a_44123_20550.t9 VSS.t3160 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5375 6MSB_0.OUTN.t120 a_10818_20514.t2 a_11523_20550.t4 VSS.t2559 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5376 a_31083_17750.t1 a_29957_17694.t2 6MSB_0.OUTP.t131 VSS.t1119 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5377 a_37769_3490.t7 a_37679_3394# a_37603_3750.t8 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5378 VDD.t761 VDD.t1317 a_48323_23895.t2 VDD.t760 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X5379 a_42997_17694.t0 a_42400_17493.t2 VSS.t3252 VSS.t3251 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5380 VSS.t2755 a_n2648_3264.t7 a_13625_14994.t0 VSS.t3420 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5381 VDD.t783 a_48920_14693.t2 a_49517_14894.t1 VDD.t3 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5382 a_16548_9233.t0 a_16320_9093.t2 a_16739_9016.t0 VSS.t1344 sg13_lv_nmos ad=0.1428p pd=1.52u
+ as=37.8f ps=0.6u w=0.42u l=0.13u
X5383 a_7105_6594.t0 a_2713_24910.t4 VSS.t2806 VSS.t2805 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X5384 a_48897_26516.t0 a_48540_26473.t4 VDD.t1015 VDD.t13 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5385 VDD.t1782 a_13625_20594.t2 a_13930_20198.t1 VDD.t7 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5386 a_8830_17429.t1 a_8541_17734.t4 a_8767_17429.t0 VSS.t3242 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5387 a_28101_17734.t3 a_28075_17639.t3 VDD.t1382 VDD.t733 sg13_lv_pmos ad=0.34p pd=2.68u
+ as=0.36237p ps=2.605u w=1u l=0.13u
X5388 a_40949_9016.t0 a_40399_9314.t3 a_40855_9016.t0 VSS.t1440 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5389 a_24729_6290.t7 a_24639_6194# a_24563_6550.t8 VSS.t3123 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5390 a_8515_20439.t0 a_8950_20473.t3 a_8255_20216.t0 VSS.t2421 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5391 a_27359_20514.t2 a_n2044_4040.t12 VDD.t1097 VDD.t9 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5392 a_8950_9273.t0 CLK.t30 VSS.t1318 VSS.t3661 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5393 6MSB_0.OUTP.t2 a_49517_6494.t2 a_50643_6550.t0 VSS.t90 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5394 VSS.t3499 a_31159_594# a_31249_690.t1 VSS.t3498 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5395 a_50600_26513.t0 a_49799_26830.t2 VSS.t2578 VSS.t2579 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X5396 a_33778_14617.t0 a_33490_14598.t2 VSS.t4193 VSS.t4194 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5397 a_36108_12033.t1 VDD.t1459 VDD.t83 VDD.t66 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X5398 VDD.t201 a_16320_9093.t2 a_16548_9233.t1 VDD.t159 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5399 a_7199_14994.t0 a_2713_24910.t7 a_7105_14994.t1 VDD.t912 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X5400 a_15350_11829.t0 a_15572_12160.t3 a_15035_12039.t0 VSS.t3392 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5401 a_21295_3416.t1 a_20839_3714.t3 VDD.t522 VDD.t297 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5402 a_46818_6217.t1 a_n2646_2484.t11 a_46919_6514.t1 VSS.t1519 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5403 a_44289_6290.t0 a_44199_6194# VSS.t835 VSS.t2403 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5404 a_15287_11829.t0 VDD.t1441 VSS.t3827 VSS.t3826 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5405 6MSB_0.OUTP.t63 a_42997_9294.t2 a_44123_9350.t6 VSS.t1166 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5406 a_18209_690.t7 a_18119_594# a_18043_950.t8 VSS.t2261 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5407 a_50809_3490.t6 a_50719_3394# a_50643_3750.t9 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5408 a_1735_17416.t0 a_2532_17760.t3 a_1995_17639.t0 VDD.t752 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5409 a_50643_14950.t1 a_49517_14894.t2 6MSB_0.OUTP.t75 VSS.t93 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5410 VDD.t108 a_46225_12194.t2 a_46530_11798.t1 VDD.t1 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5411 a_46919_3714.t2 a_46530_3398.t2 VDD.t582 VDD.t293 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5412 a_5003_17750.t5 a_4298_17714.t2 6MSB_0.OUTN.t130 VSS.t1209 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5413 a_17338_14914.t1 a_17121_14894.t2 VDD.t1019 VDD.t887 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X5414 VDD.t1344 VDD.t1291 a_27815_20216.t2 VDD.t9 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5415 a_34621_17734.t2 a_34595_17639.t3 VSS.t3203 VSS.t3202 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5416 a_31249_9090.t0 a_31159_8994# VSS.t733 VSS.t2273 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5417 VSS.t1079 VSS.t1077 VSS.t1079 VSS.t1078 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u
+ l=0.45u
X5418 a_3877_3694.t1 a_3280_3493.t2 VDD.t483 VDD.t303 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X5419 a_2021_17734.t2 a_2532_17760.t2 a_3280_17493.t1 VSS.t2978 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5420 a_24563_14950.t6 a_23858_14914.t2 6MSB_0.OUTN.t70 VSS.t1134 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5421 VSS.t2977 a_48758_24994.t3 a_48860_25081.t0 VSS.t2976 sg13_lv_nmos ad=3.46352p pd=12.58u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5422 a_47950_11829.t1 a_47661_12134.t4 a_47887_11829.t0 VSS.t1180 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5423 a_8541_9334.t1 a_8515_9239.t3 VDD.t184 VDD.t162 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5424 VSS.t4055 a_37679_17394# a_37769_17490.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5425 VSS.t3100 a_11599_6194# a_11689_6290.t1 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5426 a_33879_6514.t2 a_33490_6198.t2 VDD.t391 VDD.t135 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5427 a_4298_20514.t0 a_4081_20494.t2 VSS.t3265 VSS.t3264 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5428 a_15350_17429.t1 a_15061_17734.t4 a_15287_17429.t0 VSS.t3348 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5429 a_5003_3750.t8 a_5079_3394# a_5169_3490.t5 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5430 VSS.t2923 a_16320_20293.t2 a_16917_20494.t0 VSS.t2921 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5431 a_20738_17417.t2 a_n2648_3264.t14 a_20839_17714.t1 VSS.t3433 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5432 a_21555_12039.t0 a_21990_12073.t3 a_21938_12207.t0 VDD.t34 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X5433 a_46319_3794.t0 VSS.t989 a_46225_3794.t1 VDD.t293 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X5434 a_35030_14873.t1 CLK.t42 VDD.t1222 VDD.t846 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X5435 VDD.t678 a_29588_833.t2 a_29549_931.t0 VDD.t456 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5436 a_15035_20439.t0 a_15470_20473.t3 a_14775_20216.t1 VSS.t2610 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5437 a_10818_914.t0 a_10601_894.t2 VSS.t2080 VSS.t2079 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5438 a_48766_27232.t0 VDD.t1301 VSS.t3735 VSS.t3734 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5439 a_44289_20290.t1 a_44199_20194# VSS.t3164 VSS.t3156 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5440 a_20839_9314.t2 a_20450_8998.t2 VDD.t207 VDD.t156 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5441 a_23641_20494.t0 a_22840_20293.t2 VSS.t4231 VSS.t4232 sg13_lv_nmos ad=0.2176p pd=1.96u
+ as=0.1331p ps=1.12u w=0.64u l=0.13u
X5442 a_1279_14914.t1 a_n2044_1752.t17 VDD.t953 VDD.t817 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5443 VSS.t2432 a_3280_11893.t2 a_3877_12094.t0 VSS.t2431 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5444 a_33279_6594.t0 a_3545_25331.t4 a_33185_6594.t1 VDD.t135 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X5445 VSS.t2212 a_42628_833.t2 a_42306_693.t1 VSS.t2211 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5446 a_50817_27517.t0 a_50600_27497.t2 VSS.t2 VSS.t1 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5447 a_1995_12039.t0 a_2430_12073.t3 a_1735_11816.t0 VSS.t3385 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5448 a_18209_690.t1 a_18119_594# VSS.t2636 VSS.t2637 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5449 a_37603_6550.t2 VSS.t829 VSS.t853 VSS.t286 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X5450 a_44289_690.t0 a_44199_594# VSS.t1075 VSS.t3601 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5451 a_37769_17490.t2 a_37679_17394# VSS.t4053 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5452 a_44123_14950.t4 a_44199_14594# a_44289_14690.t6 VSS.t2404 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5453 a_44123_12150.t9 a_43418_12114.t2 6MSB_0.OUTN.t60 VSS.t1129 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5454 a_18209_3490.t5 a_18119_3394# a_18043_3750.t7 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5455 a_11523_17750.t9 a_10818_17714.t2 6MSB_0.OUTN.t26 VSS.t1217 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5456 VSS.t3413 a_n2044_4040.t5 a_26665_17794.t0 VSS.t3534 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5457 VDD.t1021 a_n2648_3264.t6 a_20239_14994.t0 VDD.t736 sg13_lv_pmos ad=0.2226p pd=1.535u
+ as=0.1596p ps=1.22u w=0.84u l=0.13u
X5458 6MSB_0.OUTP.t37 a_16917_9294.t2 a_18043_9350.t5 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5459 a_20239_9394.t0 a_521_25453.t5 a_20145_9394.t1 VDD.t156 sg13_lv_pmos ad=0.1596p pd=1.22u
+ as=0.2856p ps=2.36u w=0.84u l=0.13u
X5460 a_28390_3429.t1 a_28101_3734.t4 a_28327_3429.t0 VSS.t1902 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5461 a_24729_14690.t6 a_24639_14594# a_24563_14950.t7 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5462 a_41141_12134.t3 a_41652_12160.t2 a_42400_11893.t1 VSS.t1145 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5463 a_42997_894.t0 a_42400_693.t2 VSS.t2215 VSS.t2214 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5464 VDD.t585 VDD.t1611 a_47375_3416.t1 VDD.t293 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5465 VDD.t489 a_7105_3794.t2 a_7410_3398.t1 VDD.t301 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5466 a_5003_17750.t0 VSS.t344 VSS.t346 VSS.t345 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5467 a_34910_14629.t1 a_34621_14934.t4 a_34847_14629.t0 VSS.t4198 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5468 a_29588_9233.t1 VDD.t1501 VDD.t227 VDD.t153 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p ps=11.92u
+ w=0.42u l=0.13u
X5469 VSS.t752 a_37679_8994# a_37769_9090.t3 VSS.t2339 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5470 a_40298_14617.t1 a_n2044_1752.t11 a_40399_14914.t0 VSS.t2822 sg13_lv_nmos ad=0.2448p pd=2.12u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5471 a_41430_629.t0 a_41652_960.t3 a_41115_839.t0 VSS.t2202 sg13_lv_nmos ad=0.2163p pd=1.87u as=81f
+ ps=0.81u w=0.42u l=0.13u
X5472 a_11523_950.t8 a_11599_594# a_11689_690.t5 VSS.t2351 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5473 6MSB_0.OUTP.t109 a_29957_894.t2 a_31083_950.t5 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5474 a_48829_26894.t1 a_48540_26473.t4 a_48766_26894.t0 VSS.t3034 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5475 a_51440_25469.t6 4LSB_weighted_0.VBIAS a_51516_24785.t5 VSS.t4065 sg13_hv_nmos ad=57f pd=0.68u
+ as=57f ps=0.68u w=0.3u l=0.45u
X5476 a_40399_14914.t2 a_40010_14598.t2 VDD.t1750 VDD.t810 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.4032p ps=2.96u w=1.12u l=0.13u
X5477 a_15350_6229.t1 a_15061_6534.t4 a_15287_6229.t0 VSS.t1588 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5478 a_21990_17673.t1 CLK.t52 VDD.t1216 VDD.t737 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X5479 VDD.t1150 a_n2648_3264.t13 a_27359_17714.t0 VDD.t733 sg13_lv_pmos ad=0.392p pd=2.94u
+ as=0.2128p ps=1.5u w=1.12u l=0.13u
X5480 VDD.t394 VDD.t1551 a_34335_6216.t1 VDD.t135 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5481 a_8767_17429.t0 VDD.t1357 VSS.t3771 VSS.t3770 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5482 a_16917_17694.t0 a_16320_17493.t2 VSS.t2865 VSS.t2864 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5483 VDD.t1020 a_17121_14894.t2 a_17338_14914.t1 VDD.t887 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X5484 a_48920_693.t1 a_48070_873.t2 a_48826_693.t0 VSS.t2234 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5485 VSS.t1753 a_585_3794.t2 a_890_3398.t0 VSS.t1752 sg13_lv_nmos ad=0.2812p pd=2.24u as=0.1665p
+ ps=1.19u w=0.74u l=0.13u
X5486 a_28390_14629.t0 a_28612_14960.t3 a_28075_14839.t0 VSS.t2771 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5487 a_28327_14629.t0 VDD.t1417 VSS.t3810 VSS.t3809 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5488 a_49988_26592.t0 a_49051_26480.t2 a_49799_26830.t1 VDD.t13 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5489 VSS.t3263 a_41550_17673.t3 a_41652_17760.t0 VSS.t3262 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5490 VSS.t35 a_20450_11798.t2 a_20738_11817.t0 VSS.t36 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X5491 VSS.t634 VSS.t462 VSS.t634 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5492 6MSB_0.OUTN.t132 a_43418_20514.t2 a_44123_20550.t4 VSS.t2859 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5493 a_7410_11798.t1 a_7105_12194.t2 VDD.t773 VDD.t17 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5494 a_10601_12094.t1 a_9800_11893.t2 VDD.t20 VDD.t17 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5495 a_8541_9334.t2 a_9052_9360.t2 a_9800_9093.t1 VSS.t1315 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5496 VSS.t2126 a_21990_873.t3 a_22092_960.t0 VSS.t2125 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5497 a_2713_25289.t0 X7.t4 VSS.t105 VSS.t104 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.14642p ps=1.155u
+ w=0.55u l=0.13u
X5498 a_36108_20433.t1 VDD.t1349 VDD.t794 VDD.t793 sg13_lv_pmos ad=79.8f pd=0.8u as=1.8612p
+ ps=11.92u w=0.42u l=0.13u
X5499 VSS.t68 VDD.t1449 a_27909_11816.t0 VSS.t3833 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5500 VSS.t833 VSS.t832 VSS.t833 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5501 a_31249_3490.t7 a_31159_3394# a_31083_3750.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5502 a_28510_3673.t1 CLK.t11 VDD.t540 VDD.t295 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X5503 a_37769_9090.t7 a_37679_8994# a_37603_9350.t8 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5504 a_50396_27497.t0 a_49799_27296.t2 VSS.t4148 VSS.t2575 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5505 a_27815_3416.t2 a_28612_3760.t3 a_28075_3639.t0 VDD.t295 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5506 a_18043_6550.t3 a_18119_6194# a_18209_6290.t6 VSS.t2264 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5507 a_44123_12150.t0 VSS.t610 VSS.t611 VSS.t514 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5508 a_15470_6473.t1 CLK.t21 VDD.t351 VDD.t127 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X5509 a_31083_14950.t3 a_31159_14594# a_31249_14690.t6 VSS.t2280 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5510 a_26970_20198.t0 a_26665_20594.t2 VSS.t273 VSS.t2546 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X5511 a_18209_17490.t5 a_18119_17394# a_18043_17750.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5512 a_48349_23931.t0 a_48860_23938.t2 a_49608_24288.t1 VSS.t2400 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5513 a_47887_11829.t0 VDD.t1467 VSS.t3846 VSS.t3845 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5514 a_21555_20439.t0 a_21990_20473.t3 a_21938_20607.t0 VDD.t11 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X5515 a_21295_9016.t1 a_20839_9314.t3 VDD.t209 VDD.t156 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5516 a_3280_693.t0 a_2430_873.t2 a_2021_934.t3 VDD.t462 sg13_lv_pmos ad=0.19115p pd=1.565u as=0.34p
+ ps=2.68u w=1u l=0.13u
X5517 a_33490_3398.t0 a_33185_3794.t2 VSS.t1504 VSS.t1919 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X5518 a_15350_17429.t0 a_15572_17760.t3 a_15035_17639.t1 VSS.t3347 sg13_lv_nmos ad=0.2163p pd=1.87u
+ as=81f ps=0.81u w=0.42u l=0.13u
X5519 a_15287_17429.t0 VDD.t1367 VSS.t3776 VSS.t3775 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5520 a_4341_25535.t0 X6.t0 VSS.t3344 VSS.t3573 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.1331p ps=1.12u
+ w=0.64u l=0.13u
X5521 a_49938_14914.t1 a_49721_14894.t2 VDD.t786 VDD.t3 sg13_lv_pmos ad=0.2156p pd=1.505u as=0.3808p
+ ps=2.92u w=1.12u l=0.13u
X5522 a_50809_9090.t6 a_50719_8994# a_50643_9350.t9 VSS.t2370 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5523 a_n2770_240.t0 a_n2966_249.t2 VSS.t2028 VSS.t2027 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.1371p
+ ps=1.12u w=0.74u l=0.13u
X5524 VSS.t1909 a_28510_3673.t3 a_28612_3760.t0 VSS.t1908 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5525 a_35880_11893.t1 a_35030_12073.t2 a_35786_11893.t0 VSS.t97 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5526 a_46919_9314.t2 a_46530_8998.t2 VDD.t267 VDD.t2 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.4032p
+ ps=2.96u w=1.12u l=0.13u
X5527 a_1317_25535.t0 X6.t4 VSS.t2601 VSS.t3571 sg13_lv_nmos ad=0.1216p pd=1.02u as=0.1331p ps=1.12u
+ w=0.64u l=0.13u
X5528 VSS.t2343 a_37679_20194# a_37769_20290.t0 VSS.t2333 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5529 a_20450_6198.t0 a_20145_6594.t2 VSS.t1255 VSS.t1605 sg13_lv_nmos ad=0.1665p pd=1.19u
+ as=0.14642p ps=1.155u w=0.74u l=0.13u
X5530 VSS.t1769 a_n2042_2484.t4 a_33185_994.t0 VSS.t1768 sg13_lv_nmos ad=0.14642p pd=1.155u
+ as=0.1045p ps=0.93u w=0.55u l=0.13u
X5531 a_3877_9294.t1 a_3280_9093.t2 VDD.t168 VDD.t122 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X5532 a_2021_6534.t0 a_1995_6439.t3 VSS.t1502 VSS.t1501 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X5533 VDD.t1000 VDD.t1301 a_48514_27442.t0 VDD.t14 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X5534 VSS.t1595 a_15470_6473.t3 a_15572_6560.t0 VSS.t1594 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5535 VSS.t153 VSS.t151 a_37603_20550.t1 VSS.t152 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X5536 a_47950_17429.t1 a_47661_17734.t4 a_47887_17429.t0 VSS.t4319 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5537 VSS.t1186 a_49148_12033.t2 a_48826_11893.t1 VSS.t1185 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5538 a_34978_15007.t0 a_34621_14934.t4 VDD.t1416 VDD.t846 sg13_lv_pmos ad=54.6f pd=0.68u as=0.1563p
+ ps=1.22u w=0.42u l=0.13u
X5539 a_15035_6439.t0 a_15470_6473.t3 a_15418_6607.t0 VDD.t127 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X5540 a_5003_9350.t8 a_5079_8994# a_5169_9090.t5 VSS.t2903 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5541 a_46319_9394.t0 VSS.t759 a_46225_9394.t1 VDD.t2 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X5542 a_36477_894.t1 a_35880_693.t2 VDD.t695 VDD.t454 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X5543 VDD.t1426 VDD.t1415 a_34335_14616.t0 VDD.t846 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5544 a_37769_14690.t4 a_37679_14594# a_37603_14950.t2 VSS.t2332 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5545 a_28101_12134.t1 a_28075_12039.t3 VDD.t56 VDD.t50 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5546 a_11689_690.t5 a_11599_594# a_11523_950.t7 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5547 a_42400_3493.t1 a_41550_3673.t2 a_42306_3493.t0 VSS.t1957 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5548 a_47469_616.t0 a_46919_914.t3 a_47375_616.t0 VSS.t2229 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5549 VSS.t2465 a_49721_14894.t2 a_49938_14914.t0 VSS.t2464 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5550 VSS.t2386 a_3280_17493.t2 a_3877_17694.t0 VSS.t2385 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5551 VDD.t889 a_16320_14693.t2 a_16548_14833.t1 VDD.t887 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5552 a_46319_14994.t0 VSS.t573 a_46225_14994.t1 VDD.t3 sg13_lv_pmos ad=0.1596p pd=1.22u as=0.2856p
+ ps=2.36u w=0.84u l=0.13u
X5553 VSS.t2217 a_42400_693.t2 a_42997_894.t0 VSS.t2216 sg13_lv_nmos ad=0.1331p pd=1.12u as=0.1406p
+ ps=1.12u w=0.74u l=0.13u
X5554 a_48766_26894.t0 VDD.t1311 VSS.t3744 VSS.t3734 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5555 a_1995_17639.t1 a_2430_17673.t3 a_1735_17416.t3 VSS.t2979 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5556 a_20839_17714.t2 a_n2648_3264.t14 VDD.t1006 VDD.t737 sg13_lv_pmos ad=0.2128p pd=1.5u
+ as=0.2184p ps=1.51u w=1.12u l=0.13u
X5557 a_36898_17714.t1 a_36681_17694.t2 VDD.t899 VDD.t893 sg13_lv_pmos ad=0.2156p pd=1.505u
+ as=0.3808p ps=2.92u w=1.12u l=0.13u
X5558 a_40855_17416.t2 a_41652_17760.t3 a_41115_17639.t1 VDD.t812 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5559 a_20450_11798.t0 a_20145_12194.t2 VSS.t31 VSS.t30 sg13_lv_nmos ad=0.1665p pd=1.19u as=0.14642p
+ ps=1.155u w=0.74u l=0.13u
X5560 VDD.t426 a_48070_6473.t3 a_48172_6560.t1 VDD.t0 sg13_lv_pmos ad=1.8612p pd=11.92u as=0.3864p
+ ps=2.93u w=1.12u l=0.13u
X5561 a_44123_17750.t8 a_43418_17714.t2 6MSB_0.OUTN.t22 VSS.t2860 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5562 a_18209_6290.t3 a_18119_6194# VSS.t2269 VSS.t2263 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5563 a_24563_950.t3 a_24639_594# a_24729_690.t6 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5564 a_11689_3490.t5 a_11599_3394# a_11523_3750.t7 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5565 a_7410_20198.t1 a_7105_20594.t2 VDD.t1067 VDD.t762 sg13_lv_pmos ad=0.252p pd=1.57u as=0.2226p
+ ps=1.535u w=1.12u l=0.13u
X5566 a_10601_20494.t1 a_9800_20293.t2 VDD.t1785 VDD.t762 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
X5567 VDD.t1055 VDD.t1357 a_8515_17639.t2 VDD.t741 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X5568 a_18209_9090.t5 a_18119_8994# a_18043_9350.t7 VSS.t2259 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5569 a_50643_950.t9 a_50719_594# a_50809_690.t7 VSS.t2369 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5570 a_21870_3429.t1 a_21581_3734.t4 a_21807_3429.t0 VSS.t1876 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5571 6MSB_0.OUTP.t47 a_42997_3694.t2 a_44123_3750.t5 VSS.t1166 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5572 a_41141_17734.t2 a_41652_17760.t2 a_42400_17493.t1 VSS.t3260 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5573 a_1735_11816.t1 a_2532_12160.t3 a_1995_12039.t1 VDD.t765 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5574 VDD.t176 a_7105_9394.t2 a_7410_8998.t1 VDD.t162 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5575 a_28390_9029.t1 a_28101_9334.t4 a_28327_9029.t0 VSS.t1388 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5576 VDD.t270 VDD.t1515 a_47375_9016.t1 VDD.t2 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5577 VSS.t1928 VDD.t1599 a_34429_3416.t0 VSS.t3932 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5578 VSS.t3817 a_36108_14833.t2 a_35786_14693.t1 VSS.t4200 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5579 a_15470_873.t0 CLK.t5 VSS.t2098 VSS.t3686 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5580 a_36477_17694.t1 a_35880_17493.t2 VDD.t894 VDD.t893 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2014p
+ ps=1.53u w=1.12u l=0.13u
X5581 a_43418_20514.t0 a_43201_20494.t2 VSS.t2673 VSS.t2672 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5582 a_33185_9394.t0 a_3545_25331.t5 VSS.t3037 VSS.t3036 sg13_lv_nmos ad=0.1045p pd=0.93u as=0.187p
+ ps=1.78u w=0.55u l=0.13u
X5583 6MSB_0.OUTN.t9 a_36898_20514.t2 a_37603_20550.t9 VSS.t4118 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5584 VDD.t1008 VDD.t1371 a_21295_17416.t1 VDD.t737 sg13_lv_pmos ad=0.36237p pd=2.605u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5585 VSS.t3577 a_31159_11794# a_31249_11890.t0 VSS.t2274 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5586 6MSB_0.OUTP.t73 a_29957_6494.t2 a_31083_6550.t5 VSS.t1118 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5587 VDD.t285 a_890_6198.t2 a_1279_6514.t0 VDD.t143 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5588 a_40298_6217.t0 a_40010_6198.t2 VSS.t1691 VSS.t1692 sg13_lv_nmos ad=0.1404p pd=1.11u
+ as=0.1368p ps=1.1u w=0.72u l=0.13u
X5589 VSS.t980 VSS.t979 VSS.t980 VSS.t130 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5590 VSS.t128 a_24639_20194# a_24729_20290.t3 VSS.t3126 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5591 VSS.t1614 VDD.t1539 a_21389_6216.t0 VSS.t3892 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5592 a_11689_11890.t1 a_11599_11794# VSS.t3479 VSS.t2350 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5593 a_18043_9350.t0 VSS.t686 VSS.t687 VSS.t336 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5594 a_44289_6290.t7 a_44199_6194# a_44123_6550.t8 VSS.t2407 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5595 VSS.t583 VSS.t582 a_31083_12150.t1 VSS.t360 sg13_lv_nmos ad=0.17p pd=1.68u as=95f ps=0.88u
+ w=0.5u l=0.13u
X5596 a_3877_3694.t0 a_3280_3493.t2 VSS.t1803 VSS.t1802 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5597 a_3545_25331.t0 a_3509_25305.t2 VSS.t3342 VSS.t3341 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2812p ps=2.24u w=0.74u l=0.13u
X5598 VSS.t413 VSS.t408 VSS.t413 VSS.t301 sg13_hv_nmos ad=0.1235p pd=1.03u as=0 ps=0 w=0.65u l=0.45u
X5599 a_40399_14914.t1 a_n2044_1752.t11 VDD.t941 VDD.t810 sg13_lv_pmos ad=0.2128p pd=1.5u as=0.2184p
+ ps=1.51u w=1.12u l=0.13u
X5600 a_44123_14950.t6 a_44199_14594# a_44289_14690.t5 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5601 VSS.t1154 a_42400_11893.t2 a_42997_12094.t0 VSS.t1152 sg13_lv_nmos ad=0.1331p pd=1.12u
+ as=0.1406p ps=1.12u w=0.74u l=0.13u
X5602 a_33778_617.t1 a_33490_598.t2 VSS.t2171 VSS.t2170 sg13_lv_nmos ad=0.1404p pd=1.11u as=0.1368p
+ ps=1.1u w=0.72u l=0.13u
X5603 a_51768_27313.t1 VSS.t143 VSS.t155 VSS.t144 sg13_hv_nmos ad=57f pd=0.68u as=0.102p ps=1.28u
+ w=0.3u l=0.45u
X5604 a_1253_24711.t1 a_1201_24685.t2 VDD.t1002 VDD.t76 sg13_lv_pmos ad=0.252p pd=1.57u as=0.4256p
+ ps=3u w=1.12u l=0.13u
X5605 VSS.t3079 a_20450_17398.t2 a_20738_17417.t0 VSS.t3078 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.27p
+ ps=2.19u w=0.72u l=0.13u
X5606 a_8767_6229.t0 VDD.t1527 VSS.t3885 VSS.t3884 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5607 a_23259_616.t0 VDD.t1655 VSS.t2128 VSS.t3967 sg13_lv_nmos ad=37.8f pd=0.6u as=79.8f ps=0.8u
+ w=0.42u l=0.13u
X5608 a_21990_3673.t1 CLK.t12 VDD.t525 VDD.t297 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X5609 VSS.t3780 VDD.t1379 a_27909_17416.t0 VSS.t3779 sg13_lv_nmos ad=0.1626p pd=1.415u as=60.89999f
+ ps=0.71u w=0.42u l=0.13u
X5610 a_24729_14690.t4 a_24639_14594# a_24563_14950.t9 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5611 a_41115_12039.t0 a_41550_12073.t3 a_40855_11816.t2 VSS.t1146 sg13_lv_nmos ad=81f pd=0.81u
+ as=0.1296p ps=1.52u w=0.42u l=0.13u
X5612 a_28510_9273.t1 CLK.t27 VDD.t227 VDD.t153 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p
+ ps=11.92u w=1.12u l=0.13u
X5613 a_24563_950.t2 VSS.t893 VSS.t1028 VSS.t123 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.221p ps=1.98u
+ w=0.65u l=0.45u
X5614 a_31249_9090.t7 a_31159_8994# a_31083_9350.t8 VSS.t2277 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5615 VSS.t3995 a_50719_594# a_50809_690.t1 VSS.t2367 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5616 VSS.t1851 a_16548_3633.t2 a_16226_3493.t1 VSS.t1850 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5617 a_27815_9016.t2 a_28612_9360.t3 a_28075_9239.t1 VDD.t153 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5618 a_11523_6550.t3 a_11599_6194# a_11689_6290.t6 VSS.t2355 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5619 a_44123_17750.t0 VSS.t367 VSS.t368 VSS.t240 sg13_lv_nmos ad=95f pd=0.88u as=0.17p ps=1.68u
+ w=0.5u l=0.13u
X5620 VDD.t1092 VDD.t1367 a_15035_17639.t2 VDD.t748 sg13_lv_pmos ad=0.1563p pd=1.22u as=0.147p
+ ps=1.54u w=0.42u l=0.13u
X5621 6MSB_0.OUTN.t95 a_49938_9314.t2 a_50643_9350.t6 VSS.t1230 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5622 VDD.t614 a_890_598.t2 a_1279_914.t0 VDD.t462 sg13_lv_pmos ad=0.2184p pd=1.51u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5623 6MSB_0.OUTN.t107 a_17338_914.t2 a_18043_950.t6 VSS.t1226 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5624 a_44123_3750.t9 a_44199_3394# a_44289_3490.t7 VSS.t2408 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5625 a_35030_20473.t0 CLK.t57 VSS.t2555 VSS.t3631 sg13_lv_nmos ad=0.2516p pd=2.16u as=3.46165p
+ ps=22.395u w=0.74u l=0.13u
X5626 VDD.t499 a_9800_3493.t2 a_10397_3694.t1 VDD.t301 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5627 a_51517_23976.t1 4LSB_weighted_0.VBIAS VSS.t4068 VSS.t4067 sg13_hv_nmos ad=0.114p pd=0.98u
+ as=0.114p ps=0.98u w=0.6u l=0.48u
X5628 6MSB_0.OUTP.t43 a_16917_3694.t2 a_18043_3750.t5 VSS.t1214 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5629 a_50809_6290.t5 a_50719_6194# a_50643_6550.t7 VSS.t2366 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5630 a_37769_690.t7 a_37679_594# a_37603_950.t8 VSS.t2336 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5631 a_31083_20550.t1 a_29957_20494.t2 6MSB_0.OUTP.t123 VSS.t3462 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5632 VDD.t900 a_36681_17694.t2 a_36898_17714.t1 VDD.t893 sg13_lv_pmos ad=0.3808p pd=2.92u
+ as=0.2156p ps=1.505u w=1.12u l=0.13u
X5633 a_1735_14616.t1 a_1279_14914.t3 VDD.t932 VDD.t817 sg13_lv_pmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5634 a_34621_934.t0 a_34595_839.t3 VSS.t2176 VSS.t2175 sg13_lv_nmos ad=0.2516p pd=2.16u as=0.1626p
+ ps=1.415u w=0.74u l=0.13u
X5635 a_42997_20494.t0 a_42400_20293.t2 VSS.t2489 VSS.t2488 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5636 a_8830_20229.t1 a_8541_20534.t4 a_8767_20229.t0 VSS.t3106 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5637 a_47887_17429.t0 VDD.t1389 VSS.t3716 VSS.t3715 sg13_lv_nmos ad=38.85f pd=0.605u as=0.1701p
+ ps=1.65u w=0.42u l=0.13u
X5638 a_20839_914.t1 VDD.t1647 a_20738_617.t1 VSS.t3962 sg13_lv_nmos ad=0.1368p pd=1.1u as=0.1404p
+ ps=1.11u w=0.72u l=0.13u
X5639 a_28101_20534.t3 a_28075_20439.t3 VDD.t1344 VDD.t9 sg13_lv_pmos ad=0.34p pd=2.68u as=0.36237p
+ ps=2.605u w=1u l=0.13u
X5640 VDD.t1045 a_29360_17493.t2 a_29588_17633.t0 VDD.t733 sg13_lv_pmos ad=0.2014p pd=1.53u as=79.8f
+ ps=0.8u w=0.42u l=0.13u
X5641 a_1829_616.t0 a_1279_914.t3 a_1735_616.t0 VSS.t2034 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5642 a_21990_12073.t1 CLK.t36 VDD.t42 VDD.t34 sg13_lv_pmos ad=0.3808p pd=2.92u as=1.8612p ps=11.92u
+ w=1.12u l=0.13u
X5643 VDD.t1111 a_n2770_240.t13 a_27359_12114.t2 VDD.t50 sg13_lv_pmos ad=0.392p pd=2.94u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5644 VSS.t1395 a_28510_9273.t3 a_28612_9360.t0 VSS.t1394 sg13_lv_nmos ad=3.46165p pd=22.395u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5645 a_28101_3734.t2 a_28612_3760.t2 a_29360_3493.t1 VSS.t1906 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5646 a_35880_17493.t1 a_35030_17673.t2 a_35786_17493.t1 VSS.t3275 sg13_lv_nmos ad=0.12665p
+ pd=1.145u as=0.1428p ps=1.52u w=0.42u l=0.13u
X5647 a_8349_14616.t0 a_7799_14914.t3 a_8255_14616.t3 VSS.t4006 sg13_lv_nmos ad=60.89999f pd=0.71u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5648 a_21555_3639.t1 a_21990_3673.t3 a_21938_3807.t0 VDD.t297 sg13_lv_pmos ad=79.8f pd=0.8u
+ as=54.6f ps=0.68u w=0.42u l=0.13u
X5649 a_11689_17490.t4 a_11599_17394# a_11523_17750.t6 VSS.t2354 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5650 a_50643_9350.t1 a_49517_9294.t2 6MSB_0.OUTP.t50 VSS.t91 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5651 a_18043_950.t4 a_16917_894.t2 6MSB_0.OUTP.t104 VSS.t1213 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5652 a_36069_14931.t0 a_35132_14960.t2 a_35880_14693.t0 VDD.t846 sg13_lv_pmos ad=52.5f pd=0.67u
+ as=0.19115p ps=1.565u w=0.42u l=0.13u
X5653 a_18043_12150.t1 a_16917_12094.t2 6MSB_0.OUTP.t87 VSS.t1215 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5654 VDD.t723 a_49148_833.t2 a_49109_931.t0 VDD.t4 sg13_lv_pmos ad=1.8612p pd=11.92u as=52.5f
+ ps=0.67u w=0.42u l=0.13u
X5655 a_15061_6534.t2 a_15572_6560.t2 a_16320_6293.t1 VSS.t1592 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5656 a_30378_914.t0 a_30161_894.t2 VSS.t2164 VSS.t2163 sg13_lv_nmos ad=0.1406p pd=1.12u as=0.2516p
+ ps=2.16u w=0.74u l=0.13u
X5657 VDD.t652 a_16320_693.t2 a_16917_894.t1 VDD.t444 sg13_lv_pmos ad=0.2083p pd=1.5u as=0.2128p
+ ps=1.5u w=1.12u l=0.13u
X5658 VSS.t3233 a_49148_17633.t2 a_48826_17493.t1 VSS.t3232 sg13_lv_nmos ad=79.8f pd=0.8u as=0.1428p
+ ps=1.52u w=0.42u l=0.13u
X5659 a_18043_14950.t6 a_17338_14914.t2 6MSB_0.OUTN.t35 VSS.t1227 sg13_lv_nmos ad=95f pd=0.88u
+ as=95f ps=0.88u w=0.5u l=0.13u
X5660 a_17338_3714.t0 a_17121_3694.t2 VSS.t1862 VSS.t1861 sg13_lv_nmos ad=0.1406p pd=1.12u
+ as=0.2516p ps=2.16u w=0.74u l=0.13u
X5661 a_37769_690.t1 a_37679_594# VSS.t4102 VSS.t4103 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5662 a_1735_20216.t0 a_2532_20560.t3 a_1995_20439.t0 VDD.t5 sg13_lv_pmos ad=0.1428p pd=1.52u
+ as=79.8f ps=0.8u w=0.42u l=0.13u
X5663 a_50643_17750.t3 a_50719_17394# a_50809_17490.t4 VSS.t2371 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5664 a_5003_20550.t9 a_4298_20514.t2 6MSB_0.OUTN.t18 VSS.t4132 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5665 a_34621_20534.t1 a_34595_20439.t3 VSS.t2917 VSS.t2916 sg13_lv_nmos ad=0.2516p pd=2.16u
+ as=0.1626p ps=1.415u w=0.74u l=0.13u
X5666 a_18043_3750.t9 a_18119_3394# a_18209_3490.t7 VSS.t2262 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5667 VDD.t1728 a_39705_17794.t2 a_40010_17398.t1 VDD.t812 sg13_lv_pmos ad=0.4256p pd=3u as=0.252p
+ ps=1.57u w=1.12u l=0.13u
X5668 a_42400_9093.t1 a_41550_9273.t2 a_42306_9093.t0 VSS.t1445 sg13_lv_nmos ad=0.12665p pd=1.145u
+ as=0.1428p ps=1.52u w=0.42u l=0.13u
X5669 a_24729_3490.t3 a_24639_3394# VSS.t4039 VSS.t3125 sg13_hv_nmos ad=0.1235p pd=1.03u as=0.1235p
+ ps=1.03u w=0.65u l=0.45u
X5670 a_2021_20534.t0 a_2532_20560.t2 a_3280_20293.t0 VSS.t4205 sg13_lv_nmos ad=0.3473p pd=2.71u
+ as=0.12665p ps=1.145u w=0.74u l=0.13u
X5671 a_24729_6290.t5 a_24639_6194# a_24563_6550.t7 VSS.t3121 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5672 6MSB_0.OUTP.t117 a_49517_894.t2 a_50643_950.t5 VSS.t92 sg13_lv_nmos ad=95f pd=0.88u as=95f
+ ps=0.88u w=0.5u l=0.13u
X5673 VSS.t2346 a_37679_20194# a_37769_20290.t2 VSS.t2337 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5674 a_34910_6229.t1 a_34621_6534.t4 a_34847_6229.t0 VSS.t1669 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5675 a_15350_20229.t0 a_15061_20534.t4 a_15287_20229.t0 VSS.t2607 sg13_lv_nmos ad=0.1596p pd=1.6u
+ as=38.85f ps=0.605u w=0.42u l=0.13u
X5676 a_18209_11890.t4 a_18119_11794# a_18043_12150.t2 VSS.t2257 sg13_hv_nmos ad=0.1235p pd=1.03u
+ as=0.1235p ps=1.03u w=0.65u l=0.45u
X5677 a_36681_3694.t1 a_35880_3493.t2 VDD.t559 VDD.t290 sg13_lv_pmos ad=0.34p pd=2.68u as=0.2083p
+ ps=1.5u w=1u l=0.13u
C0 4LSB_weighted_0.VBIAS a_18119_20194# 0.15069f
C1 4LSB_weighted_0.VBIAS a_24639_14594# 0.15069f
C2 a_11599_8994# VDD 0.03071f
C3 4LSB_weighted_0.VBIAS a_5079_8994# 0.15069f
C4 4LSB_weighted_0.VBIAS a_31159_6194# 0.15069f
C5 a_44199_8994# VDD 0.03032f
C6 X3 X4 2.87074f
C7 4LSB_weighted_0.VBIAS a_11599_17394# 0.15069f
C8 4LSB_weighted_0.VBIAS a_11599_11794# 0.15069f
C9 4LSB_weighted_0.VBIAS a_50719_594# 0.15073f
C10 4LSB_weighted_0.VBIAS a_37679_8994# 0.15069f
C11 a_31159_3394# VDD 0.03041f
C12 4LSB_weighted_0.VBIAS a_50719_3394# 0.15073f
C13 4LSB_weighted_0.VBIAS a_44199_17394# 0.15069f
C14 a_5079_14594# VDD 0.03039f
C15 4LSB_weighted_0.VBIAS a_24639_594# 0.15069f
C16 6MSB_0.OUTN CLK 0.24552p
C17 4LSB_weighted_0.VBIAS a_44199_11794# 0.15069f
C18 6MSB_0.OUTN VDD 11.7965f
C19 4LSB_weighted_0.VBIAS a_24639_3394# 0.15069f
C20 a_31159_20194# VDD 0.03041f
C21 VDD X9 1.08916f
C22 6MSB_0.OUTP CLK 5.76853f
C23 a_37679_14594# VDD 0.03071f
C24 6MSB_0.OUTP VDD 27.4167f
C25 4LSB_weighted_0.VBIAS a_24639_20194# 0.15069f
C26 4LSB_weighted_0.VBIAS a_31159_14594# 0.15069f
C27 a_18119_8994# VDD 0.03102f
C28 4LSB_weighted_0.VBIAS a_5079_6194# 0.15069f
C29 4LSB_weighted_0.VBIAS a_11599_8994# 0.15069f
C30 a_5079_3394# VDD 0.03039f
C31 4LSB_weighted_0.VBIAS a_37679_6194# 0.15069f
C32 4LSB_weighted_0.VBIAS a_18119_17394# 0.15069f
C33 X9 X10 4.01232f
C34 4LSB_weighted_0.VBIAS a_18119_11794# 0.15069f
C35 4LSB_weighted_0.VBIAS a_44199_8994# 0.15069f
C36 a_5079_20194# VDD 0.03039f
C37 a_37679_3394# VDD 0.03071f
C38 a_11599_14594# VDD 0.03071f
C39 4LSB_weighted_0.VBIAS a_31159_594# 0.15069f
C40 VDD X6 1.0804f
C41 4LSB_weighted_0.VBIAS a_31159_3394# 0.15069f
C42 4LSB_weighted_0.VBIAS a_5079_14594# 0.15069f
C43 a_37679_20194# VDD 0.03071f
C44 X7 X6 5.02495f
C45 a_44199_14594# VDD 0.03032f
C46 6MSB_0.OUTN 4LSB_weighted_0.VBIAS 3.63448f
C47 4LSB_weighted_0.VBIAS a_31159_20194# 0.15069f
C48 a_50719_8994# VDD 0.02754f
C49 4LSB_weighted_0.VBIAS a_37679_14594# 0.15069f
C50 6MSB_0.OUTP 4LSB_weighted_0.VBIAS 7.56168f
C51 X8 X9 4.09479f
C52 a_24639_8994# VDD 0.03133f
C53 4LSB_weighted_0.VBIAS a_11599_6194# 0.15069f
C54 VDD CLK 30.9319f
C55 4LSB_weighted_0.VBIAS a_50719_17394# 0.15073f
C56 4LSB_weighted_0.VBIAS a_50719_11794# 0.15073f
C57 VDD X1 0.36959f
C58 4LSB_weighted_0.VBIAS a_18119_8994# 0.15069f
C59 a_11599_3394# VDD 0.03071f
C60 VDD X7 1.65067f
C61 4LSB_weighted_0.VBIAS a_44199_6194# 0.15069f
C62 4LSB_weighted_0.VBIAS a_5079_594# 0.15069f
C63 4LSB_weighted_0.VBIAS a_24639_17394# 0.15069f
C64 4LSB_weighted_0.VBIAS a_24639_11794# 0.15069f
C65 VDD X2 0.29548f
C66 4LSB_weighted_0.VBIAS a_5079_3394# 0.15069f
C67 X1 X2 1.08178f
C68 a_11599_20194# VDD 0.03071f
C69 a_44199_3394# VDD 0.03032f
C70 a_18119_14594# VDD 0.03102f
C71 4LSB_weighted_0.VBIAS a_37679_594# 0.15069f
C72 4LSB_weighted_0.VBIAS a_5079_20194# 0.15069f
C73 4LSB_weighted_0.VBIAS a_37679_3394# 0.15069f
C74 4LSB_weighted_0.VBIAS a_11599_14594# 0.15069f
C75 VDD X10 1.55974f
C76 4LSB_weighted_0.VBIAS a_37679_20194# 0.15069f
C77 4LSB_weighted_0.VBIAS a_44199_14594# 0.15069f
C78 a_31159_8994# VDD 0.03041f
C79 4LSB_weighted_0.VBIAS a_50719_8994# 0.15073f
C80 4LSB_weighted_0.VBIAS a_18119_6194# 0.15069f
C81 4LSB_weighted_0.VBIAS a_24639_8994# 0.15069f
C82 a_18119_3394# VDD 0.03102f
C83 4LSB_weighted_0.VBIAS CLK 0.81813f
C84 4LSB_weighted_0.VBIAS a_31159_17394# 0.15069f
C85 4LSB_weighted_0.VBIAS VDD 40.05239f
C86 a_44199_20194# VDD 0.03034f
C87 4LSB_weighted_0.VBIAS a_11599_594# 0.15069f
C88 4LSB_weighted_0.VBIAS a_31159_11794# 0.15069f
C89 a_50719_14594# VDD 0.02754f
C90 4LSB_weighted_0.VBIAS a_11599_3394# 0.15069f
C91 VDD X8 1.44428f
C92 a_18119_20194# VDD 0.03102f
C93 VDD X4 0.43744f
C94 a_24639_14594# VDD 0.03133f
C95 4LSB_weighted_0.VBIAS a_44199_594# 0.15069f
C96 4LSB_weighted_0.VBIAS a_11599_20194# 0.15069f
C97 VDD X3 0.38344f
C98 4LSB_weighted_0.VBIAS a_44199_3394# 0.15069f
C99 4LSB_weighted_0.VBIAS a_18119_14594# 0.15069f
C100 X5 X6 5.10703f
C101 a_5079_8994# VDD 0.03039f
C102 X2 X3 1.5283f
C103 4LSB_weighted_0.VBIAS a_50719_6194# 0.15073f
C104 a_37679_8994# VDD 0.03071f
C105 6MSB_0.OUTN 6MSB_0.OUTP 0.27447p
C106 4LSB_weighted_0.VBIAS a_24639_6194# 0.15069f
C107 4LSB_weighted_0.VBIAS a_5079_17394# 0.15069f
C108 X8 X10 0.49542f
C109 a_50719_3394# VDD 0.02754f
C110 4LSB_weighted_0.VBIAS a_5079_11794# 0.15069f
C111 4LSB_weighted_0.VBIAS a_31159_8994# 0.15069f
C112 a_24639_3394# VDD 0.03133f
C113 4LSB_weighted_0.VBIAS a_37679_17394# 0.15069f
C114 VDD X5 1.51195f
C115 4LSB_weighted_0.VBIAS a_18119_594# 0.15069f
C116 4LSB_weighted_0.VBIAS a_37679_11794# 0.15069f
C117 4LSB_weighted_0.VBIAS a_18119_3394# 0.15069f
C118 X7 X5 0.50831f
C119 4LSB_weighted_0.VBIAS a_44199_20194# 0.15069f
C120 a_24639_20194# VDD 0.03133f
C121 a_31159_14594# VDD 0.03041f
C122 4LSB_weighted_0.VBIAS a_50719_14594# 0.15073f
R0 X10.n0 X10.t1 35.3201
R1 X10.n0 X10.t0 35.1456
R2 X10.n2 X10.t3 34.0427
R3 X10.n3 X10.t4 34.0288
R4 X10.n1 X10.t2 22.7804
R5 X10.n4 X10.t5 22.7789
R6 X10 X10.n4 1.40987
R7 X10.n3 X10.n2 1.12388
R8 X10.n1 X10.n0 1.09362
R9 X10.n2 X10.n1 0.63575
R10 X10.n4 X10.n3 0.6275
R11 X9.n0 X9.t0 34.7802
R12 X9.n1 X9.t2 33.9232
R13 X9.n0 X9.t1 33.82
R14 X9.n3 X9.t4 33.7997
R15 X9.n2 X9.t3 21.6331
R16 X9 X9.n3 1.48098
R17 X9.n1 X9.n0 1.32325
R18 X9.n2 X9.n1 1.227
R19 X9.n3 X9.n2 0.63025
R20 X8.n1 X8.t2 34.8396
R21 X8.n0 X8.t1 33.5845
R22 X8.n0 X8.t0 9.07304
R23 X8.n2 X8.t3 7.73929
R24 X8 X8.n2 2.08421
R25 X8.n1 X8.n0 1.34387
R26 X8.n2 X8.n1 1.32875
R27 X4 X4.t0 15.0028
R28 X3 X3.t0 15.0039
R29 X6.n0 X6.t4 34.7802
R30 X6.n1 X6.t2 33.9232
R31 X6.n0 X6.t3 33.82
R32 X6.n3 X6.t0 33.7997
R33 X6.n2 X6.t1 21.6331
R34 X6.n1 X6.n0 1.32325
R35 X6.n2 X6.n1 1.227
R36 X6 X6.n3 0.987554
R37 X6.n3 X6.n2 0.63025
R38 X5.n1 X5.t0 34.8396
R39 X5.n0 X5.t2 33.5845
R40 X5.n0 X5.t3 9.07304
R41 X5.n2 X5.t1 7.73929
R42 X5 X5.n2 1.47293
R43 X5.n1 X5.n0 1.34387
R44 X5.n2 X5.n1 1.32875
R45 X7.n0 X7.t2 35.3201
R46 X7.n0 X7.t5 35.1456
R47 X7.n2 X7.t4 34.0427
R48 X7.n3 X7.t3 34.0288
R49 X7.n1 X7.t1 22.7804
R50 X7.n4 X7.t0 22.7789
R51 X7.n3 X7.n2 1.12388
R52 X7.n1 X7.n0 1.09362
R53 X7 X7.n4 1.0343
R54 X7.n2 X7.n1 0.63575
R55 X7.n4 X7.n3 0.6275
R56 X2 X2.t0 15.0028
R57 CLK.n69 CLK 43.4951
R58 CLK.n55 CLK.t56 36.4656
R59 CLK.n47 CLK.t48 36.4656
R60 CLK.n39 CLK.t40 36.4656
R61 CLK.n31 CLK.t32 36.4656
R62 CLK.n23 CLK.t24 36.4656
R63 CLK.n15 CLK.t16 36.4656
R64 CLK.n7 CLK.t8 36.4656
R65 CLK.n0 CLK.t0 36.4656
R66 CLK.n55 CLK.t57 31.3428
R67 CLK.n56 CLK.t58 31.3428
R68 CLK.n57 CLK.t59 31.3428
R69 CLK.n58 CLK.t60 31.3428
R70 CLK.n59 CLK.t61 31.3428
R71 CLK.n60 CLK.t62 31.3428
R72 CLK.n47 CLK.t49 31.3428
R73 CLK.n48 CLK.t50 31.3428
R74 CLK.n49 CLK.t51 31.3428
R75 CLK.n50 CLK.t52 31.3428
R76 CLK.n51 CLK.t53 31.3428
R77 CLK.n52 CLK.t54 31.3428
R78 CLK.n53 CLK.t55 31.3428
R79 CLK.n39 CLK.t41 31.3428
R80 CLK.n40 CLK.t42 31.3428
R81 CLK.n41 CLK.t43 31.3428
R82 CLK.n42 CLK.t44 31.3428
R83 CLK.n43 CLK.t45 31.3428
R84 CLK.n44 CLK.t46 31.3428
R85 CLK.n45 CLK.t47 31.3428
R86 CLK.n31 CLK.t33 31.3428
R87 CLK.n32 CLK.t34 31.3428
R88 CLK.n33 CLK.t35 31.3428
R89 CLK.n34 CLK.t36 31.3428
R90 CLK.n35 CLK.t37 31.3428
R91 CLK.n36 CLK.t38 31.3428
R92 CLK.n37 CLK.t39 31.3428
R93 CLK.n23 CLK.t25 31.3428
R94 CLK.n24 CLK.t26 31.3428
R95 CLK.n25 CLK.t27 31.3428
R96 CLK.n26 CLK.t28 31.3428
R97 CLK.n27 CLK.t29 31.3428
R98 CLK.n28 CLK.t30 31.3428
R99 CLK.n29 CLK.t31 31.3428
R100 CLK.n15 CLK.t17 31.3428
R101 CLK.n16 CLK.t18 31.3428
R102 CLK.n17 CLK.t19 31.3428
R103 CLK.n18 CLK.t20 31.3428
R104 CLK.n19 CLK.t21 31.3428
R105 CLK.n20 CLK.t22 31.3428
R106 CLK.n21 CLK.t23 31.3428
R107 CLK.n7 CLK.t9 31.3428
R108 CLK.n8 CLK.t10 31.3428
R109 CLK.n9 CLK.t11 31.3428
R110 CLK.n10 CLK.t12 31.3428
R111 CLK.n11 CLK.t13 31.3428
R112 CLK.n12 CLK.t14 31.3428
R113 CLK.n13 CLK.t15 31.3428
R114 CLK.n0 CLK.t1 31.3428
R115 CLK.n1 CLK.t2 31.3428
R116 CLK.n2 CLK.t3 31.3428
R117 CLK.n3 CLK.t4 31.3428
R118 CLK.n4 CLK.t5 31.3428
R119 CLK.n5 CLK.t6 31.3428
R120 CLK.n6 CLK.t7 31.3428
R121 CLK.n64 CLK.t66 15.061
R122 CLK.n65 CLK.t65 15.0546
R123 CLK.n63 CLK.t64 15.0344
R124 CLK.n62 CLK.t63 15.0317
R125 CLK.n66 CLK.n64 9.33025
R126 CLK.n67 CLK.n63 9.11733
R127 CLK.n68 CLK.n62 9.11278
R128 CLK.n66 CLK.n65 9.0005
R129 CLK.n14 CLK.n6 6.39593
R130 CLK.n56 CLK.n55 5.12336
R131 CLK.n57 CLK.n56 5.12336
R132 CLK.n58 CLK.n57 5.12336
R133 CLK.n59 CLK.n58 5.12336
R134 CLK.n60 CLK.n59 5.12336
R135 CLK.n48 CLK.n47 5.12336
R136 CLK.n49 CLK.n48 5.12336
R137 CLK.n50 CLK.n49 5.12336
R138 CLK.n51 CLK.n50 5.12336
R139 CLK.n52 CLK.n51 5.12336
R140 CLK.n53 CLK.n52 5.12336
R141 CLK.n40 CLK.n39 5.12336
R142 CLK.n41 CLK.n40 5.12336
R143 CLK.n42 CLK.n41 5.12336
R144 CLK.n43 CLK.n42 5.12336
R145 CLK.n44 CLK.n43 5.12336
R146 CLK.n45 CLK.n44 5.12336
R147 CLK.n32 CLK.n31 5.12336
R148 CLK.n33 CLK.n32 5.12336
R149 CLK.n34 CLK.n33 5.12336
R150 CLK.n35 CLK.n34 5.12336
R151 CLK.n36 CLK.n35 5.12336
R152 CLK.n37 CLK.n36 5.12336
R153 CLK.n24 CLK.n23 5.12336
R154 CLK.n25 CLK.n24 5.12336
R155 CLK.n26 CLK.n25 5.12336
R156 CLK.n27 CLK.n26 5.12336
R157 CLK.n28 CLK.n27 5.12336
R158 CLK.n29 CLK.n28 5.12336
R159 CLK.n16 CLK.n15 5.12336
R160 CLK.n17 CLK.n16 5.12336
R161 CLK.n18 CLK.n17 5.12336
R162 CLK.n19 CLK.n18 5.12336
R163 CLK.n20 CLK.n19 5.12336
R164 CLK.n21 CLK.n20 5.12336
R165 CLK.n8 CLK.n7 5.12336
R166 CLK.n9 CLK.n8 5.12336
R167 CLK.n10 CLK.n9 5.12336
R168 CLK.n11 CLK.n10 5.12336
R169 CLK.n12 CLK.n11 5.12336
R170 CLK.n13 CLK.n12 5.12336
R171 CLK.n1 CLK.n0 5.12336
R172 CLK.n2 CLK.n1 5.12336
R173 CLK.n3 CLK.n2 5.12336
R174 CLK.n4 CLK.n3 5.12336
R175 CLK.n5 CLK.n4 5.12336
R176 CLK.n6 CLK.n5 5.12336
R177 CLK.n61 CLK.n60 4.63593
R178 CLK.n54 CLK.n53 4.63593
R179 CLK.n46 CLK.n45 4.63593
R180 CLK.n38 CLK.n37 4.63593
R181 CLK.n30 CLK.n29 4.63593
R182 CLK.n22 CLK.n21 4.63593
R183 CLK.n14 CLK.n13 4.63593
R184 CLK.n61 CLK.n54 1.7605
R185 CLK.n54 CLK.n46 1.7605
R186 CLK.n46 CLK.n38 1.7605
R187 CLK.n38 CLK.n30 1.7605
R188 CLK.n30 CLK.n22 1.7605
R189 CLK.n22 CLK.n14 1.7605
R190 CLK.n67 CLK.n66 0.893848
R191 CLK CLK.n68 0.596725
R192 CLK.n68 CLK.n67 0.373264
R193 CLK CLK.n61 0.170214
R194 CLK.n69 CLK 0.0897571
R195 CLK.n62 CLK 0.0591667
R196 CLK.n63 CLK 0.0564167
R197 CLK CLK.n69 0.0445
R198 CLK.n65 CLK 0.03625
R199 CLK.n64 CLK 0.0298333
R200 X1.n0 X1.t0 15.0005
R201 X1.n0 X1 0.220593
R202 X1 X1.n0 0.01425
R203 VDD.n778 VDD.t1389 33.6519
R204 VDD.n851 VDD.t1271 33.6519
R205 VDD.n827 VDD.t1467 33.6519
R206 VDD.n802 VDD.t1515 33.6519
R207 VDD.n85 VDD.t1563 33.6519
R208 VDD.n1883 VDD.t1611 33.6519
R209 VDD.n1907 VDD.t1691 33.6519
R210 VDD.n750 VDD.t1277 33.6519
R211 VDD.n726 VDD.t1307 33.6519
R212 VDD.n701 VDD.t1427 33.6519
R213 VDD.n166 VDD.t1461 33.6519
R214 VDD.n1783 VDD.t1509 33.6519
R215 VDD.n1807 VDD.t1557 33.6519
R216 VDD.n1855 VDD.t1605 33.6519
R217 VDD.n1831 VDD.t1677 33.6519
R218 VDD.n674 VDD.t1287 33.6519
R219 VDD.n191 VDD.t1375 33.6519
R220 VDD.n1633 VDD.t1415 33.6519
R221 VDD.n1657 VDD.t1455 33.6519
R222 VDD.n1754 VDD.t1503 33.6519
R223 VDD.n1730 VDD.t1551 33.6519
R224 VDD.n1705 VDD.t1599 33.6519
R225 VDD.n1681 VDD.t1667 33.6519
R226 VDD.n649 VDD.t1291 33.6519
R227 VDD.n219 VDD.t1379 33.6519
R228 VDD.n1606 VDD.t1417 33.6519
R229 VDD.n1581 VDD.t1449 33.6519
R230 VDD.n1555 VDD.t1497 33.6519
R231 VDD.n1530 VDD.t1545 33.6519
R232 VDD.n269 VDD.t1593 33.6519
R233 VDD.n244 VDD.t1657 33.6519
R234 VDD.n622 VDD.t1335 33.6519
R235 VDD.n598 VDD.t1371 33.6519
R236 VDD.n573 VDD.t1409 33.6519
R237 VDD.n294 VDD.t1265 33.6519
R238 VDD.n1429 VDD.t1491 33.6519
R239 VDD.n1453 VDD.t1539 33.6519
R240 VDD.n1501 VDD.t1587 33.6519
R241 VDD.n1477 VDD.t1651 33.6519
R242 VDD.n438 VDD.t1283 33.6519
R243 VDD.n320 VDD.t1367 33.6519
R244 VDD.n1275 VDD.t1393 33.6519
R245 VDD.n1300 VDD.t1441 33.6519
R246 VDD.n1401 VDD.t1485 33.6519
R247 VDD.n1376 VDD.t1533 33.6519
R248 VDD.n1350 VDD.t1581 33.6519
R249 VDD.n1325 VDD.t1641 33.6519
R250 VDD.n1099 VDD.t1323 33.6519
R251 VDD.n1123 VDD.t1357 33.6519
R252 VDD.n1246 VDD.t1399 33.6519
R253 VDD.n1222 VDD.t1273 33.6519
R254 VDD.n1197 VDD.t1479 33.6519
R255 VDD.n1173 VDD.t1527 33.6519
R256 VDD.n1147 VDD.t1575 33.6519
R257 VDD.n55 VDD.t1627 33.6519
R258 VDD.n1071 VDD.t1295 33.6519
R259 VDD.n1047 VDD.t1353 33.6519
R260 VDD.n1022 VDD.t1281 33.6519
R261 VDD.n998 VDD.t1435 33.6519
R262 VDD.n972 VDD.t1473 33.6519
R263 VDD.n29 VDD.t1521 33.6519
R264 VDD.n1979 VDD.t1569 33.6519
R265 VDD.n1955 VDD.t1621 33.6519
R266 VDD.t1389 VDD.t1303 33.4092
R267 VDD.t1271 VDD.t1267 33.4092
R268 VDD.t1467 VDD.t1471 33.4092
R269 VDD.t1515 VDD.t1519 33.4092
R270 VDD.t1563 VDD.t1567 33.4092
R271 VDD.t1611 VDD.t1615 33.4092
R272 VDD.t1691 VDD.t1695 33.4092
R273 VDD.t1301 VDD.t1299 33.4092
R274 VDD.t1311 VDD.t1297 33.4092
R275 VDD.t1317 VDD.t1321 33.4092
R276 VDD.t1293 VDD.t1289 33.4092
R277 VDD.t1277 VDD.t1275 33.4092
R278 VDD.t1307 VDD.t1305 33.4092
R279 VDD.t1427 VDD.t1285 33.4092
R280 VDD.t1461 VDD.t1465 33.4092
R281 VDD.t1509 VDD.t1513 33.4092
R282 VDD.t1557 VDD.t1561 33.4092
R283 VDD.t1605 VDD.t1609 33.4092
R284 VDD.t1677 VDD.t1685 33.4092
R285 VDD.t1287 VDD.t1349 33.4092
R286 VDD.t1375 VDD.t1385 33.4092
R287 VDD.t1415 VDD.t1405 33.4092
R288 VDD.t1455 VDD.t1459 33.4092
R289 VDD.t1503 VDD.t1507 33.4092
R290 VDD.t1551 VDD.t1555 33.4092
R291 VDD.t1599 VDD.t1603 33.4092
R292 VDD.t1667 VDD.t1675 33.4092
R293 VDD.t1291 VDD.t1345 33.4092
R294 VDD.t1379 VDD.t1363 33.4092
R295 VDD.t1417 VDD.t1419 33.4092
R296 VDD.t1449 VDD.t1453 33.4092
R297 VDD.t1497 VDD.t1501 33.4092
R298 VDD.t1545 VDD.t1549 33.4092
R299 VDD.t1593 VDD.t1597 33.4092
R300 VDD.t1657 VDD.t1665 33.4092
R301 VDD.t1335 VDD.t1339 33.4092
R302 VDD.t1371 VDD.t1377 33.4092
R303 VDD.t1409 VDD.t1421 33.4092
R304 VDD.t1265 VDD.t1447 33.4092
R305 VDD.t1491 VDD.t1495 33.4092
R306 VDD.t1539 VDD.t1543 33.4092
R307 VDD.t1587 VDD.t1591 33.4092
R308 VDD.t1651 VDD.t1655 33.4092
R309 VDD.t1283 VDD.t1333 33.4092
R310 VDD.t1367 VDD.t1365 33.4092
R311 VDD.t1393 VDD.t1407 33.4092
R312 VDD.t1441 VDD.t1263 33.4092
R313 VDD.t1485 VDD.t1489 33.4092
R314 VDD.t1533 VDD.t1537 33.4092
R315 VDD.t1581 VDD.t1585 33.4092
R316 VDD.t1641 VDD.t1645 33.4092
R317 VDD.t1323 VDD.t1329 33.4092
R318 VDD.t1357 VDD.t1361 33.4092
R319 VDD.t1399 VDD.t1403 33.4092
R320 VDD.t1273 VDD.t1269 33.4092
R321 VDD.t1479 VDD.t1483 33.4092
R322 VDD.t1527 VDD.t1531 33.4092
R323 VDD.t1575 VDD.t1579 33.4092
R324 VDD.t1627 VDD.t1635 33.4092
R325 VDD.t1295 VDD.t1325 33.4092
R326 VDD.t1353 VDD.t1351 33.4092
R327 VDD.t1281 VDD.t1397 33.4092
R328 VDD.t1435 VDD.t1433 33.4092
R329 VDD.t1473 VDD.t1477 33.4092
R330 VDD.t1521 VDD.t1525 33.4092
R331 VDD.t1569 VDD.t1573 33.4092
R332 VDD.t1621 VDD.t1625 33.4092
R333 VDD.n1929 VDD.t1687 29.9207
R334 VDD.n1928 VDD.t1679 29.6622
R335 VDD.n1926 VDD.t1669 29.6622
R336 VDD.n1924 VDD.t1659 29.6622
R337 VDD.n1922 VDD.t1647 29.6622
R338 VDD.n1920 VDD.t1637 29.6622
R339 VDD.n41 VDD.t1629 29.6622
R340 VDD.n1940 VDD.t1617 29.6622
R341 VDD.n474 VDD.t1293 24.153
R342 VDD.n473 VDD.t1317 24.1448
R343 VDD.n876 VDD.t1301 24.0573
R344 VDD.n505 VDD.t1311 24.0476
R345 VDD.n770 VDD.t1803 17.378
R346 VDD.n843 VDD.t779 17.378
R347 VDD.n819 VDD.t109 17.378
R348 VDD.n794 VDD.t269 17.378
R349 VDD.n77 VDD.t423 17.378
R350 VDD.n1875 VDD.t584 17.378
R351 VDD.n1899 VDD.t720 17.378
R352 VDD.n491 VDD.t1194 17.378
R353 VDD.n479 VDD.t1193 17.378
R354 VDD.n462 VDD.t1804 17.378
R355 VDD.n886 VDD.t1262 17.378
R356 VDD.n742 VDD.t856 17.378
R357 VDD.n718 VDD.t1731 17.378
R358 VDD.n693 VDD.t1770 17.378
R359 VDD.n158 VDD.t94 17.378
R360 VDD.n1775 VDD.t254 17.378
R361 VDD.n1799 VDD.t408 17.378
R362 VDD.n1847 VDD.t567 17.378
R363 VDD.n1823 VDD.t705 17.378
R364 VDD.n667 VDD.t931 17.378
R365 VDD.n184 VDD.t1036 17.378
R366 VDD.n1626 VDD.t1754 17.378
R367 VDD.n1650 VDD.t80 17.378
R368 VDD.n1747 VDD.t239 17.378
R369 VDD.n1723 VDD.t393 17.378
R370 VDD.n1698 VDD.t552 17.378
R371 VDD.n1674 VDD.t690 17.378
R372 VDD.n640 VDD.t1715 17.378
R373 VDD.n210 VDD.t1797 17.378
R374 VDD.n1597 VDD.t1078 17.378
R375 VDD.n1572 VDD.t55 17.378
R376 VDD.n1546 VDD.t224 17.378
R377 VDD.n1521 VDD.t378 17.378
R378 VDD.n260 VDD.t537 17.378
R379 VDD.n235 VDD.t675 17.378
R380 VDD.n614 VDD.t1072 17.378
R381 VDD.n590 VDD.t1007 17.378
R382 VDD.n565 VDD.t903 17.378
R383 VDD.n286 VDD.t39 17.378
R384 VDD.n1421 VDD.t209 17.378
R385 VDD.n1445 VDD.t363 17.378
R386 VDD.n1493 VDD.t522 17.378
R387 VDD.n1469 VDD.t660 17.378
R388 VDD.n429 VDD.t1738 17.378
R389 VDD.n311 VDD.t822 17.378
R390 VDD.n1266 VDD.t923 17.378
R391 VDD.n1291 VDD.t1123 17.378
R392 VDD.n1392 VDD.t192 17.378
R393 VDD.n1367 VDD.t348 17.378
R394 VDD.n1341 VDD.t507 17.378
R395 VDD.n1316 VDD.t645 17.378
R396 VDD.n1090 VDD.t1043 17.378
R397 VDD.n1115 VDD.t1085 17.378
R398 VDD.n1238 VDD.t1701 17.378
R399 VDD.n1214 VDD.t790 17.378
R400 VDD.n1189 VDD.t179 17.378
R401 VDD.n1164 VDD.t333 17.378
R402 VDD.n1139 VDD.t492 17.378
R403 VDD.n46 VDD.t630 17.378
R404 VDD.n1063 VDD.t1168 17.378
R405 VDD.n1039 VDD.t1136 17.378
R406 VDD.n1014 VDD.t932 17.378
R407 VDD.n990 VDD.t1747 17.378
R408 VDD.n964 VDD.t134 17.378
R409 VDD.n21 VDD.t292 17.378
R410 VDD.n1971 VDD.t453 17.378
R411 VDD.n1947 VDD.t615 17.378
R412 VDD.n780 VDD.t1392 17.3693
R413 VDD.n853 VDD.t731 17.3693
R414 VDD.n829 VDD.t113 17.3693
R415 VDD.n804 VDD.t271 17.3693
R416 VDD.n87 VDD.t425 17.3693
R417 VDD.n1885 VDD.t586 17.3693
R418 VDD.n1909 VDD.t722 17.3693
R419 VDD.n495 VDD.t1015 17.3693
R420 VDD.n476 VDD.t814 17.3693
R421 VDD.n459 VDD.t761 17.3693
R422 VDD.n884 VDD.t1000 17.3693
R423 VDD.n752 VDD.t807 17.3693
R424 VDD.n728 VDD.t1063 17.3693
R425 VDD.n703 VDD.t1430 17.3693
R426 VDD.n168 VDD.t98 17.3693
R427 VDD.n1785 VDD.t256 17.3693
R428 VDD.n1809 VDD.t410 17.3693
R429 VDD.n1857 VDD.t569 17.3693
R430 VDD.n1833 VDD.t707 17.3693
R431 VDD.n676 VDD.t820 17.3693
R432 VDD.n193 VDD.t1070 17.3693
R433 VDD.n1635 VDD.t1416 17.3693
R434 VDD.n1659 VDD.t82 17.3693
R435 VDD.n1756 VDD.t241 17.3693
R436 VDD.n1732 VDD.t395 17.3693
R437 VDD.n1707 VDD.t554 17.3693
R438 VDD.n1683 VDD.t692 17.3693
R439 VDD.n651 VDD.t988 17.3693
R440 VDD.n221 VDD.t734 17.3693
R441 VDD.n1608 VDD.t1080 17.3693
R442 VDD.n1583 VDD.t57 17.3693
R443 VDD.n1557 VDD.t226 17.3693
R444 VDD.n1532 VDD.t380 17.3693
R445 VDD.n271 VDD.t539 17.3693
R446 VDD.n246 VDD.t677 17.3693
R447 VDD.n624 VDD.t1069 17.3693
R448 VDD.n600 VDD.t1374 17.3693
R449 VDD.n575 VDD.t1159 17.3693
R450 VDD.n296 VDD.t41 17.3693
R451 VDD.n1431 VDD.t211 17.3693
R452 VDD.n1455 VDD.t365 17.3693
R453 VDD.n1503 VDD.t524 17.3693
R454 VDD.n1479 VDD.t662 17.3693
R455 VDD.n440 VDD.t844 17.3693
R456 VDD.n322 VDD.t1092 17.3693
R457 VDD.n1277 VDD.t925 17.3693
R458 VDD.n1302 VDD.t1125 17.3693
R459 VDD.n1403 VDD.t198 17.3693
R460 VDD.n1378 VDD.t350 17.3693
R461 VDD.n1352 VDD.t509 17.3693
R462 VDD.n1327 VDD.t647 17.3693
R463 VDD.n1101 VDD.t1012 17.3693
R464 VDD.n1125 VDD.t1055 17.3693
R465 VDD.n1248 VDD.t1400 17.3693
R466 VDD.n1224 VDD.t775 17.3693
R467 VDD.n1199 VDD.t185 17.3693
R468 VDD.n1175 VDD.t335 17.3693
R469 VDD.n1149 VDD.t494 17.3693
R470 VDD.n57 VDD.t632 17.3693
R471 VDD.n1073 VDD.t1040 17.3693
R472 VDD.n1049 VDD.t792 17.3693
R473 VDD.n1024 VDD.t955 17.3693
R474 VDD.n1000 VDD.t876 17.3693
R475 VDD.n974 VDD.t129 17.3693
R476 VDD.n31 VDD.t288 17.3693
R477 VDD.n1981 VDD.t450 17.3693
R478 VDD.n1957 VDD.t617 17.3693
R479 VDD.n3 VDD.t611 17.2438
R480 VDD.n333 VDD.t74 17.2438
R481 VDD.n775 VDD.t1143 17.2247
R482 VDD.n848 VDD.t778 17.2247
R483 VDD.n824 VDD.t111 17.2247
R484 VDD.n799 VDD.t145 17.2247
R485 VDD.n82 VDD.t305 17.2247
R486 VDD.n1880 VDD.t464 17.2247
R487 VDD.n1904 VDD.t719 17.2247
R488 VDD.n747 VDD.t855 17.2247
R489 VDD.n723 VDD.t1145 17.2247
R490 VDD.n698 VDD.t941 17.2247
R491 VDD.n163 VDD.t96 17.2247
R492 VDD.n1780 VDD.t148 17.2247
R493 VDD.n1804 VDD.t307 17.2247
R494 VDD.n1852 VDD.t466 17.2247
R495 VDD.n1828 VDD.t704 17.2247
R496 VDD.n670 VDD.t930 17.2247
R497 VDD.n187 VDD.t1039 17.2247
R498 VDD.n1629 VDD.t943 17.2247
R499 VDD.n1653 VDD.t70 17.2247
R500 VDD.n1750 VDD.t151 17.2247
R501 VDD.n1726 VDD.t309 17.2247
R502 VDD.n1701 VDD.t468 17.2247
R503 VDD.n1677 VDD.t689 17.2247
R504 VDD.n646 VDD.t1097 17.2247
R505 VDD.n216 VDD.t1149 17.2247
R506 VDD.n1603 VDD.t928 17.2247
R507 VDD.n1578 VDD.t54 17.2247
R508 VDD.n1552 VDD.t154 17.2247
R509 VDD.n1527 VDD.t311 17.2247
R510 VDD.n266 VDD.t470 17.2247
R511 VDD.n241 VDD.t674 17.2247
R512 VDD.n619 VDD.t1082 17.2247
R513 VDD.n595 VDD.t1006 17.2247
R514 VDD.n570 VDD.t902 17.2247
R515 VDD.n291 VDD.t38 17.2247
R516 VDD.n1426 VDD.t157 17.2247
R517 VDD.n1450 VDD.t313 17.2247
R518 VDD.n1498 VDD.t472 17.2247
R519 VDD.n1474 VDD.t659 17.2247
R520 VDD.n435 VDD.t1017 17.2247
R521 VDD.n317 VDD.t838 17.2247
R522 VDD.n1272 VDD.t922 17.2247
R523 VDD.n1297 VDD.t1114 17.2247
R524 VDD.n1398 VDD.t160 17.2247
R525 VDD.n1373 VDD.t315 17.2247
R526 VDD.n1347 VDD.t474 17.2247
R527 VDD.n1322 VDD.t644 17.2247
R528 VDD.n1096 VDD.t1042 17.2247
R529 VDD.n1120 VDD.t1155 17.2247
R530 VDD.n1243 VDD.t951 17.2247
R531 VDD.n1219 VDD.t789 17.2247
R532 VDD.n1194 VDD.t163 17.2247
R533 VDD.n1170 VDD.t317 17.2247
R534 VDD.n1144 VDD.t476 17.2247
R535 VDD.n52 VDD.t629 17.2247
R536 VDD.n1068 VDD.t1029 17.2247
R537 VDD.n1044 VDD.t1095 17.2247
R538 VDD.n1019 VDD.t953 17.2247
R539 VDD.n995 VDD.t875 17.2247
R540 VDD.n969 VDD.t124 17.2247
R541 VDD.n26 VDD.t285 17.2247
R542 VDD.n1976 VDD.t447 17.2247
R543 VDD.n1952 VDD.t614 17.2247
R544 VDD.n2024 VDD.n2023 17.0268
R545 VDD.n770 VDD.t1390 17.0005
R546 VDD.t1051 VDD.n779 17.0005
R547 VDD.n843 VDD.t780 17.0005
R548 VDD.t732 VDD.n852 17.0005
R549 VDD.n819 VDD.t112 17.0005
R550 VDD.t114 VDD.n828 17.0005
R551 VDD.n794 VDD.t270 17.0005
R552 VDD.t272 VDD.n803 17.0005
R553 VDD.n77 VDD.t424 17.0005
R554 VDD.t426 VDD.n86 17.0005
R555 VDD.n1875 VDD.t585 17.0005
R556 VDD.t587 VDD.n1884 17.0005
R557 VDD.n1899 VDD.t721 17.0005
R558 VDD.t723 VDD.n1908 17.0005
R559 VDD.n2005 VDD.n2002 17.0005
R560 VDD.n2006 VDD.n2005 17.0005
R561 VDD.n2005 VDD.n1993 17.0005
R562 VDD.n2005 VDD.n2004 17.0005
R563 VDD.n2005 VDD.n1999 17.0005
R564 VDD.n2039 VDD.n2035 17.0005
R565 VDD.n2039 VDD.n2038 17.0005
R566 VDD.n2024 VDD.n2018 17.0005
R567 VDD.n2024 VDD.n2021 17.0005
R568 VDD.n2024 VDD.n2015 17.0005
R569 VDD.n491 VDD.t1050 17.0005
R570 VDD.t981 VDD.n494 17.0005
R571 VDD.t981 VDD.n490 17.0005
R572 VDD.n479 VDD.t1044 17.0005
R573 VDD.t992 VDD.n478 17.0005
R574 VDD.n487 VDD.t992 17.0005
R575 VDD.n462 VDD.t1188 17.0005
R576 VDD.t1161 VDD.n461 17.0005
R577 VDD.n470 VDD.t1161 17.0005
R578 VDD.n886 VDD.t1014 17.0005
R579 VDD.t998 VDD.n877 17.0005
R580 VDD.n887 VDD.t998 17.0005
R581 VDD.n742 VDD.t857 17.0005
R582 VDD.t802 VDD.n751 17.0005
R583 VDD.n718 VDD.t1308 17.0005
R584 VDD.t1062 VDD.n727 17.0005
R585 VDD.n693 VDD.t1428 17.0005
R586 VDD.t862 VDD.n702 17.0005
R587 VDD.n158 VDD.t97 17.0005
R588 VDD.t99 VDD.n167 17.0005
R589 VDD.n1775 VDD.t255 17.0005
R590 VDD.t257 VDD.n1784 17.0005
R591 VDD.n1799 VDD.t409 17.0005
R592 VDD.t411 VDD.n1808 17.0005
R593 VDD.n1847 VDD.t568 17.0005
R594 VDD.t570 VDD.n1856 17.0005
R595 VDD.n1823 VDD.t706 17.0005
R596 VDD.t708 VDD.n1832 17.0005
R597 VDD.n667 VDD.t971 17.0005
R598 VDD.t794 VDD.n675 17.0005
R599 VDD.n184 VDD.t1037 17.0005
R600 VDD.t898 VDD.n192 17.0005
R601 VDD.n1626 VDD.t1426 17.0005
R602 VDD.t1222 VDD.n1634 17.0005
R603 VDD.n1650 VDD.t81 17.0005
R604 VDD.t83 VDD.n1658 17.0005
R605 VDD.n1747 VDD.t240 17.0005
R606 VDD.t242 VDD.n1755 17.0005
R607 VDD.n1723 VDD.t394 17.0005
R608 VDD.t396 VDD.n1731 17.0005
R609 VDD.n1698 VDD.t553 17.0005
R610 VDD.t555 VDD.n1706 17.0005
R611 VDD.n1674 VDD.t691 17.0005
R612 VDD.t693 VDD.n1682 17.0005
R613 VDD.n640 VDD.t1344 17.0005
R614 VDD.n658 VDD.t989 17.0005
R615 VDD.t989 VDD.n636 17.0005
R616 VDD.t989 VDD.n650 17.0005
R617 VDD.n210 VDD.t1382 17.0005
R618 VDD.n228 VDD.t735 17.0005
R619 VDD.t735 VDD.n206 17.0005
R620 VDD.t735 VDD.n220 17.0005
R621 VDD.n1597 VDD.t1079 17.0005
R622 VDD.n1615 VDD.t982 17.0005
R623 VDD.t982 VDD.n1593 17.0005
R624 VDD.t982 VDD.n1607 17.0005
R625 VDD.n1572 VDD.t56 17.0005
R626 VDD.n1590 VDD.t58 17.0005
R627 VDD.t58 VDD.n1568 17.0005
R628 VDD.t58 VDD.n1582 17.0005
R629 VDD.n1546 VDD.t225 17.0005
R630 VDD.n1564 VDD.t227 17.0005
R631 VDD.t227 VDD.n1542 17.0005
R632 VDD.t227 VDD.n1556 17.0005
R633 VDD.n1521 VDD.t379 17.0005
R634 VDD.n1539 VDD.t381 17.0005
R635 VDD.t381 VDD.n1517 17.0005
R636 VDD.t381 VDD.n1531 17.0005
R637 VDD.n260 VDD.t538 17.0005
R638 VDD.n278 VDD.t540 17.0005
R639 VDD.t540 VDD.n256 17.0005
R640 VDD.t540 VDD.n270 17.0005
R641 VDD.n235 VDD.t676 17.0005
R642 VDD.n253 VDD.t678 17.0005
R643 VDD.t678 VDD.n231 17.0005
R644 VDD.t678 VDD.n245 17.0005
R645 VDD.n614 VDD.t1073 17.0005
R646 VDD.t994 VDD.n623 17.0005
R647 VDD.n590 VDD.t1008 17.0005
R648 VDD.t1216 VDD.n599 17.0005
R649 VDD.n565 VDD.t904 17.0005
R650 VDD.t877 VDD.n574 17.0005
R651 VDD.n286 VDD.t40 17.0005
R652 VDD.t42 VDD.n295 17.0005
R653 VDD.n1421 VDD.t210 17.0005
R654 VDD.t212 VDD.n1430 17.0005
R655 VDD.n1445 VDD.t364 17.0005
R656 VDD.t366 VDD.n1454 17.0005
R657 VDD.n1493 VDD.t523 17.0005
R658 VDD.t525 VDD.n1502 17.0005
R659 VDD.n1469 VDD.t661 17.0005
R660 VDD.t663 VDD.n1478 17.0005
R661 VDD.n429 VDD.t1284 17.0005
R662 VDD.n447 VDD.t845 17.0005
R663 VDD.t845 VDD.n425 17.0005
R664 VDD.t845 VDD.n439 17.0005
R665 VDD.n311 VDD.t823 17.0005
R666 VDD.n329 VDD.t764 17.0005
R667 VDD.t764 VDD.n307 17.0005
R668 VDD.t764 VDD.n321 17.0005
R669 VDD.n1266 VDD.t924 17.0005
R670 VDD.n1284 VDD.t888 17.0005
R671 VDD.t888 VDD.n1262 17.0005
R672 VDD.t888 VDD.n1276 17.0005
R673 VDD.n1291 VDD.t1124 17.0005
R674 VDD.n1309 VDD.t1126 17.0005
R675 VDD.t1126 VDD.n1287 17.0005
R676 VDD.t1126 VDD.n1301 17.0005
R677 VDD.n1392 VDD.t197 17.0005
R678 VDD.n1410 VDD.t199 17.0005
R679 VDD.t199 VDD.n1388 17.0005
R680 VDD.t199 VDD.n1402 17.0005
R681 VDD.n1367 VDD.t349 17.0005
R682 VDD.n1385 VDD.t351 17.0005
R683 VDD.t351 VDD.n1363 17.0005
R684 VDD.t351 VDD.n1377 17.0005
R685 VDD.n1341 VDD.t508 17.0005
R686 VDD.n1359 VDD.t510 17.0005
R687 VDD.t510 VDD.n1337 17.0005
R688 VDD.t510 VDD.n1351 17.0005
R689 VDD.n1316 VDD.t646 17.0005
R690 VDD.n1334 VDD.t648 17.0005
R691 VDD.t648 VDD.n1312 17.0005
R692 VDD.t648 VDD.n1326 17.0005
R693 VDD.n1090 VDD.t1013 17.0005
R694 VDD.n1108 VDD.t763 17.0005
R695 VDD.t763 VDD.n1086 17.0005
R696 VDD.t763 VDD.n1100 17.0005
R697 VDD.n1115 VDD.t1086 17.0005
R698 VDD.t1056 VDD.n1124 17.0005
R699 VDD.n1238 VDD.t1402 17.0005
R700 VDD.t1220 VDD.n1247 17.0005
R701 VDD.n1214 VDD.t791 17.0005
R702 VDD.t18 VDD.n1223 17.0005
R703 VDD.n1189 VDD.t184 17.0005
R704 VDD.t186 VDD.n1198 17.0005
R705 VDD.n1164 VDD.t334 17.0005
R706 VDD.n1182 VDD.t336 17.0005
R707 VDD.t336 VDD.n1160 17.0005
R708 VDD.t336 VDD.n1174 17.0005
R709 VDD.n1139 VDD.t493 17.0005
R710 VDD.t495 VDD.n1148 17.0005
R711 VDD.n46 VDD.t631 17.0005
R712 VDD.n64 VDD.t633 17.0005
R713 VDD.t633 VDD.n42 17.0005
R714 VDD.t633 VDD.n56 17.0005
R715 VDD.n335 VDD.n334 17.0005
R716 VDD.n366 VDD.n340 17.0005
R717 VDD.n367 VDD.n366 17.0005
R718 VDD.n344 VDD.n341 17.0005
R719 VDD.n351 VDD.n344 17.0005
R720 VDD.n353 VDD.n352 17.0005
R721 VDD.n354 VDD.n353 17.0005
R722 VDD.n355 VDD.n347 17.0005
R723 VDD.n358 VDD.n347 17.0005
R724 VDD.n363 VDD.n359 17.0005
R725 VDD.n363 VDD.n362 17.0005
R726 VDD.n385 VDD.n373 17.0005
R727 VDD.n383 VDD.n382 17.0005
R728 VDD.n382 VDD.n381 17.0005
R729 VDD.n380 VDD.n379 17.0005
R730 VDD.n379 VDD.n378 17.0005
R731 VDD.n418 VDD.n417 17.0005
R732 VDD.n417 VDD.n416 17.0005
R733 VDD.n415 VDD.n414 17.0005
R734 VDD.n414 VDD.n413 17.0005
R735 VDD.n412 VDD.n411 17.0005
R736 VDD.n411 VDD.n410 17.0005
R737 VDD.n409 VDD.n408 17.0005
R738 VDD.n408 VDD.n407 17.0005
R739 VDD.n406 VDD.n405 17.0005
R740 VDD.n405 VDD.n404 17.0005
R741 VDD.n1063 VDD.t1167 17.0005
R742 VDD.t1023 VDD.n1072 17.0005
R743 VDD.n1039 VDD.t808 17.0005
R744 VDD.t753 VDD.n1048 17.0005
R745 VDD.n1014 VDD.t841 17.0005
R746 VDD.t962 VDD.n1023 17.0005
R747 VDD.n990 VDD.t1436 17.0005
R748 VDD.t766 VDD.n999 17.0005
R749 VDD.n964 VDD.t132 17.0005
R750 VDD.t167 VDD.n973 17.0005
R751 VDD.n21 VDD.t289 17.0005
R752 VDD.t321 VDD.n30 17.0005
R753 VDD.n1971 VDD.t452 17.0005
R754 VDD.t480 VDD.n1980 17.0005
R755 VDD.n1947 VDD.t616 17.0005
R756 VDD.t618 VDD.n1956 17.0005
R757 VDD.n2043 VDD.n2007 9.06259
R758 VDD.n789 VDD.n788 9.0005
R759 VDD.n862 VDD.n861 9.0005
R760 VDD.n838 VDD.n837 9.0005
R761 VDD.n813 VDD.n812 9.0005
R762 VDD.n96 VDD.n95 9.0005
R763 VDD.n1894 VDD.n1893 9.0005
R764 VDD.n1918 VDD.n1917 9.0005
R765 VDD.n2042 VDD.n2041 9.0005
R766 VDD.n2027 VDD.n2026 9.0005
R767 VDD.n5 VDD.n4 9.0005
R768 VDD.n761 VDD.n760 9.0005
R769 VDD.n737 VDD.n736 9.0005
R770 VDD.n712 VDD.n711 9.0005
R771 VDD.n177 VDD.n176 9.0005
R772 VDD.n1794 VDD.n1793 9.0005
R773 VDD.n1818 VDD.n1817 9.0005
R774 VDD.n1866 VDD.n1865 9.0005
R775 VDD.n1842 VDD.n1841 9.0005
R776 VDD.n686 VDD.n685 9.0005
R777 VDD.n203 VDD.n202 9.0005
R778 VDD.n1645 VDD.n1644 9.0005
R779 VDD.n1669 VDD.n1668 9.0005
R780 VDD.n1766 VDD.n1765 9.0005
R781 VDD.n1742 VDD.n1741 9.0005
R782 VDD.n1717 VDD.n1716 9.0005
R783 VDD.n1693 VDD.n1692 9.0005
R784 VDD.n660 VDD.n659 9.0005
R785 VDD.n230 VDD.n229 9.0005
R786 VDD.n1617 VDD.n1616 9.0005
R787 VDD.n1592 VDD.n1591 9.0005
R788 VDD.n1566 VDD.n1565 9.0005
R789 VDD.n1541 VDD.n1540 9.0005
R790 VDD.n280 VDD.n279 9.0005
R791 VDD.n255 VDD.n254 9.0005
R792 VDD.n633 VDD.n632 9.0005
R793 VDD.n609 VDD.n608 9.0005
R794 VDD.n584 VDD.n583 9.0005
R795 VDD.n305 VDD.n304 9.0005
R796 VDD.n1440 VDD.n1439 9.0005
R797 VDD.n1464 VDD.n1463 9.0005
R798 VDD.n1512 VDD.n1511 9.0005
R799 VDD.n1488 VDD.n1487 9.0005
R800 VDD.n449 VDD.n448 9.0005
R801 VDD.n331 VDD.n330 9.0005
R802 VDD.n1286 VDD.n1285 9.0005
R803 VDD.n1311 VDD.n1310 9.0005
R804 VDD.n1412 VDD.n1411 9.0005
R805 VDD.n1387 VDD.n1386 9.0005
R806 VDD.n1361 VDD.n1360 9.0005
R807 VDD.n1336 VDD.n1335 9.0005
R808 VDD.n1110 VDD.n1109 9.0005
R809 VDD.n1134 VDD.n1133 9.0005
R810 VDD.n1257 VDD.n1256 9.0005
R811 VDD.n1233 VDD.n1232 9.0005
R812 VDD.n1208 VDD.n1207 9.0005
R813 VDD.n1184 VDD.n1183 9.0005
R814 VDD.n1158 VDD.n1157 9.0005
R815 VDD.n66 VDD.n65 9.0005
R816 VDD.n339 VDD.n338 9.0005
R817 VDD.n371 VDD.n370 9.0005
R818 VDD.n392 VDD.n391 9.0005
R819 VDD.n420 VDD.n419 9.0005
R820 VDD.n1082 VDD.n1081 9.0005
R821 VDD.n1058 VDD.n1057 9.0005
R822 VDD.n1033 VDD.n1032 9.0005
R823 VDD.n1009 VDD.n1008 9.0005
R824 VDD.n983 VDD.n982 9.0005
R825 VDD.n40 VDD.n39 9.0005
R826 VDD.n1990 VDD.n1989 9.0005
R827 VDD.n1966 VDD.n1965 9.0005
R828 VDD.n2090 VDD.n2047 9.0005
R829 VDD.n2093 VDD.n2047 9.0005
R830 VDD.n151 VDD.n104 9.0005
R831 VDD.n151 VDD.n150 9.0005
R832 VDD.n2067 VDD.n13 9.0005
R833 VDD.n2090 VDD.n13 9.0005
R834 VDD.n2093 VDD.n13 9.0005
R835 VDD.n111 VDD.n72 9.0005
R836 VDD.n111 VDD.n104 9.0005
R837 VDD.n150 VDD.n111 9.0005
R838 VDD.n2067 VDD.n2049 9.0005
R839 VDD.n2065 VDD.n2049 9.0005
R840 VDD.n2070 VDD.n2049 9.0005
R841 VDD.n2064 VDD.n2049 9.0005
R842 VDD.n2073 VDD.n2049 9.0005
R843 VDD.n2063 VDD.n2049 9.0005
R844 VDD.n2076 VDD.n2049 9.0005
R845 VDD.n2062 VDD.n2049 9.0005
R846 VDD.n2079 VDD.n2049 9.0005
R847 VDD.n2061 VDD.n2049 9.0005
R848 VDD.n2081 VDD.n2049 9.0005
R849 VDD.n2090 VDD.n2049 9.0005
R850 VDD.n2093 VDD.n2049 9.0005
R851 VDD.n114 VDD.n72 9.0005
R852 VDD.n137 VDD.n114 9.0005
R853 VDD.n139 VDD.n114 9.0005
R854 VDD.n136 VDD.n114 9.0005
R855 VDD.n141 VDD.n114 9.0005
R856 VDD.n135 VDD.n114 9.0005
R857 VDD.n143 VDD.n114 9.0005
R858 VDD.n134 VDD.n114 9.0005
R859 VDD.n145 VDD.n114 9.0005
R860 VDD.n133 VDD.n114 9.0005
R861 VDD.n147 VDD.n114 9.0005
R862 VDD.n114 VDD.n104 9.0005
R863 VDD.n150 VDD.n114 9.0005
R864 VDD.n2067 VDD.n12 9.0005
R865 VDD.n2065 VDD.n12 9.0005
R866 VDD.n2070 VDD.n12 9.0005
R867 VDD.n2064 VDD.n12 9.0005
R868 VDD.n2073 VDD.n12 9.0005
R869 VDD.n2063 VDD.n12 9.0005
R870 VDD.n2076 VDD.n12 9.0005
R871 VDD.n2062 VDD.n12 9.0005
R872 VDD.n2079 VDD.n12 9.0005
R873 VDD.n2061 VDD.n12 9.0005
R874 VDD.n2081 VDD.n12 9.0005
R875 VDD.n2090 VDD.n12 9.0005
R876 VDD.n2093 VDD.n12 9.0005
R877 VDD.n110 VDD.n72 9.0005
R878 VDD.n137 VDD.n110 9.0005
R879 VDD.n139 VDD.n110 9.0005
R880 VDD.n136 VDD.n110 9.0005
R881 VDD.n141 VDD.n110 9.0005
R882 VDD.n135 VDD.n110 9.0005
R883 VDD.n143 VDD.n110 9.0005
R884 VDD.n134 VDD.n110 9.0005
R885 VDD.n145 VDD.n110 9.0005
R886 VDD.n133 VDD.n110 9.0005
R887 VDD.n147 VDD.n110 9.0005
R888 VDD.n110 VDD.n104 9.0005
R889 VDD.n150 VDD.n110 9.0005
R890 VDD.n2067 VDD.n2051 9.0005
R891 VDD.n2065 VDD.n2051 9.0005
R892 VDD.n2070 VDD.n2051 9.0005
R893 VDD.n2064 VDD.n2051 9.0005
R894 VDD.n2073 VDD.n2051 9.0005
R895 VDD.n2063 VDD.n2051 9.0005
R896 VDD.n2076 VDD.n2051 9.0005
R897 VDD.n2062 VDD.n2051 9.0005
R898 VDD.n2079 VDD.n2051 9.0005
R899 VDD.n2061 VDD.n2051 9.0005
R900 VDD.n2081 VDD.n2051 9.0005
R901 VDD.n2090 VDD.n2051 9.0005
R902 VDD.n2093 VDD.n2051 9.0005
R903 VDD.n116 VDD.n72 9.0005
R904 VDD.n137 VDD.n116 9.0005
R905 VDD.n139 VDD.n116 9.0005
R906 VDD.n136 VDD.n116 9.0005
R907 VDD.n141 VDD.n116 9.0005
R908 VDD.n135 VDD.n116 9.0005
R909 VDD.n143 VDD.n116 9.0005
R910 VDD.n134 VDD.n116 9.0005
R911 VDD.n145 VDD.n116 9.0005
R912 VDD.n133 VDD.n116 9.0005
R913 VDD.n147 VDD.n116 9.0005
R914 VDD.n116 VDD.n104 9.0005
R915 VDD.n150 VDD.n116 9.0005
R916 VDD.n2067 VDD.n11 9.0005
R917 VDD.n2065 VDD.n11 9.0005
R918 VDD.n2070 VDD.n11 9.0005
R919 VDD.n2064 VDD.n11 9.0005
R920 VDD.n2073 VDD.n11 9.0005
R921 VDD.n2063 VDD.n11 9.0005
R922 VDD.n2076 VDD.n11 9.0005
R923 VDD.n2062 VDD.n11 9.0005
R924 VDD.n2079 VDD.n11 9.0005
R925 VDD.n2061 VDD.n11 9.0005
R926 VDD.n2081 VDD.n11 9.0005
R927 VDD.n2090 VDD.n11 9.0005
R928 VDD.n2093 VDD.n11 9.0005
R929 VDD.n109 VDD.n72 9.0005
R930 VDD.n137 VDD.n109 9.0005
R931 VDD.n139 VDD.n109 9.0005
R932 VDD.n136 VDD.n109 9.0005
R933 VDD.n141 VDD.n109 9.0005
R934 VDD.n135 VDD.n109 9.0005
R935 VDD.n143 VDD.n109 9.0005
R936 VDD.n134 VDD.n109 9.0005
R937 VDD.n145 VDD.n109 9.0005
R938 VDD.n133 VDD.n109 9.0005
R939 VDD.n147 VDD.n109 9.0005
R940 VDD.n109 VDD.n104 9.0005
R941 VDD.n150 VDD.n109 9.0005
R942 VDD.n2067 VDD.n2053 9.0005
R943 VDD.n2065 VDD.n2053 9.0005
R944 VDD.n2070 VDD.n2053 9.0005
R945 VDD.n2064 VDD.n2053 9.0005
R946 VDD.n2073 VDD.n2053 9.0005
R947 VDD.n2063 VDD.n2053 9.0005
R948 VDD.n2076 VDD.n2053 9.0005
R949 VDD.n2062 VDD.n2053 9.0005
R950 VDD.n2079 VDD.n2053 9.0005
R951 VDD.n2061 VDD.n2053 9.0005
R952 VDD.n2081 VDD.n2053 9.0005
R953 VDD.n2090 VDD.n2053 9.0005
R954 VDD.n2093 VDD.n2053 9.0005
R955 VDD.n118 VDD.n72 9.0005
R956 VDD.n137 VDD.n118 9.0005
R957 VDD.n139 VDD.n118 9.0005
R958 VDD.n136 VDD.n118 9.0005
R959 VDD.n141 VDD.n118 9.0005
R960 VDD.n135 VDD.n118 9.0005
R961 VDD.n143 VDD.n118 9.0005
R962 VDD.n134 VDD.n118 9.0005
R963 VDD.n145 VDD.n118 9.0005
R964 VDD.n133 VDD.n118 9.0005
R965 VDD.n147 VDD.n118 9.0005
R966 VDD.n118 VDD.n104 9.0005
R967 VDD.n150 VDD.n118 9.0005
R968 VDD.n2067 VDD.n10 9.0005
R969 VDD.n2065 VDD.n10 9.0005
R970 VDD.n2070 VDD.n10 9.0005
R971 VDD.n2064 VDD.n10 9.0005
R972 VDD.n2073 VDD.n10 9.0005
R973 VDD.n2063 VDD.n10 9.0005
R974 VDD.n2076 VDD.n10 9.0005
R975 VDD.n2062 VDD.n10 9.0005
R976 VDD.n2079 VDD.n10 9.0005
R977 VDD.n2061 VDD.n10 9.0005
R978 VDD.n2081 VDD.n10 9.0005
R979 VDD.n2090 VDD.n10 9.0005
R980 VDD.n2093 VDD.n10 9.0005
R981 VDD.n108 VDD.n72 9.0005
R982 VDD.n137 VDD.n108 9.0005
R983 VDD.n139 VDD.n108 9.0005
R984 VDD.n136 VDD.n108 9.0005
R985 VDD.n141 VDD.n108 9.0005
R986 VDD.n135 VDD.n108 9.0005
R987 VDD.n143 VDD.n108 9.0005
R988 VDD.n134 VDD.n108 9.0005
R989 VDD.n145 VDD.n108 9.0005
R990 VDD.n133 VDD.n108 9.0005
R991 VDD.n147 VDD.n108 9.0005
R992 VDD.n108 VDD.n104 9.0005
R993 VDD.n150 VDD.n108 9.0005
R994 VDD.n2067 VDD.n2055 9.0005
R995 VDD.n2065 VDD.n2055 9.0005
R996 VDD.n2070 VDD.n2055 9.0005
R997 VDD.n2064 VDD.n2055 9.0005
R998 VDD.n2073 VDD.n2055 9.0005
R999 VDD.n2063 VDD.n2055 9.0005
R1000 VDD.n2076 VDD.n2055 9.0005
R1001 VDD.n2062 VDD.n2055 9.0005
R1002 VDD.n2079 VDD.n2055 9.0005
R1003 VDD.n2061 VDD.n2055 9.0005
R1004 VDD.n2081 VDD.n2055 9.0005
R1005 VDD.n2090 VDD.n2055 9.0005
R1006 VDD.n2093 VDD.n2055 9.0005
R1007 VDD.n120 VDD.n72 9.0005
R1008 VDD.n137 VDD.n120 9.0005
R1009 VDD.n139 VDD.n120 9.0005
R1010 VDD.n136 VDD.n120 9.0005
R1011 VDD.n141 VDD.n120 9.0005
R1012 VDD.n135 VDD.n120 9.0005
R1013 VDD.n143 VDD.n120 9.0005
R1014 VDD.n134 VDD.n120 9.0005
R1015 VDD.n145 VDD.n120 9.0005
R1016 VDD.n133 VDD.n120 9.0005
R1017 VDD.n147 VDD.n120 9.0005
R1018 VDD.n120 VDD.n104 9.0005
R1019 VDD.n150 VDD.n120 9.0005
R1020 VDD.n2067 VDD.n9 9.0005
R1021 VDD.n2065 VDD.n9 9.0005
R1022 VDD.n2070 VDD.n9 9.0005
R1023 VDD.n2064 VDD.n9 9.0005
R1024 VDD.n2073 VDD.n9 9.0005
R1025 VDD.n2063 VDD.n9 9.0005
R1026 VDD.n2076 VDD.n9 9.0005
R1027 VDD.n2062 VDD.n9 9.0005
R1028 VDD.n2079 VDD.n9 9.0005
R1029 VDD.n2061 VDD.n9 9.0005
R1030 VDD.n2081 VDD.n9 9.0005
R1031 VDD.n2090 VDD.n9 9.0005
R1032 VDD.n2093 VDD.n9 9.0005
R1033 VDD.n107 VDD.n72 9.0005
R1034 VDD.n137 VDD.n107 9.0005
R1035 VDD.n139 VDD.n107 9.0005
R1036 VDD.n136 VDD.n107 9.0005
R1037 VDD.n141 VDD.n107 9.0005
R1038 VDD.n135 VDD.n107 9.0005
R1039 VDD.n143 VDD.n107 9.0005
R1040 VDD.n134 VDD.n107 9.0005
R1041 VDD.n145 VDD.n107 9.0005
R1042 VDD.n133 VDD.n107 9.0005
R1043 VDD.n147 VDD.n107 9.0005
R1044 VDD.n107 VDD.n104 9.0005
R1045 VDD.n150 VDD.n107 9.0005
R1046 VDD.n2067 VDD.n2057 9.0005
R1047 VDD.n2065 VDD.n2057 9.0005
R1048 VDD.n2070 VDD.n2057 9.0005
R1049 VDD.n2064 VDD.n2057 9.0005
R1050 VDD.n2073 VDD.n2057 9.0005
R1051 VDD.n2063 VDD.n2057 9.0005
R1052 VDD.n2076 VDD.n2057 9.0005
R1053 VDD.n2062 VDD.n2057 9.0005
R1054 VDD.n2079 VDD.n2057 9.0005
R1055 VDD.n2061 VDD.n2057 9.0005
R1056 VDD.n2081 VDD.n2057 9.0005
R1057 VDD.n2090 VDD.n2057 9.0005
R1058 VDD.n2093 VDD.n2057 9.0005
R1059 VDD.n122 VDD.n72 9.0005
R1060 VDD.n137 VDD.n122 9.0005
R1061 VDD.n139 VDD.n122 9.0005
R1062 VDD.n136 VDD.n122 9.0005
R1063 VDD.n141 VDD.n122 9.0005
R1064 VDD.n135 VDD.n122 9.0005
R1065 VDD.n143 VDD.n122 9.0005
R1066 VDD.n134 VDD.n122 9.0005
R1067 VDD.n145 VDD.n122 9.0005
R1068 VDD.n133 VDD.n122 9.0005
R1069 VDD.n147 VDD.n122 9.0005
R1070 VDD.n122 VDD.n104 9.0005
R1071 VDD.n150 VDD.n122 9.0005
R1072 VDD.n2067 VDD.n8 9.0005
R1073 VDD.n2065 VDD.n8 9.0005
R1074 VDD.n2070 VDD.n8 9.0005
R1075 VDD.n2064 VDD.n8 9.0005
R1076 VDD.n2073 VDD.n8 9.0005
R1077 VDD.n2063 VDD.n8 9.0005
R1078 VDD.n2076 VDD.n8 9.0005
R1079 VDD.n2062 VDD.n8 9.0005
R1080 VDD.n2079 VDD.n8 9.0005
R1081 VDD.n2061 VDD.n8 9.0005
R1082 VDD.n2081 VDD.n8 9.0005
R1083 VDD.n2090 VDD.n8 9.0005
R1084 VDD.n2093 VDD.n8 9.0005
R1085 VDD.n106 VDD.n72 9.0005
R1086 VDD.n137 VDD.n106 9.0005
R1087 VDD.n139 VDD.n106 9.0005
R1088 VDD.n136 VDD.n106 9.0005
R1089 VDD.n141 VDD.n106 9.0005
R1090 VDD.n135 VDD.n106 9.0005
R1091 VDD.n143 VDD.n106 9.0005
R1092 VDD.n134 VDD.n106 9.0005
R1093 VDD.n145 VDD.n106 9.0005
R1094 VDD.n133 VDD.n106 9.0005
R1095 VDD.n147 VDD.n106 9.0005
R1096 VDD.n106 VDD.n104 9.0005
R1097 VDD.n150 VDD.n106 9.0005
R1098 VDD.n2067 VDD.n2059 9.0005
R1099 VDD.n2065 VDD.n2059 9.0005
R1100 VDD.n2070 VDD.n2059 9.0005
R1101 VDD.n2064 VDD.n2059 9.0005
R1102 VDD.n2073 VDD.n2059 9.0005
R1103 VDD.n2063 VDD.n2059 9.0005
R1104 VDD.n2076 VDD.n2059 9.0005
R1105 VDD.n2062 VDD.n2059 9.0005
R1106 VDD.n2079 VDD.n2059 9.0005
R1107 VDD.n2061 VDD.n2059 9.0005
R1108 VDD.n2081 VDD.n2059 9.0005
R1109 VDD.n2090 VDD.n2059 9.0005
R1110 VDD.n2093 VDD.n2059 9.0005
R1111 VDD.n124 VDD.n72 9.0005
R1112 VDD.n137 VDD.n124 9.0005
R1113 VDD.n139 VDD.n124 9.0005
R1114 VDD.n136 VDD.n124 9.0005
R1115 VDD.n141 VDD.n124 9.0005
R1116 VDD.n135 VDD.n124 9.0005
R1117 VDD.n143 VDD.n124 9.0005
R1118 VDD.n134 VDD.n124 9.0005
R1119 VDD.n145 VDD.n124 9.0005
R1120 VDD.n133 VDD.n124 9.0005
R1121 VDD.n147 VDD.n124 9.0005
R1122 VDD.n124 VDD.n104 9.0005
R1123 VDD.n150 VDD.n124 9.0005
R1124 VDD.n2067 VDD.n7 9.0005
R1125 VDD.n2065 VDD.n7 9.0005
R1126 VDD.n2070 VDD.n7 9.0005
R1127 VDD.n2064 VDD.n7 9.0005
R1128 VDD.n2073 VDD.n7 9.0005
R1129 VDD.n2063 VDD.n7 9.0005
R1130 VDD.n2076 VDD.n7 9.0005
R1131 VDD.n2062 VDD.n7 9.0005
R1132 VDD.n2079 VDD.n7 9.0005
R1133 VDD.n2061 VDD.n7 9.0005
R1134 VDD.n2081 VDD.n7 9.0005
R1135 VDD.n2090 VDD.n7 9.0005
R1136 VDD.n2093 VDD.n7 9.0005
R1137 VDD.n105 VDD.n72 9.0005
R1138 VDD.n137 VDD.n105 9.0005
R1139 VDD.n139 VDD.n105 9.0005
R1140 VDD.n136 VDD.n105 9.0005
R1141 VDD.n141 VDD.n105 9.0005
R1142 VDD.n135 VDD.n105 9.0005
R1143 VDD.n143 VDD.n105 9.0005
R1144 VDD.n134 VDD.n105 9.0005
R1145 VDD.n145 VDD.n105 9.0005
R1146 VDD.n133 VDD.n105 9.0005
R1147 VDD.n147 VDD.n105 9.0005
R1148 VDD.n105 VDD.n104 9.0005
R1149 VDD.n150 VDD.n105 9.0005
R1150 VDD.n2092 VDD.n2067 9.0005
R1151 VDD.n2092 VDD.n2065 9.0005
R1152 VDD.n2092 VDD.n2070 9.0005
R1153 VDD.n2092 VDD.n2064 9.0005
R1154 VDD.n2092 VDD.n2073 9.0005
R1155 VDD.n2092 VDD.n2063 9.0005
R1156 VDD.n2092 VDD.n2076 9.0005
R1157 VDD.n2092 VDD.n2062 9.0005
R1158 VDD.n2092 VDD.n2079 9.0005
R1159 VDD.n2092 VDD.n2061 9.0005
R1160 VDD.n2092 VDD.n2081 9.0005
R1161 VDD.n2093 VDD.n2092 9.0005
R1162 VDD.n149 VDD.n72 9.0005
R1163 VDD.n149 VDD.n137 9.0005
R1164 VDD.n149 VDD.n139 9.0005
R1165 VDD.n149 VDD.n136 9.0005
R1166 VDD.n149 VDD.n141 9.0005
R1167 VDD.n149 VDD.n135 9.0005
R1168 VDD.n149 VDD.n143 9.0005
R1169 VDD.n149 VDD.n134 9.0005
R1170 VDD.n149 VDD.n145 9.0005
R1171 VDD.n149 VDD.n133 9.0005
R1172 VDD.n149 VDD.n147 9.0005
R1173 VDD.n150 VDD.n149 9.0005
R1174 VDD.n557 VDD.n537 9.0005
R1175 VDD.n559 VDD.n537 9.0005
R1176 VDD.n950 VDD.n929 9.0005
R1177 VDD.n951 VDD.n950 9.0005
R1178 VDD.n529 VDD.n457 9.0005
R1179 VDD.n557 VDD.n529 9.0005
R1180 VDD.n559 VDD.n529 9.0005
R1181 VDD.n539 VDD.n457 9.0005
R1182 VDD.n539 VDD.n511 9.0005
R1183 VDD.n539 VDD.n512 9.0005
R1184 VDD.n539 VDD.n510 9.0005
R1185 VDD.n539 VDD.n513 9.0005
R1186 VDD.n539 VDD.n509 9.0005
R1187 VDD.n539 VDD.n514 9.0005
R1188 VDD.n539 VDD.n508 9.0005
R1189 VDD.n539 VDD.n515 9.0005
R1190 VDD.n539 VDD.n507 9.0005
R1191 VDD.n539 VDD.n516 9.0005
R1192 VDD.n557 VDD.n539 9.0005
R1193 VDD.n559 VDD.n539 9.0005
R1194 VDD.n953 VDD.n905 9.0005
R1195 VDD.n929 VDD.n905 9.0005
R1196 VDD.n951 VDD.n905 9.0005
R1197 VDD.n953 VDD.n907 9.0005
R1198 VDD.n918 VDD.n907 9.0005
R1199 VDD.n920 VDD.n907 9.0005
R1200 VDD.n917 VDD.n907 9.0005
R1201 VDD.n922 VDD.n907 9.0005
R1202 VDD.n916 VDD.n907 9.0005
R1203 VDD.n924 VDD.n907 9.0005
R1204 VDD.n915 VDD.n907 9.0005
R1205 VDD.n926 VDD.n907 9.0005
R1206 VDD.n914 VDD.n907 9.0005
R1207 VDD.n928 VDD.n907 9.0005
R1208 VDD.n929 VDD.n907 9.0005
R1209 VDD.n951 VDD.n907 9.0005
R1210 VDD.n523 VDD.n457 9.0005
R1211 VDD.n523 VDD.n511 9.0005
R1212 VDD.n523 VDD.n512 9.0005
R1213 VDD.n523 VDD.n510 9.0005
R1214 VDD.n523 VDD.n513 9.0005
R1215 VDD.n523 VDD.n509 9.0005
R1216 VDD.n523 VDD.n514 9.0005
R1217 VDD.n523 VDD.n508 9.0005
R1218 VDD.n523 VDD.n515 9.0005
R1219 VDD.n523 VDD.n507 9.0005
R1220 VDD.n523 VDD.n516 9.0005
R1221 VDD.n557 VDD.n523 9.0005
R1222 VDD.n559 VDD.n523 9.0005
R1223 VDD.n953 VDD.n904 9.0005
R1224 VDD.n918 VDD.n904 9.0005
R1225 VDD.n920 VDD.n904 9.0005
R1226 VDD.n917 VDD.n904 9.0005
R1227 VDD.n922 VDD.n904 9.0005
R1228 VDD.n916 VDD.n904 9.0005
R1229 VDD.n924 VDD.n904 9.0005
R1230 VDD.n915 VDD.n904 9.0005
R1231 VDD.n926 VDD.n904 9.0005
R1232 VDD.n914 VDD.n904 9.0005
R1233 VDD.n928 VDD.n904 9.0005
R1234 VDD.n929 VDD.n904 9.0005
R1235 VDD.n951 VDD.n904 9.0005
R1236 VDD.n541 VDD.n457 9.0005
R1237 VDD.n541 VDD.n511 9.0005
R1238 VDD.n541 VDD.n512 9.0005
R1239 VDD.n541 VDD.n510 9.0005
R1240 VDD.n541 VDD.n513 9.0005
R1241 VDD.n541 VDD.n509 9.0005
R1242 VDD.n541 VDD.n514 9.0005
R1243 VDD.n541 VDD.n508 9.0005
R1244 VDD.n541 VDD.n515 9.0005
R1245 VDD.n541 VDD.n507 9.0005
R1246 VDD.n541 VDD.n516 9.0005
R1247 VDD.n557 VDD.n541 9.0005
R1248 VDD.n559 VDD.n541 9.0005
R1249 VDD.n953 VDD.n908 9.0005
R1250 VDD.n918 VDD.n908 9.0005
R1251 VDD.n920 VDD.n908 9.0005
R1252 VDD.n917 VDD.n908 9.0005
R1253 VDD.n922 VDD.n908 9.0005
R1254 VDD.n916 VDD.n908 9.0005
R1255 VDD.n924 VDD.n908 9.0005
R1256 VDD.n915 VDD.n908 9.0005
R1257 VDD.n926 VDD.n908 9.0005
R1258 VDD.n914 VDD.n908 9.0005
R1259 VDD.n928 VDD.n908 9.0005
R1260 VDD.n929 VDD.n908 9.0005
R1261 VDD.n951 VDD.n908 9.0005
R1262 VDD.n522 VDD.n457 9.0005
R1263 VDD.n522 VDD.n511 9.0005
R1264 VDD.n522 VDD.n512 9.0005
R1265 VDD.n522 VDD.n510 9.0005
R1266 VDD.n522 VDD.n513 9.0005
R1267 VDD.n522 VDD.n509 9.0005
R1268 VDD.n522 VDD.n514 9.0005
R1269 VDD.n522 VDD.n508 9.0005
R1270 VDD.n522 VDD.n515 9.0005
R1271 VDD.n522 VDD.n507 9.0005
R1272 VDD.n522 VDD.n516 9.0005
R1273 VDD.n557 VDD.n522 9.0005
R1274 VDD.n559 VDD.n522 9.0005
R1275 VDD.n953 VDD.n903 9.0005
R1276 VDD.n918 VDD.n903 9.0005
R1277 VDD.n920 VDD.n903 9.0005
R1278 VDD.n917 VDD.n903 9.0005
R1279 VDD.n922 VDD.n903 9.0005
R1280 VDD.n916 VDD.n903 9.0005
R1281 VDD.n924 VDD.n903 9.0005
R1282 VDD.n915 VDD.n903 9.0005
R1283 VDD.n926 VDD.n903 9.0005
R1284 VDD.n914 VDD.n903 9.0005
R1285 VDD.n928 VDD.n903 9.0005
R1286 VDD.n929 VDD.n903 9.0005
R1287 VDD.n951 VDD.n903 9.0005
R1288 VDD.n543 VDD.n457 9.0005
R1289 VDD.n543 VDD.n511 9.0005
R1290 VDD.n543 VDD.n512 9.0005
R1291 VDD.n543 VDD.n510 9.0005
R1292 VDD.n543 VDD.n513 9.0005
R1293 VDD.n543 VDD.n509 9.0005
R1294 VDD.n543 VDD.n514 9.0005
R1295 VDD.n543 VDD.n508 9.0005
R1296 VDD.n543 VDD.n515 9.0005
R1297 VDD.n543 VDD.n507 9.0005
R1298 VDD.n543 VDD.n516 9.0005
R1299 VDD.n557 VDD.n543 9.0005
R1300 VDD.n559 VDD.n543 9.0005
R1301 VDD.n953 VDD.n909 9.0005
R1302 VDD.n918 VDD.n909 9.0005
R1303 VDD.n920 VDD.n909 9.0005
R1304 VDD.n917 VDD.n909 9.0005
R1305 VDD.n922 VDD.n909 9.0005
R1306 VDD.n916 VDD.n909 9.0005
R1307 VDD.n924 VDD.n909 9.0005
R1308 VDD.n915 VDD.n909 9.0005
R1309 VDD.n926 VDD.n909 9.0005
R1310 VDD.n914 VDD.n909 9.0005
R1311 VDD.n928 VDD.n909 9.0005
R1312 VDD.n929 VDD.n909 9.0005
R1313 VDD.n951 VDD.n909 9.0005
R1314 VDD.n521 VDD.n457 9.0005
R1315 VDD.n521 VDD.n511 9.0005
R1316 VDD.n521 VDD.n512 9.0005
R1317 VDD.n521 VDD.n510 9.0005
R1318 VDD.n521 VDD.n513 9.0005
R1319 VDD.n521 VDD.n509 9.0005
R1320 VDD.n521 VDD.n514 9.0005
R1321 VDD.n521 VDD.n508 9.0005
R1322 VDD.n521 VDD.n515 9.0005
R1323 VDD.n521 VDD.n507 9.0005
R1324 VDD.n521 VDD.n516 9.0005
R1325 VDD.n557 VDD.n521 9.0005
R1326 VDD.n559 VDD.n521 9.0005
R1327 VDD.n953 VDD.n902 9.0005
R1328 VDD.n918 VDD.n902 9.0005
R1329 VDD.n920 VDD.n902 9.0005
R1330 VDD.n917 VDD.n902 9.0005
R1331 VDD.n922 VDD.n902 9.0005
R1332 VDD.n916 VDD.n902 9.0005
R1333 VDD.n924 VDD.n902 9.0005
R1334 VDD.n915 VDD.n902 9.0005
R1335 VDD.n926 VDD.n902 9.0005
R1336 VDD.n914 VDD.n902 9.0005
R1337 VDD.n928 VDD.n902 9.0005
R1338 VDD.n929 VDD.n902 9.0005
R1339 VDD.n951 VDD.n902 9.0005
R1340 VDD.n545 VDD.n457 9.0005
R1341 VDD.n545 VDD.n511 9.0005
R1342 VDD.n545 VDD.n512 9.0005
R1343 VDD.n545 VDD.n510 9.0005
R1344 VDD.n545 VDD.n513 9.0005
R1345 VDD.n545 VDD.n509 9.0005
R1346 VDD.n545 VDD.n514 9.0005
R1347 VDD.n545 VDD.n508 9.0005
R1348 VDD.n545 VDD.n515 9.0005
R1349 VDD.n545 VDD.n507 9.0005
R1350 VDD.n545 VDD.n516 9.0005
R1351 VDD.n557 VDD.n545 9.0005
R1352 VDD.n559 VDD.n545 9.0005
R1353 VDD.n520 VDD.n457 9.0005
R1354 VDD.n520 VDD.n511 9.0005
R1355 VDD.n520 VDD.n512 9.0005
R1356 VDD.n520 VDD.n510 9.0005
R1357 VDD.n520 VDD.n513 9.0005
R1358 VDD.n520 VDD.n509 9.0005
R1359 VDD.n520 VDD.n514 9.0005
R1360 VDD.n520 VDD.n508 9.0005
R1361 VDD.n520 VDD.n515 9.0005
R1362 VDD.n520 VDD.n507 9.0005
R1363 VDD.n520 VDD.n516 9.0005
R1364 VDD.n557 VDD.n520 9.0005
R1365 VDD.n559 VDD.n520 9.0005
R1366 VDD.n953 VDD.n910 9.0005
R1367 VDD.n918 VDD.n910 9.0005
R1368 VDD.n920 VDD.n910 9.0005
R1369 VDD.n917 VDD.n910 9.0005
R1370 VDD.n922 VDD.n910 9.0005
R1371 VDD.n916 VDD.n910 9.0005
R1372 VDD.n924 VDD.n910 9.0005
R1373 VDD.n915 VDD.n910 9.0005
R1374 VDD.n926 VDD.n910 9.0005
R1375 VDD.n914 VDD.n910 9.0005
R1376 VDD.n928 VDD.n910 9.0005
R1377 VDD.n929 VDD.n910 9.0005
R1378 VDD.n951 VDD.n910 9.0005
R1379 VDD.n953 VDD.n901 9.0005
R1380 VDD.n918 VDD.n901 9.0005
R1381 VDD.n920 VDD.n901 9.0005
R1382 VDD.n917 VDD.n901 9.0005
R1383 VDD.n922 VDD.n901 9.0005
R1384 VDD.n916 VDD.n901 9.0005
R1385 VDD.n924 VDD.n901 9.0005
R1386 VDD.n915 VDD.n901 9.0005
R1387 VDD.n926 VDD.n901 9.0005
R1388 VDD.n914 VDD.n901 9.0005
R1389 VDD.n928 VDD.n901 9.0005
R1390 VDD.n929 VDD.n901 9.0005
R1391 VDD.n951 VDD.n901 9.0005
R1392 VDD.n547 VDD.n457 9.0005
R1393 VDD.n547 VDD.n511 9.0005
R1394 VDD.n547 VDD.n512 9.0005
R1395 VDD.n547 VDD.n510 9.0005
R1396 VDD.n547 VDD.n513 9.0005
R1397 VDD.n547 VDD.n509 9.0005
R1398 VDD.n547 VDD.n514 9.0005
R1399 VDD.n547 VDD.n508 9.0005
R1400 VDD.n547 VDD.n515 9.0005
R1401 VDD.n547 VDD.n507 9.0005
R1402 VDD.n547 VDD.n516 9.0005
R1403 VDD.n557 VDD.n547 9.0005
R1404 VDD.n559 VDD.n547 9.0005
R1405 VDD.n953 VDD.n911 9.0005
R1406 VDD.n918 VDD.n911 9.0005
R1407 VDD.n920 VDD.n911 9.0005
R1408 VDD.n917 VDD.n911 9.0005
R1409 VDD.n922 VDD.n911 9.0005
R1410 VDD.n916 VDD.n911 9.0005
R1411 VDD.n924 VDD.n911 9.0005
R1412 VDD.n915 VDD.n911 9.0005
R1413 VDD.n926 VDD.n911 9.0005
R1414 VDD.n914 VDD.n911 9.0005
R1415 VDD.n928 VDD.n911 9.0005
R1416 VDD.n929 VDD.n911 9.0005
R1417 VDD.n951 VDD.n911 9.0005
R1418 VDD.n519 VDD.n457 9.0005
R1419 VDD.n519 VDD.n511 9.0005
R1420 VDD.n519 VDD.n512 9.0005
R1421 VDD.n519 VDD.n510 9.0005
R1422 VDD.n519 VDD.n513 9.0005
R1423 VDD.n519 VDD.n509 9.0005
R1424 VDD.n519 VDD.n514 9.0005
R1425 VDD.n519 VDD.n508 9.0005
R1426 VDD.n519 VDD.n515 9.0005
R1427 VDD.n519 VDD.n507 9.0005
R1428 VDD.n519 VDD.n516 9.0005
R1429 VDD.n557 VDD.n519 9.0005
R1430 VDD.n559 VDD.n519 9.0005
R1431 VDD.n953 VDD.n900 9.0005
R1432 VDD.n918 VDD.n900 9.0005
R1433 VDD.n920 VDD.n900 9.0005
R1434 VDD.n917 VDD.n900 9.0005
R1435 VDD.n922 VDD.n900 9.0005
R1436 VDD.n916 VDD.n900 9.0005
R1437 VDD.n924 VDD.n900 9.0005
R1438 VDD.n915 VDD.n900 9.0005
R1439 VDD.n926 VDD.n900 9.0005
R1440 VDD.n914 VDD.n900 9.0005
R1441 VDD.n928 VDD.n900 9.0005
R1442 VDD.n929 VDD.n900 9.0005
R1443 VDD.n951 VDD.n900 9.0005
R1444 VDD.n558 VDD.n457 9.0005
R1445 VDD.n558 VDD.n511 9.0005
R1446 VDD.n558 VDD.n512 9.0005
R1447 VDD.n558 VDD.n510 9.0005
R1448 VDD.n558 VDD.n513 9.0005
R1449 VDD.n558 VDD.n509 9.0005
R1450 VDD.n558 VDD.n514 9.0005
R1451 VDD.n558 VDD.n508 9.0005
R1452 VDD.n558 VDD.n515 9.0005
R1453 VDD.n558 VDD.n507 9.0005
R1454 VDD.n558 VDD.n516 9.0005
R1455 VDD.n558 VDD.n557 9.0005
R1456 VDD.n559 VDD.n558 9.0005
R1457 VDD.n953 VDD.n952 9.0005
R1458 VDD.n952 VDD.n918 9.0005
R1459 VDD.n952 VDD.n920 9.0005
R1460 VDD.n952 VDD.n917 9.0005
R1461 VDD.n952 VDD.n922 9.0005
R1462 VDD.n952 VDD.n916 9.0005
R1463 VDD.n952 VDD.n924 9.0005
R1464 VDD.n952 VDD.n915 9.0005
R1465 VDD.n952 VDD.n926 9.0005
R1466 VDD.n952 VDD.n914 9.0005
R1467 VDD.n952 VDD.n928 9.0005
R1468 VDD.n952 VDD.n929 9.0005
R1469 VDD.n952 VDD.n951 9.0005
R1470 VDD.n518 VDD.n457 9.0005
R1471 VDD.n518 VDD.n511 9.0005
R1472 VDD.n518 VDD.n512 9.0005
R1473 VDD.n518 VDD.n510 9.0005
R1474 VDD.n518 VDD.n513 9.0005
R1475 VDD.n518 VDD.n509 9.0005
R1476 VDD.n518 VDD.n514 9.0005
R1477 VDD.n518 VDD.n508 9.0005
R1478 VDD.n518 VDD.n515 9.0005
R1479 VDD.n518 VDD.n507 9.0005
R1480 VDD.n518 VDD.n516 9.0005
R1481 VDD.n557 VDD.n518 9.0005
R1482 VDD.n559 VDD.n518 9.0005
R1483 VDD.n953 VDD.n899 9.0005
R1484 VDD.n918 VDD.n899 9.0005
R1485 VDD.n920 VDD.n899 9.0005
R1486 VDD.n917 VDD.n899 9.0005
R1487 VDD.n922 VDD.n899 9.0005
R1488 VDD.n916 VDD.n899 9.0005
R1489 VDD.n924 VDD.n899 9.0005
R1490 VDD.n915 VDD.n899 9.0005
R1491 VDD.n926 VDD.n899 9.0005
R1492 VDD.n914 VDD.n899 9.0005
R1493 VDD.n928 VDD.n899 9.0005
R1494 VDD.n929 VDD.n899 9.0005
R1495 VDD.n951 VDD.n899 9.0005
R1496 VDD.n560 VDD.n457 9.0005
R1497 VDD.n560 VDD.n511 9.0005
R1498 VDD.n560 VDD.n512 9.0005
R1499 VDD.n560 VDD.n510 9.0005
R1500 VDD.n560 VDD.n513 9.0005
R1501 VDD.n560 VDD.n509 9.0005
R1502 VDD.n560 VDD.n514 9.0005
R1503 VDD.n560 VDD.n508 9.0005
R1504 VDD.n560 VDD.n515 9.0005
R1505 VDD.n560 VDD.n507 9.0005
R1506 VDD.n560 VDD.n516 9.0005
R1507 VDD.n560 VDD.n559 9.0005
R1508 VDD.n953 VDD.n423 9.0005
R1509 VDD.n918 VDD.n423 9.0005
R1510 VDD.n920 VDD.n423 9.0005
R1511 VDD.n917 VDD.n423 9.0005
R1512 VDD.n922 VDD.n423 9.0005
R1513 VDD.n916 VDD.n423 9.0005
R1514 VDD.n924 VDD.n423 9.0005
R1515 VDD.n915 VDD.n423 9.0005
R1516 VDD.n926 VDD.n423 9.0005
R1517 VDD.n914 VDD.n423 9.0005
R1518 VDD.n928 VDD.n423 9.0005
R1519 VDD.n951 VDD.n423 9.0005
R1520 VDD.n0 VDD.t612 8.87397
R1521 VDD.n372 VDD.t1725 8.85969
R1522 VDD.n342 VDD.t1191 8.8041
R1523 VDD.n393 VDD.t1190 8.8041
R1524 VDD.n883 VDD.t1733 8.80385
R1525 VDD.n782 VDD.t906 8.80285
R1526 VDD.n855 VDD.t782 8.80285
R1527 VDD.n831 VDD.t116 8.80285
R1528 VDD.n806 VDD.t274 8.80285
R1529 VDD.n89 VDD.t428 8.80285
R1530 VDD.n1887 VDD.t589 8.80285
R1531 VDD.n1911 VDD.t726 8.80285
R1532 VDD.n497 VDD.t826 8.80285
R1533 VDD.n482 VDD.t1790 8.80285
R1534 VDD.n465 VDD.t1773 8.80285
R1535 VDD.n754 VDD.t803 8.80285
R1536 VDD.n730 VDD.t1059 8.80285
R1537 VDD.n705 VDD.t864 8.80285
R1538 VDD.n170 VDD.t101 8.80285
R1539 VDD.n1787 VDD.t258 8.80285
R1540 VDD.n1811 VDD.t414 8.80285
R1541 VDD.n1859 VDD.t572 8.80285
R1542 VDD.n1835 VDD.t710 8.80285
R1543 VDD.n678 VDD.t795 8.80285
R1544 VDD.n195 VDD.t894 8.80285
R1545 VDD.n1637 VDD.t847 8.80285
R1546 VDD.n1661 VDD.t85 8.80285
R1547 VDD.n1758 VDD.t243 8.80285
R1548 VDD.n1734 VDD.t398 8.80285
R1549 VDD.n1709 VDD.t557 8.80285
R1550 VDD.n1685 VDD.t695 8.80285
R1551 VDD.n653 VDD.t1717 8.80285
R1552 VDD.n223 VDD.t1045 8.80285
R1553 VDD.n1610 VDD.t984 8.80285
R1554 VDD.n1585 VDD.t60 8.80285
R1555 VDD.n1559 VDD.t230 8.80285
R1556 VDD.n1534 VDD.t382 8.80285
R1557 VDD.n273 VDD.t542 8.80285
R1558 VDD.n248 VDD.t680 8.80285
R1559 VDD.n626 VDD.t1764 8.80285
R1560 VDD.n602 VDD.t1128 8.80285
R1561 VDD.n577 VDD.t878 8.80285
R1562 VDD.n298 VDD.t44 8.80285
R1563 VDD.n1433 VDD.t214 8.80285
R1564 VDD.n1457 VDD.t368 8.80285
R1565 VDD.n1505 VDD.t526 8.80285
R1566 VDD.n1481 VDD.t665 8.80285
R1567 VDD.n442 VDD.t974 8.80285
R1568 VDD.n324 VDD.t963 8.80285
R1569 VDD.n1279 VDD.t889 8.80285
R1570 VDD.n1304 VDD.t28 8.80285
R1571 VDD.n1405 VDD.t201 8.80285
R1572 VDD.n1380 VDD.t353 8.80285
R1573 VDD.n1354 VDD.t512 8.80285
R1574 VDD.n1329 VDD.t650 8.80285
R1575 VDD.n1103 VDD.t1783 8.80285
R1576 VDD.n1127 VDD.t742 8.80285
R1577 VDD.n1250 VDD.t913 8.80285
R1578 VDD.n1226 VDD.t19 8.80285
R1579 VDD.n1201 VDD.t187 8.80285
R1580 VDD.n1177 VDD.t337 8.80285
R1581 VDD.n1151 VDD.t497 8.80285
R1582 VDD.n59 VDD.t635 8.80285
R1583 VDD.n1075 VDD.t1024 8.80285
R1584 VDD.n1051 VDD.t754 8.80285
R1585 VDD.n1026 VDD.t1706 8.80285
R1586 VDD.n1002 VDD.t768 8.80285
R1587 VDD.n976 VDD.t168 8.80285
R1588 VDD.n33 VDD.t323 8.80285
R1589 VDD.n1983 VDD.t483 8.80285
R1590 VDD.n1959 VDD.t619 8.80285
R1591 VDD.n336 VDD.t1004 8.76154
R1592 VDD.n348 VDD.t79 8.76154
R1593 VDD.n356 VDD.t1162 8.76154
R1594 VDD.n390 VDD.t72 8.76154
R1595 VDD.n1994 VDD.t738 8.76054
R1596 VDD.n2000 VDD.t435 8.76054
R1597 VDD.n1998 VDD.t832 8.76054
R1598 VDD.n1996 VDD.t437 8.76054
R1599 VDD.n2028 VDD.t440 8.76054
R1600 VDD.n2029 VDD.t1768 8.76054
R1601 VDD.n2012 VDD.t600 8.76054
R1602 VDD.n2014 VDD.t834 8.76054
R1603 VDD.n2009 VDD.t740 8.76054
R1604 VDD.n2008 VDD.t603 8.76054
R1605 VDD.n369 VDD.t839 8.76054
R1606 VDD.n401 VDD.t815 8.76054
R1607 VDD.n399 VDD.t78 8.76054
R1608 VDD.n394 VDD.t1089 8.76054
R1609 VDD.n334 VDD.n333 8.54664
R1610 VDD.n365 VDD.t76 8.501
R1611 VDD.t76 VDD.n345 8.501
R1612 VDD.t76 VDD.n346 8.501
R1613 VDD.t77 VDD.n396 8.501
R1614 VDD.t77 VDD.n398 8.501
R1615 VDD.t77 VDD.n400 8.501
R1616 VDD.n343 VDD.n342 8.48842
R1617 VDD.n395 VDD.n393 8.48842
R1618 VDD.n787 VDD.t1051 8.47111
R1619 VDD.t1051 VDD.n776 8.47111
R1620 VDD.t1051 VDD.n774 8.47111
R1621 VDD.t1051 VDD.n772 8.47111
R1622 VDD.t1051 VDD.n783 8.47111
R1623 VDD.t1051 VDD.n786 8.47111
R1624 VDD.n860 VDD.t732 8.47111
R1625 VDD.t732 VDD.n849 8.47111
R1626 VDD.t732 VDD.n847 8.47111
R1627 VDD.t732 VDD.n845 8.47111
R1628 VDD.t732 VDD.n856 8.47111
R1629 VDD.t732 VDD.n859 8.47111
R1630 VDD.n836 VDD.t114 8.47111
R1631 VDD.t114 VDD.n825 8.47111
R1632 VDD.t114 VDD.n823 8.47111
R1633 VDD.t114 VDD.n821 8.47111
R1634 VDD.t114 VDD.n832 8.47111
R1635 VDD.t114 VDD.n835 8.47111
R1636 VDD.n811 VDD.t272 8.47111
R1637 VDD.t272 VDD.n800 8.47111
R1638 VDD.t272 VDD.n798 8.47111
R1639 VDD.t272 VDD.n796 8.47111
R1640 VDD.t272 VDD.n807 8.47111
R1641 VDD.t272 VDD.n810 8.47111
R1642 VDD.n94 VDD.t426 8.47111
R1643 VDD.t426 VDD.n83 8.47111
R1644 VDD.t426 VDD.n81 8.47111
R1645 VDD.t426 VDD.n79 8.47111
R1646 VDD.t426 VDD.n90 8.47111
R1647 VDD.t426 VDD.n93 8.47111
R1648 VDD.n1892 VDD.t587 8.47111
R1649 VDD.t587 VDD.n1881 8.47111
R1650 VDD.t587 VDD.n1879 8.47111
R1651 VDD.t587 VDD.n1877 8.47111
R1652 VDD.t587 VDD.n1888 8.47111
R1653 VDD.t587 VDD.n1891 8.47111
R1654 VDD.n1916 VDD.t723 8.47111
R1655 VDD.t723 VDD.n1905 8.47111
R1656 VDD.t723 VDD.n1903 8.47111
R1657 VDD.t723 VDD.n1901 8.47111
R1658 VDD.t723 VDD.n1912 8.47111
R1659 VDD.t723 VDD.n1915 8.47111
R1660 VDD.n2005 VDD.n2001 8.47111
R1661 VDD.n2005 VDD.n1997 8.47111
R1662 VDD.n2040 VDD.n2039 8.47111
R1663 VDD.n2039 VDD.n2034 8.47111
R1664 VDD.n2025 VDD.n2024 8.47111
R1665 VDD.n2024 VDD.n2017 8.47111
R1666 VDD.n2024 VDD.n2013 8.47111
R1667 VDD.n2024 VDD.n2010 8.47111
R1668 VDD.n2 VDD.n1 8.47111
R1669 VDD.t981 VDD.n498 8.47111
R1670 VDD.t981 VDD.n501 8.47111
R1671 VDD.t992 VDD.n483 8.47111
R1672 VDD.t992 VDD.n486 8.47111
R1673 VDD.t1161 VDD.n466 8.47111
R1674 VDD.t1161 VDD.n469 8.47111
R1675 VDD.t998 VDD.n880 8.47111
R1676 VDD.t998 VDD.n882 8.47111
R1677 VDD.n759 VDD.t802 8.47111
R1678 VDD.t802 VDD.n748 8.47111
R1679 VDD.t802 VDD.n746 8.47111
R1680 VDD.t802 VDD.n744 8.47111
R1681 VDD.t802 VDD.n755 8.47111
R1682 VDD.t802 VDD.n758 8.47111
R1683 VDD.n735 VDD.t1062 8.47111
R1684 VDD.t1062 VDD.n724 8.47111
R1685 VDD.t1062 VDD.n722 8.47111
R1686 VDD.t1062 VDD.n720 8.47111
R1687 VDD.t1062 VDD.n731 8.47111
R1688 VDD.t1062 VDD.n734 8.47111
R1689 VDD.n710 VDD.t862 8.47111
R1690 VDD.t862 VDD.n699 8.47111
R1691 VDD.t862 VDD.n697 8.47111
R1692 VDD.t862 VDD.n695 8.47111
R1693 VDD.t862 VDD.n706 8.47111
R1694 VDD.t862 VDD.n709 8.47111
R1695 VDD.n175 VDD.t99 8.47111
R1696 VDD.t99 VDD.n164 8.47111
R1697 VDD.t99 VDD.n162 8.47111
R1698 VDD.t99 VDD.n160 8.47111
R1699 VDD.t99 VDD.n171 8.47111
R1700 VDD.t99 VDD.n174 8.47111
R1701 VDD.n1792 VDD.t257 8.47111
R1702 VDD.t257 VDD.n1781 8.47111
R1703 VDD.t257 VDD.n1779 8.47111
R1704 VDD.t257 VDD.n1777 8.47111
R1705 VDD.t257 VDD.n1788 8.47111
R1706 VDD.t257 VDD.n1791 8.47111
R1707 VDD.n1816 VDD.t411 8.47111
R1708 VDD.t411 VDD.n1805 8.47111
R1709 VDD.t411 VDD.n1803 8.47111
R1710 VDD.t411 VDD.n1801 8.47111
R1711 VDD.t411 VDD.n1812 8.47111
R1712 VDD.t411 VDD.n1815 8.47111
R1713 VDD.n1864 VDD.t570 8.47111
R1714 VDD.t570 VDD.n1853 8.47111
R1715 VDD.t570 VDD.n1851 8.47111
R1716 VDD.t570 VDD.n1849 8.47111
R1717 VDD.t570 VDD.n1860 8.47111
R1718 VDD.t570 VDD.n1863 8.47111
R1719 VDD.n1840 VDD.t708 8.47111
R1720 VDD.t708 VDD.n1829 8.47111
R1721 VDD.t708 VDD.n1827 8.47111
R1722 VDD.t708 VDD.n1825 8.47111
R1723 VDD.t708 VDD.n1836 8.47111
R1724 VDD.t708 VDD.n1839 8.47111
R1725 VDD.n683 VDD.t794 8.47111
R1726 VDD.t794 VDD.n663 8.47111
R1727 VDD.t794 VDD.n672 8.47111
R1728 VDD.t794 VDD.n669 8.47111
R1729 VDD.t794 VDD.n679 8.47111
R1730 VDD.t794 VDD.n682 8.47111
R1731 VDD.n200 VDD.t898 8.47111
R1732 VDD.t898 VDD.n180 8.47111
R1733 VDD.t898 VDD.n189 8.47111
R1734 VDD.t898 VDD.n186 8.47111
R1735 VDD.t898 VDD.n196 8.47111
R1736 VDD.t898 VDD.n199 8.47111
R1737 VDD.n1642 VDD.t1222 8.47111
R1738 VDD.t1222 VDD.n1622 8.47111
R1739 VDD.t1222 VDD.n1631 8.47111
R1740 VDD.t1222 VDD.n1628 8.47111
R1741 VDD.t1222 VDD.n1638 8.47111
R1742 VDD.t1222 VDD.n1641 8.47111
R1743 VDD.n1666 VDD.t83 8.47111
R1744 VDD.t83 VDD.n1646 8.47111
R1745 VDD.t83 VDD.n1655 8.47111
R1746 VDD.t83 VDD.n1652 8.47111
R1747 VDD.t83 VDD.n1662 8.47111
R1748 VDD.t83 VDD.n1665 8.47111
R1749 VDD.n1763 VDD.t242 8.47111
R1750 VDD.t242 VDD.n1743 8.47111
R1751 VDD.t242 VDD.n1752 8.47111
R1752 VDD.t242 VDD.n1749 8.47111
R1753 VDD.t242 VDD.n1759 8.47111
R1754 VDD.t242 VDD.n1762 8.47111
R1755 VDD.n1739 VDD.t396 8.47111
R1756 VDD.t396 VDD.n1719 8.47111
R1757 VDD.t396 VDD.n1728 8.47111
R1758 VDD.t396 VDD.n1725 8.47111
R1759 VDD.t396 VDD.n1735 8.47111
R1760 VDD.t396 VDD.n1738 8.47111
R1761 VDD.n1714 VDD.t555 8.47111
R1762 VDD.t555 VDD.n1694 8.47111
R1763 VDD.t555 VDD.n1703 8.47111
R1764 VDD.t555 VDD.n1700 8.47111
R1765 VDD.t555 VDD.n1710 8.47111
R1766 VDD.t555 VDD.n1713 8.47111
R1767 VDD.n1690 VDD.t693 8.47111
R1768 VDD.t693 VDD.n1670 8.47111
R1769 VDD.t693 VDD.n1679 8.47111
R1770 VDD.t693 VDD.n1676 8.47111
R1771 VDD.t693 VDD.n1686 8.47111
R1772 VDD.t693 VDD.n1689 8.47111
R1773 VDD.t989 VDD.n647 8.47111
R1774 VDD.t989 VDD.n644 8.47111
R1775 VDD.t989 VDD.n642 8.47111
R1776 VDD.t989 VDD.n654 8.47111
R1777 VDD.t989 VDD.n657 8.47111
R1778 VDD.t735 VDD.n217 8.47111
R1779 VDD.t735 VDD.n214 8.47111
R1780 VDD.t735 VDD.n212 8.47111
R1781 VDD.t735 VDD.n224 8.47111
R1782 VDD.t735 VDD.n227 8.47111
R1783 VDD.t982 VDD.n1604 8.47111
R1784 VDD.t982 VDD.n1601 8.47111
R1785 VDD.t982 VDD.n1599 8.47111
R1786 VDD.t982 VDD.n1611 8.47111
R1787 VDD.t982 VDD.n1614 8.47111
R1788 VDD.t58 VDD.n1579 8.47111
R1789 VDD.t58 VDD.n1576 8.47111
R1790 VDD.t58 VDD.n1574 8.47111
R1791 VDD.t58 VDD.n1586 8.47111
R1792 VDD.t58 VDD.n1589 8.47111
R1793 VDD.t227 VDD.n1553 8.47111
R1794 VDD.t227 VDD.n1550 8.47111
R1795 VDD.t227 VDD.n1548 8.47111
R1796 VDD.t227 VDD.n1560 8.47111
R1797 VDD.t227 VDD.n1563 8.47111
R1798 VDD.t381 VDD.n1528 8.47111
R1799 VDD.t381 VDD.n1525 8.47111
R1800 VDD.t381 VDD.n1523 8.47111
R1801 VDD.t381 VDD.n1535 8.47111
R1802 VDD.t381 VDD.n1538 8.47111
R1803 VDD.t540 VDD.n267 8.47111
R1804 VDD.t540 VDD.n264 8.47111
R1805 VDD.t540 VDD.n262 8.47111
R1806 VDD.t540 VDD.n274 8.47111
R1807 VDD.t540 VDD.n277 8.47111
R1808 VDD.t678 VDD.n242 8.47111
R1809 VDD.t678 VDD.n239 8.47111
R1810 VDD.t678 VDD.n237 8.47111
R1811 VDD.t678 VDD.n249 8.47111
R1812 VDD.t678 VDD.n252 8.47111
R1813 VDD.n631 VDD.t994 8.47111
R1814 VDD.t994 VDD.n620 8.47111
R1815 VDD.t994 VDD.n618 8.47111
R1816 VDD.t994 VDD.n616 8.47111
R1817 VDD.t994 VDD.n627 8.47111
R1818 VDD.t994 VDD.n630 8.47111
R1819 VDD.n607 VDD.t1216 8.47111
R1820 VDD.t1216 VDD.n596 8.47111
R1821 VDD.t1216 VDD.n594 8.47111
R1822 VDD.t1216 VDD.n592 8.47111
R1823 VDD.t1216 VDD.n603 8.47111
R1824 VDD.t1216 VDD.n606 8.47111
R1825 VDD.n582 VDD.t877 8.47111
R1826 VDD.t877 VDD.n571 8.47111
R1827 VDD.t877 VDD.n569 8.47111
R1828 VDD.t877 VDD.n567 8.47111
R1829 VDD.t877 VDD.n578 8.47111
R1830 VDD.t877 VDD.n581 8.47111
R1831 VDD.n303 VDD.t42 8.47111
R1832 VDD.t42 VDD.n292 8.47111
R1833 VDD.t42 VDD.n290 8.47111
R1834 VDD.t42 VDD.n288 8.47111
R1835 VDD.t42 VDD.n299 8.47111
R1836 VDD.t42 VDD.n302 8.47111
R1837 VDD.n1438 VDD.t212 8.47111
R1838 VDD.t212 VDD.n1427 8.47111
R1839 VDD.t212 VDD.n1425 8.47111
R1840 VDD.t212 VDD.n1423 8.47111
R1841 VDD.t212 VDD.n1434 8.47111
R1842 VDD.t212 VDD.n1437 8.47111
R1843 VDD.n1462 VDD.t366 8.47111
R1844 VDD.t366 VDD.n1451 8.47111
R1845 VDD.t366 VDD.n1449 8.47111
R1846 VDD.t366 VDD.n1447 8.47111
R1847 VDD.t366 VDD.n1458 8.47111
R1848 VDD.t366 VDD.n1461 8.47111
R1849 VDD.n1510 VDD.t525 8.47111
R1850 VDD.t525 VDD.n1499 8.47111
R1851 VDD.t525 VDD.n1497 8.47111
R1852 VDD.t525 VDD.n1495 8.47111
R1853 VDD.t525 VDD.n1506 8.47111
R1854 VDD.t525 VDD.n1509 8.47111
R1855 VDD.n1486 VDD.t663 8.47111
R1856 VDD.t663 VDD.n1475 8.47111
R1857 VDD.t663 VDD.n1473 8.47111
R1858 VDD.t663 VDD.n1471 8.47111
R1859 VDD.t663 VDD.n1482 8.47111
R1860 VDD.t663 VDD.n1485 8.47111
R1861 VDD.t845 VDD.n436 8.47111
R1862 VDD.t845 VDD.n433 8.47111
R1863 VDD.t845 VDD.n431 8.47111
R1864 VDD.t845 VDD.n443 8.47111
R1865 VDD.t845 VDD.n446 8.47111
R1866 VDD.t764 VDD.n318 8.47111
R1867 VDD.t764 VDD.n315 8.47111
R1868 VDD.t764 VDD.n313 8.47111
R1869 VDD.t764 VDD.n325 8.47111
R1870 VDD.t764 VDD.n328 8.47111
R1871 VDD.t888 VDD.n1273 8.47111
R1872 VDD.t888 VDD.n1270 8.47111
R1873 VDD.t888 VDD.n1268 8.47111
R1874 VDD.t888 VDD.n1280 8.47111
R1875 VDD.t888 VDD.n1283 8.47111
R1876 VDD.t1126 VDD.n1298 8.47111
R1877 VDD.t1126 VDD.n1295 8.47111
R1878 VDD.t1126 VDD.n1293 8.47111
R1879 VDD.t1126 VDD.n1305 8.47111
R1880 VDD.t1126 VDD.n1308 8.47111
R1881 VDD.t199 VDD.n1399 8.47111
R1882 VDD.t199 VDD.n1396 8.47111
R1883 VDD.t199 VDD.n1394 8.47111
R1884 VDD.t199 VDD.n1406 8.47111
R1885 VDD.t199 VDD.n1409 8.47111
R1886 VDD.t351 VDD.n1374 8.47111
R1887 VDD.t351 VDD.n1371 8.47111
R1888 VDD.t351 VDD.n1369 8.47111
R1889 VDD.t351 VDD.n1381 8.47111
R1890 VDD.t351 VDD.n1384 8.47111
R1891 VDD.t510 VDD.n1348 8.47111
R1892 VDD.t510 VDD.n1345 8.47111
R1893 VDD.t510 VDD.n1343 8.47111
R1894 VDD.t510 VDD.n1355 8.47111
R1895 VDD.t510 VDD.n1358 8.47111
R1896 VDD.t648 VDD.n1323 8.47111
R1897 VDD.t648 VDD.n1320 8.47111
R1898 VDD.t648 VDD.n1318 8.47111
R1899 VDD.t648 VDD.n1330 8.47111
R1900 VDD.t648 VDD.n1333 8.47111
R1901 VDD.t763 VDD.n1097 8.47111
R1902 VDD.t763 VDD.n1094 8.47111
R1903 VDD.t763 VDD.n1092 8.47111
R1904 VDD.t763 VDD.n1104 8.47111
R1905 VDD.t763 VDD.n1107 8.47111
R1906 VDD.n1132 VDD.t1056 8.47111
R1907 VDD.t1056 VDD.n1121 8.47111
R1908 VDD.t1056 VDD.n1119 8.47111
R1909 VDD.t1056 VDD.n1117 8.47111
R1910 VDD.t1056 VDD.n1128 8.47111
R1911 VDD.t1056 VDD.n1131 8.47111
R1912 VDD.n1255 VDD.t1220 8.47111
R1913 VDD.t1220 VDD.n1244 8.47111
R1914 VDD.t1220 VDD.n1242 8.47111
R1915 VDD.t1220 VDD.n1240 8.47111
R1916 VDD.t1220 VDD.n1251 8.47111
R1917 VDD.t1220 VDD.n1254 8.47111
R1918 VDD.n1231 VDD.t18 8.47111
R1919 VDD.t18 VDD.n1220 8.47111
R1920 VDD.t18 VDD.n1218 8.47111
R1921 VDD.t18 VDD.n1216 8.47111
R1922 VDD.t18 VDD.n1227 8.47111
R1923 VDD.t18 VDD.n1230 8.47111
R1924 VDD.n1206 VDD.t186 8.47111
R1925 VDD.t186 VDD.n1195 8.47111
R1926 VDD.t186 VDD.n1193 8.47111
R1927 VDD.t186 VDD.n1191 8.47111
R1928 VDD.t186 VDD.n1202 8.47111
R1929 VDD.t186 VDD.n1205 8.47111
R1930 VDD.t336 VDD.n1171 8.47111
R1931 VDD.t336 VDD.n1168 8.47111
R1932 VDD.t336 VDD.n1166 8.47111
R1933 VDD.t336 VDD.n1178 8.47111
R1934 VDD.t336 VDD.n1181 8.47111
R1935 VDD.n1156 VDD.t495 8.47111
R1936 VDD.t495 VDD.n1145 8.47111
R1937 VDD.t495 VDD.n1143 8.47111
R1938 VDD.t495 VDD.n1141 8.47111
R1939 VDD.t495 VDD.n1152 8.47111
R1940 VDD.t495 VDD.n1155 8.47111
R1941 VDD.t633 VDD.n53 8.47111
R1942 VDD.t633 VDD.n50 8.47111
R1943 VDD.t633 VDD.n48 8.47111
R1944 VDD.t633 VDD.n60 8.47111
R1945 VDD.t633 VDD.n63 8.47111
R1946 VDD.n337 VDD.n334 8.47111
R1947 VDD.n388 VDD.n373 8.47111
R1948 VDD.n384 VDD.n373 8.47111
R1949 VDD.n1080 VDD.t1023 8.47111
R1950 VDD.t1023 VDD.n1069 8.47111
R1951 VDD.t1023 VDD.n1067 8.47111
R1952 VDD.t1023 VDD.n1065 8.47111
R1953 VDD.t1023 VDD.n1076 8.47111
R1954 VDD.t1023 VDD.n1079 8.47111
R1955 VDD.n1056 VDD.t753 8.47111
R1956 VDD.t753 VDD.n1045 8.47111
R1957 VDD.t753 VDD.n1043 8.47111
R1958 VDD.t753 VDD.n1041 8.47111
R1959 VDD.t753 VDD.n1052 8.47111
R1960 VDD.t753 VDD.n1055 8.47111
R1961 VDD.n1031 VDD.t962 8.47111
R1962 VDD.t962 VDD.n1020 8.47111
R1963 VDD.t962 VDD.n1018 8.47111
R1964 VDD.t962 VDD.n1016 8.47111
R1965 VDD.t962 VDD.n1027 8.47111
R1966 VDD.t962 VDD.n1030 8.47111
R1967 VDD.n1007 VDD.t766 8.47111
R1968 VDD.t766 VDD.n996 8.47111
R1969 VDD.t766 VDD.n994 8.47111
R1970 VDD.t766 VDD.n992 8.47111
R1971 VDD.t766 VDD.n1003 8.47111
R1972 VDD.t766 VDD.n1006 8.47111
R1973 VDD.n981 VDD.t167 8.47111
R1974 VDD.t167 VDD.n970 8.47111
R1975 VDD.t167 VDD.n968 8.47111
R1976 VDD.t167 VDD.n966 8.47111
R1977 VDD.t167 VDD.n977 8.47111
R1978 VDD.t167 VDD.n980 8.47111
R1979 VDD.n38 VDD.t321 8.47111
R1980 VDD.t321 VDD.n27 8.47111
R1981 VDD.t321 VDD.n25 8.47111
R1982 VDD.t321 VDD.n23 8.47111
R1983 VDD.t321 VDD.n34 8.47111
R1984 VDD.t321 VDD.n37 8.47111
R1985 VDD.n1988 VDD.t480 8.47111
R1986 VDD.t480 VDD.n1977 8.47111
R1987 VDD.t480 VDD.n1975 8.47111
R1988 VDD.t480 VDD.n1973 8.47111
R1989 VDD.t480 VDD.n1984 8.47111
R1990 VDD.t480 VDD.n1987 8.47111
R1991 VDD.n1964 VDD.t618 8.47111
R1992 VDD.t618 VDD.n1953 8.47111
R1993 VDD.t618 VDD.n1951 8.47111
R1994 VDD.t618 VDD.n1949 8.47111
R1995 VDD.t618 VDD.n1960 8.47111
R1996 VDD.t618 VDD.n1963 8.47111
R1997 VDD.n878 VDD.t16 6.08597
R1998 VDD.n768 VDD.t911 6.08455
R1999 VDD.n841 VDD.t787 6.08455
R2000 VDD.n817 VDD.t121 6.08455
R2001 VDD.n792 VDD.t279 6.08455
R2002 VDD.n75 VDD.t433 6.08455
R2003 VDD.n1873 VDD.t594 6.08455
R2004 VDD.n1897 VDD.t730 6.08455
R2005 VDD.n477 VDD.t871 6.08455
R2006 VDD.n740 VDD.t869 6.08455
R2007 VDD.n716 VDD.t1778 6.08455
R2008 VDD.n691 VDD.t859 6.08455
R2009 VDD.n156 VDD.t106 6.08455
R2010 VDD.n1773 VDD.t264 6.08455
R2011 VDD.n1797 VDD.t418 6.08455
R2012 VDD.n1845 VDD.t577 6.08455
R2013 VDD.n1821 VDD.t715 6.08455
R2014 VDD.n665 VDD.t800 6.08455
R2015 VDD.n182 VDD.t900 6.08455
R2016 VDD.n1624 VDD.t852 6.08455
R2017 VDD.n1648 VDD.t90 6.08455
R2018 VDD.n1745 VDD.t249 6.08455
R2019 VDD.n1721 VDD.t403 6.08455
R2020 VDD.n1696 VDD.t562 6.08455
R2021 VDD.n1672 VDD.t700 6.08455
R2022 VDD.n638 VDD.t1723 6.08455
R2023 VDD.n208 VDD.t1033 6.08455
R2024 VDD.n1595 VDD.t1075 6.08455
R2025 VDD.n1570 VDD.t65 6.08455
R2026 VDD.n1544 VDD.t234 6.08455
R2027 VDD.n1519 VDD.t388 6.08455
R2028 VDD.n258 VDD.t547 6.08455
R2029 VDD.n233 VDD.t685 6.08455
R2030 VDD.n612 VDD.t996 6.08455
R2031 VDD.n588 VDD.t1133 6.08455
R2032 VDD.n563 VDD.t883 6.08455
R2033 VDD.n284 VDD.t49 6.08455
R2034 VDD.n1419 VDD.t219 6.08455
R2035 VDD.n1443 VDD.t373 6.08455
R2036 VDD.n1491 VDD.t532 6.08455
R2037 VDD.n1467 VDD.t670 6.08455
R2038 VDD.n427 VDD.t978 6.08455
R2039 VDD.n309 VDD.t968 6.08455
R2040 VDD.n1264 VDD.t1020 6.08455
R2041 VDD.n1289 VDD.t33 6.08455
R2042 VDD.n1390 VDD.t196 6.08455
R2043 VDD.n1365 VDD.t358 6.08455
R2044 VDD.n1339 VDD.t517 6.08455
R2045 VDD.n1314 VDD.t655 6.08455
R2046 VDD.n1088 VDD.t1789 6.08455
R2047 VDD.n1113 VDD.t747 6.08455
R2048 VDD.n1236 VDD.t918 6.08455
R2049 VDD.n1212 VDD.t24 6.08455
R2050 VDD.n1187 VDD.t183 6.08455
R2051 VDD.n1162 VDD.t343 6.08455
R2052 VDD.n1137 VDD.t502 6.08455
R2053 VDD.n44 VDD.t640 6.08455
R2054 VDD.n1061 VDD.t1066 6.08455
R2055 VDD.n1037 VDD.t759 6.08455
R2056 VDD.n1012 VDD.t1712 6.08455
R2057 VDD.n988 VDD.t772 6.08455
R2058 VDD.n962 VDD.t174 6.08455
R2059 VDD.n19 VDD.t328 6.08455
R2060 VDD.n1969 VDD.t487 6.08455
R2061 VDD.n1945 VDD.t625 6.08455
R2062 VDD.n493 VDD.t831 6.08421
R2063 VDD.n460 VDD.t980 6.08421
R2064 VDD.n881 VDD.t1735 6.07366
R2065 VDD.n784 VDD.t907 6.073
R2066 VDD.n857 VDD.t783 6.073
R2067 VDD.n833 VDD.t118 6.073
R2068 VDD.n808 VDD.t276 6.073
R2069 VDD.n91 VDD.t430 6.073
R2070 VDD.n1889 VDD.t591 6.073
R2071 VDD.n1913 VDD.t725 6.073
R2072 VDD.n499 VDD.t828 6.073
R2073 VDD.n484 VDD.t1792 6.073
R2074 VDD.n467 VDD.t1775 6.073
R2075 VDD.n756 VDD.t805 6.073
R2076 VDD.n732 VDD.t1058 6.073
R2077 VDD.n707 VDD.t866 6.073
R2078 VDD.n172 VDD.t102 6.073
R2079 VDD.n1789 VDD.t260 6.073
R2080 VDD.n1813 VDD.t413 6.073
R2081 VDD.n1861 VDD.t574 6.073
R2082 VDD.n1837 VDD.t712 6.073
R2083 VDD.n680 VDD.t797 6.073
R2084 VDD.n197 VDD.t896 6.073
R2085 VDD.n1639 VDD.t849 6.073
R2086 VDD.n1663 VDD.t87 6.073
R2087 VDD.n1760 VDD.t245 6.073
R2088 VDD.n1736 VDD.t400 6.073
R2089 VDD.n1711 VDD.t559 6.073
R2090 VDD.n1687 VDD.t697 6.073
R2091 VDD.n655 VDD.t1719 6.073
R2092 VDD.n225 VDD.t1046 6.073
R2093 VDD.n1612 VDD.t986 6.073
R2094 VDD.n1587 VDD.t62 6.073
R2095 VDD.n1561 VDD.t229 6.073
R2096 VDD.n1536 VDD.t384 6.073
R2097 VDD.n275 VDD.t544 6.073
R2098 VDD.n250 VDD.t682 6.073
R2099 VDD.n628 VDD.t1763 6.073
R2100 VDD.n604 VDD.t1129 6.073
R2101 VDD.n579 VDD.t880 6.073
R2102 VDD.n300 VDD.t46 6.073
R2103 VDD.n1435 VDD.t216 6.073
R2104 VDD.n1459 VDD.t370 6.073
R2105 VDD.n1507 VDD.t528 6.073
R2106 VDD.n1483 VDD.t667 6.073
R2107 VDD.n444 VDD.t973 6.073
R2108 VDD.n326 VDD.t965 6.073
R2109 VDD.n1281 VDD.t890 6.073
R2110 VDD.n1306 VDD.t30 6.073
R2111 VDD.n1407 VDD.t203 6.073
R2112 VDD.n1382 VDD.t355 6.073
R2113 VDD.n1356 VDD.t514 6.073
R2114 VDD.n1331 VDD.t652 6.073
R2115 VDD.n1105 VDD.t1785 6.073
R2116 VDD.n1129 VDD.t744 6.073
R2117 VDD.n1252 VDD.t915 6.073
R2118 VDD.n1228 VDD.t20 6.073
R2119 VDD.n1203 VDD.t189 6.073
R2120 VDD.n1179 VDD.t339 6.073
R2121 VDD.n1153 VDD.t499 6.073
R2122 VDD.n61 VDD.t637 6.073
R2123 VDD.n1077 VDD.t1026 6.073
R2124 VDD.n1053 VDD.t756 6.073
R2125 VDD.n1028 VDD.t1708 6.073
R2126 VDD.n1004 VDD.t767 6.073
R2127 VDD.n978 VDD.t170 6.073
R2128 VDD.n35 VDD.t325 6.073
R2129 VDD.n1985 VDD.t482 6.073
R2130 VDD.n1961 VDD.t621 6.073
R2131 VDD.n1995 VDD.t439 6.05444
R2132 VDD.n2030 VDD.t596 6.02344
R2133 VDD.n879 VDD.t15 5.98925
R2134 VDD.n785 VDD.t910 5.9886
R2135 VDD.n858 VDD.t786 5.9886
R2136 VDD.n834 VDD.t120 5.9886
R2137 VDD.n809 VDD.t278 5.9886
R2138 VDD.n92 VDD.t432 5.9886
R2139 VDD.n1890 VDD.t593 5.9886
R2140 VDD.n1914 VDD.t729 5.9886
R2141 VDD.n485 VDD.t870 5.9886
R2142 VDD.n757 VDD.t868 5.9886
R2143 VDD.n733 VDD.t1777 5.9886
R2144 VDD.n708 VDD.t858 5.9886
R2145 VDD.n173 VDD.t105 5.9886
R2146 VDD.n1790 VDD.t263 5.9886
R2147 VDD.n1814 VDD.t417 5.9886
R2148 VDD.n1862 VDD.t576 5.9886
R2149 VDD.n1838 VDD.t714 5.9886
R2150 VDD.n681 VDD.t799 5.9886
R2151 VDD.n198 VDD.t899 5.9886
R2152 VDD.n1640 VDD.t851 5.9886
R2153 VDD.n1664 VDD.t89 5.9886
R2154 VDD.n1761 VDD.t248 5.9886
R2155 VDD.n1737 VDD.t402 5.9886
R2156 VDD.n1712 VDD.t561 5.9886
R2157 VDD.n1688 VDD.t699 5.9886
R2158 VDD.n656 VDD.t1722 5.9886
R2159 VDD.n226 VDD.t1032 5.9886
R2160 VDD.n1613 VDD.t1074 5.9886
R2161 VDD.n1588 VDD.t64 5.9886
R2162 VDD.n1562 VDD.t233 5.9886
R2163 VDD.n1537 VDD.t387 5.9886
R2164 VDD.n276 VDD.t546 5.9886
R2165 VDD.n251 VDD.t684 5.9886
R2166 VDD.n629 VDD.t995 5.9886
R2167 VDD.n605 VDD.t1132 5.9886
R2168 VDD.n580 VDD.t882 5.9886
R2169 VDD.n301 VDD.t48 5.9886
R2170 VDD.n1436 VDD.t218 5.9886
R2171 VDD.n1460 VDD.t372 5.9886
R2172 VDD.n1508 VDD.t531 5.9886
R2173 VDD.n1484 VDD.t669 5.9886
R2174 VDD.n445 VDD.t977 5.9886
R2175 VDD.n327 VDD.t967 5.9886
R2176 VDD.n1282 VDD.t1019 5.9886
R2177 VDD.n1307 VDD.t32 5.9886
R2178 VDD.n1408 VDD.t195 5.9886
R2179 VDD.n1383 VDD.t357 5.9886
R2180 VDD.n1357 VDD.t516 5.9886
R2181 VDD.n1332 VDD.t654 5.9886
R2182 VDD.n1106 VDD.t1788 5.9886
R2183 VDD.n1130 VDD.t746 5.9886
R2184 VDD.n1253 VDD.t917 5.9886
R2185 VDD.n1229 VDD.t23 5.9886
R2186 VDD.n1204 VDD.t182 5.9886
R2187 VDD.n1180 VDD.t342 5.9886
R2188 VDD.n1154 VDD.t501 5.9886
R2189 VDD.n62 VDD.t639 5.9886
R2190 VDD.n1078 VDD.t1065 5.9886
R2191 VDD.n1054 VDD.t758 5.9886
R2192 VDD.n1029 VDD.t1711 5.9886
R2193 VDD.n1005 VDD.t771 5.9886
R2194 VDD.n979 VDD.t173 5.9886
R2195 VDD.n36 VDD.t327 5.9886
R2196 VDD.n1986 VDD.t486 5.9886
R2197 VDD.n1962 VDD.t624 5.9886
R2198 VDD.n500 VDD.t830 5.98825
R2199 VDD.n468 VDD.t979 5.98825
R2200 VDD.n766 VDD.t1801 5.98764
R2201 VDD.n839 VDD.t777 5.98764
R2202 VDD.n815 VDD.t110 5.98764
R2203 VDD.n790 VDD.t267 5.98764
R2204 VDD.n73 VDD.t421 5.98764
R2205 VDD.n1871 VDD.t582 5.98764
R2206 VDD.n1895 VDD.t718 5.98764
R2207 VDD.n738 VDD.t854 5.98764
R2208 VDD.n714 VDD.t1729 5.98764
R2209 VDD.n689 VDD.t1750 5.98764
R2210 VDD.n154 VDD.t95 5.98764
R2211 VDD.n1771 VDD.t252 5.98764
R2212 VDD.n1795 VDD.t406 5.98764
R2213 VDD.n1843 VDD.t565 5.98764
R2214 VDD.n1819 VDD.t703 5.98764
R2215 VDD.n684 VDD.t929 5.98764
R2216 VDD.n201 VDD.t1038 5.98764
R2217 VDD.n1643 VDD.t1752 5.98764
R2218 VDD.n1667 VDD.t69 5.98764
R2219 VDD.n1764 VDD.t237 5.98764
R2220 VDD.n1740 VDD.t391 5.98764
R2221 VDD.n1715 VDD.t550 5.98764
R2222 VDD.n1691 VDD.t688 5.98764
R2223 VDD.n645 VDD.t1096 5.98764
R2224 VDD.n215 VDD.t1795 5.98764
R2225 VDD.n1602 VDD.t927 5.98764
R2226 VDD.n1577 VDD.t53 5.98764
R2227 VDD.n1551 VDD.t222 5.98764
R2228 VDD.n1526 VDD.t376 5.98764
R2229 VDD.n265 VDD.t535 5.98764
R2230 VDD.n240 VDD.t673 5.98764
R2231 VDD.n610 VDD.t1081 5.98764
R2232 VDD.n586 VDD.t1005 5.98764
R2233 VDD.n561 VDD.t901 5.98764
R2234 VDD.n282 VDD.t37 5.98764
R2235 VDD.n1417 VDD.t207 5.98764
R2236 VDD.n1441 VDD.t361 5.98764
R2237 VDD.n1489 VDD.t520 5.98764
R2238 VDD.n1465 VDD.t658 5.98764
R2239 VDD.n434 VDD.t1016 5.98764
R2240 VDD.n316 VDD.t837 5.98764
R2241 VDD.n1271 VDD.t921 5.98764
R2242 VDD.n1296 VDD.t1121 5.98764
R2243 VDD.n1397 VDD.t193 5.98764
R2244 VDD.n1372 VDD.t346 5.98764
R2245 VDD.n1346 VDD.t505 5.98764
R2246 VDD.n1321 VDD.t643 5.98764
R2247 VDD.n1095 VDD.t1041 5.98764
R2248 VDD.n1111 VDD.t1760 5.98764
R2249 VDD.n1234 VDD.t1699 5.98764
R2250 VDD.n1210 VDD.t788 5.98764
R2251 VDD.n1185 VDD.t180 5.98764
R2252 VDD.n1169 VDD.t331 5.98764
R2253 VDD.n1135 VDD.t490 5.98764
R2254 VDD.n51 VDD.t628 5.98764
R2255 VDD.n1059 VDD.t1028 5.98764
R2256 VDD.n1035 VDD.t1094 5.98764
R2257 VDD.n1010 VDD.t960 5.98764
R2258 VDD.n986 VDD.t874 5.98764
R2259 VDD.n960 VDD.t123 5.98764
R2260 VDD.n17 VDD.t284 5.98764
R2261 VDD.n1967 VDD.t446 5.98764
R2262 VDD.n1943 VDD.t613 5.98764
R2263 VDD.n773 VDD.t1144 5.98258
R2264 VDD.n846 VDD.t940 5.98258
R2265 VDD.n822 VDD.t1105 5.98258
R2266 VDD.n797 VDD.t146 5.98258
R2267 VDD.n80 VDD.t306 5.98258
R2268 VDD.n1878 VDD.t465 5.98258
R2269 VDD.n1902 VDD.t1690 5.98258
R2270 VDD.n745 VDD.t1175 5.98258
R2271 VDD.n721 VDD.t1146 5.98258
R2272 VDD.n696 VDD.t942 5.98258
R2273 VDD.n161 VDD.t1107 5.98258
R2274 VDD.n1778 VDD.t149 5.98258
R2275 VDD.n1802 VDD.t308 5.98258
R2276 VDD.n1850 VDD.t467 5.98258
R2277 VDD.n1826 VDD.t1682 5.98258
R2278 VDD.n671 VDD.t1177 5.98258
R2279 VDD.n188 VDD.t1148 5.98258
R2280 VDD.n1630 VDD.t944 5.98258
R2281 VDD.n1654 VDD.t1109 5.98258
R2282 VDD.n1751 VDD.t152 5.98258
R2283 VDD.n1727 VDD.t310 5.98258
R2284 VDD.n1702 VDD.t469 5.98258
R2285 VDD.n1678 VDD.t1672 5.98258
R2286 VDD.n643 VDD.t1179 5.98258
R2287 VDD.n213 VDD.t1150 5.98258
R2288 VDD.n1600 VDD.t946 5.98258
R2289 VDD.n1575 VDD.t1111 5.98258
R2290 VDD.n1549 VDD.t155 5.98258
R2291 VDD.n1524 VDD.t312 5.98258
R2292 VDD.n263 VDD.t471 5.98258
R2293 VDD.n238 VDD.t1662 5.98258
R2294 VDD.n617 VDD.t1181 5.98258
R2295 VDD.n593 VDD.t1152 5.98258
R2296 VDD.n568 VDD.t948 5.98258
R2297 VDD.n289 VDD.t1113 5.98258
R2298 VDD.n1424 VDD.t158 5.98258
R2299 VDD.n1448 VDD.t314 5.98258
R2300 VDD.n1496 VDD.t473 5.98258
R2301 VDD.n1472 VDD.t1650 5.98258
R2302 VDD.n432 VDD.t1183 5.98258
R2303 VDD.n314 VDD.t1154 5.98258
R2304 VDD.n1269 VDD.t950 5.98258
R2305 VDD.n1294 VDD.t1115 5.98258
R2306 VDD.n1395 VDD.t161 5.98258
R2307 VDD.n1370 VDD.t316 5.98258
R2308 VDD.n1344 VDD.t475 5.98258
R2309 VDD.n1319 VDD.t1640 5.98258
R2310 VDD.n1093 VDD.t1185 5.98258
R2311 VDD.n1118 VDD.t1156 5.98258
R2312 VDD.n1241 VDD.t952 5.98258
R2313 VDD.n1217 VDD.t1117 5.98258
R2314 VDD.n1192 VDD.t164 5.98258
R2315 VDD.n1167 VDD.t318 5.98258
R2316 VDD.n1142 VDD.t477 5.98258
R2317 VDD.n49 VDD.t1632 5.98258
R2318 VDD.n1066 VDD.t1187 5.98258
R2319 VDD.n1042 VDD.t1158 5.98258
R2320 VDD.n1017 VDD.t954 5.98258
R2321 VDD.n993 VDD.t1119 5.98258
R2322 VDD.n967 VDD.t166 5.98258
R2323 VDD.n24 VDD.t320 5.98258
R2324 VDD.n1974 VDD.t479 5.98258
R2325 VDD.n1950 VDD.t1620 5.98258
R2326 VDD.n777 VDD.t1054 5.97398
R2327 VDD.n850 VDD.t809 5.97398
R2328 VDD.n826 VDD.t107 5.97398
R2329 VDD.n801 VDD.t265 5.97398
R2330 VDD.n84 VDD.t133 5.97398
R2331 VDD.n1882 VDD.t294 5.97398
R2332 VDD.n1906 VDD.t451 5.97398
R2333 VDD.n749 VDD.t1030 5.97398
R2334 VDD.n725 VDD.t1169 5.97398
R2335 VDD.n700 VDD.t811 5.97398
R2336 VDD.n165 VDD.t92 5.97398
R2337 VDD.n1782 VDD.t250 5.97398
R2338 VDD.n1806 VDD.t126 5.97398
R2339 VDD.n1854 VDD.t283 5.97398
R2340 VDD.n1830 VDD.t449 5.97398
R2341 VDD.n673 VDD.t1713 5.97398
R2342 VDD.n190 VDD.t1034 5.97398
R2343 VDD.n1632 VDD.t1076 5.97398
R2344 VDD.n1656 VDD.t67 5.97398
R2345 VDD.n1753 VDD.t235 5.97398
R2346 VDD.n1729 VDD.t136 5.97398
R2347 VDD.n1704 VDD.t291 5.97398
R2348 VDD.n1680 VDD.t455 5.97398
R2349 VDD.n648 VDD.t10 5.97398
R2350 VDD.n218 VDD.t1134 5.97398
R2351 VDD.n1605 VDD.t885 5.97398
R2352 VDD.n1580 VDD.t51 5.97398
R2353 VDD.n1554 VDD.t220 5.97398
R2354 VDD.n1529 VDD.t138 5.97398
R2355 VDD.n268 VDD.t296 5.97398
R2356 VDD.n243 VDD.t457 5.97398
R2357 VDD.n621 VDD.t12 5.97398
R2358 VDD.n597 VDD.t969 5.97398
R2359 VDD.n572 VDD.t1021 5.97398
R2360 VDD.n293 VDD.t35 5.97398
R2361 VDD.n1428 VDD.t205 5.97398
R2362 VDD.n1452 VDD.t140 5.97398
R2363 VDD.n1500 VDD.t298 5.97398
R2364 VDD.n1476 VDD.t459 5.97398
R2365 VDD.n437 VDD.t8 5.97398
R2366 VDD.n319 VDD.t749 5.97398
R2367 VDD.n1274 VDD.t919 5.97398
R2368 VDD.n1299 VDD.t26 5.97398
R2369 VDD.n1400 VDD.t177 5.97398
R2370 VDD.n1375 VDD.t128 5.97398
R2371 VDD.n1349 VDD.t300 5.97398
R2372 VDD.n1324 VDD.t445 5.97398
R2373 VDD.n1098 VDD.t1067 5.97398
R2374 VDD.n1122 VDD.t990 5.97398
R2375 VDD.n1245 VDD.t1141 5.97398
R2376 VDD.n1221 VDD.t773 5.97398
R2377 VDD.n1196 VDD.t175 5.97398
R2378 VDD.n1172 VDD.t142 5.97398
R2379 VDD.n1146 VDD.t302 5.97398
R2380 VDD.n54 VDD.t461 5.97398
R2381 VDD.n1070 VDD.t6 5.97398
R2382 VDD.n1046 VDD.t1083 5.97398
R2383 VDD.n1021 VDD.t958 5.97398
R2384 VDD.n997 VDD.t872 5.97398
R2385 VDD.n971 VDD.t130 5.97398
R2386 VDD.n28 VDD.t144 5.97398
R2387 VDD.n1978 VDD.t304 5.97398
R2388 VDD.n1954 VDD.t463 5.97398
R2389 VDD.n360 VDD.t1742 5.97212
R2390 VDD.n387 VDD.t1088 5.97212
R2391 VDD.n2036 VDD.t441 5.97169
R2392 VDD.n2022 VDD.t602 5.97169
R2393 VDD.n349 VDD.t840 5.97169
R2394 VDD.n403 VDD.t816 5.97169
R2395 VDD.n397 VDD.t1090 5.97169
R2396 VDD.n2003 VDD.t436 5.97146
R2397 VDD.n2019 VDD.t604 5.97146
R2398 VDD.n368 VDD.t1165 5.92136
R2399 VDD.n350 VDD.t1166 5.92136
R2400 VDD.n2020 VDD.t599 5.92092
R2401 VDD.n2016 VDD.t598 5.92092
R2402 VDD.n377 VDD.t1011 5.92092
R2403 VDD.n374 VDD.t997 5.92092
R2404 VDD.n389 VDD.t75 5.92092
R2405 VDD.n767 VDD.t1780 5.9207
R2406 VDD.n840 VDD.t861 5.9207
R2407 VDD.n816 VDD.t108 5.9207
R2408 VDD.n791 VDD.t266 5.9207
R2409 VDD.n74 VDD.t420 5.9207
R2410 VDD.n1872 VDD.t579 5.9207
R2411 VDD.n1896 VDD.t717 5.9207
R2412 VDD.n2033 VDD.t580 5.9207
R2413 VDD.n2037 VDD.t581 5.9207
R2414 VDD.n2031 VDD.t287 5.9207
R2415 VDD.n2011 VDD.t605 5.9207
R2416 VDD.n2023 VDD.t607 5.9207
R2417 VDD.n739 VDD.t1031 5.9207
R2418 VDD.n715 VDD.t1728 5.9207
R2419 VDD.n690 VDD.t1749 5.9207
R2420 VDD.n155 VDD.t93 5.9207
R2421 VDD.n1772 VDD.t251 5.9207
R2422 VDD.n1796 VDD.t405 5.9207
R2423 VDD.n1844 VDD.t564 5.9207
R2424 VDD.n1820 VDD.t702 5.9207
R2425 VDD.n664 VDD.t1714 5.9207
R2426 VDD.n181 VDD.t1035 5.9207
R2427 VDD.n1623 VDD.t1077 5.9207
R2428 VDD.n1647 VDD.t68 5.9207
R2429 VDD.n1744 VDD.t236 5.9207
R2430 VDD.n1720 VDD.t390 5.9207
R2431 VDD.n1695 VDD.t549 5.9207
R2432 VDD.n1671 VDD.t687 5.9207
R2433 VDD.n637 VDD.t819 5.9207
R2434 VDD.n207 VDD.t1135 5.9207
R2435 VDD.n1594 VDD.t886 5.9207
R2436 VDD.n1569 VDD.t52 5.9207
R2437 VDD.n1543 VDD.t221 5.9207
R2438 VDD.n1518 VDD.t375 5.9207
R2439 VDD.n257 VDD.t534 5.9207
R2440 VDD.n232 VDD.t672 5.9207
R2441 VDD.n611 VDD.t957 5.9207
R2442 VDD.n587 VDD.t970 5.9207
R2443 VDD.n562 VDD.t1022 5.9207
R2444 VDD.n283 VDD.t36 5.9207
R2445 VDD.n1418 VDD.t206 5.9207
R2446 VDD.n1442 VDD.t360 5.9207
R2447 VDD.n1490 VDD.t519 5.9207
R2448 VDD.n1466 VDD.t657 5.9207
R2449 VDD.n426 VDD.t1782 5.9207
R2450 VDD.n308 VDD.t750 5.9207
R2451 VDD.n1263 VDD.t920 5.9207
R2452 VDD.n1288 VDD.t27 5.9207
R2453 VDD.n1389 VDD.t178 5.9207
R2454 VDD.n1364 VDD.t345 5.9207
R2455 VDD.n1338 VDD.t504 5.9207
R2456 VDD.n1313 VDD.t642 5.9207
R2457 VDD.n1087 VDD.t1068 5.9207
R2458 VDD.n1112 VDD.t991 5.9207
R2459 VDD.n1235 VDD.t1698 5.9207
R2460 VDD.n1211 VDD.t774 5.9207
R2461 VDD.n1186 VDD.t176 5.9207
R2462 VDD.n1161 VDD.t330 5.9207
R2463 VDD.n1136 VDD.t489 5.9207
R2464 VDD.n43 VDD.t627 5.9207
R2465 VDD.n361 VDD.t1002 5.9207
R2466 VDD.n357 VDD.t1001 5.9207
R2467 VDD.n386 VDD.t1164 5.9207
R2468 VDD.n1060 VDD.t825 5.9207
R2469 VDD.n1036 VDD.t1084 5.9207
R2470 VDD.n1011 VDD.t959 5.9207
R2471 VDD.n987 VDD.t873 5.9207
R2472 VDD.n961 VDD.t131 5.9207
R2473 VDD.n18 VDD.t281 5.9207
R2474 VDD.n1968 VDD.t443 5.9207
R2475 VDD.n1944 VDD.t609 5.9207
R2476 VDD.t76 VDD.n364 5.66778
R2477 VDD.n376 VDD.t71 5.66778
R2478 VDD.n402 VDD.t77 5.66778
R2479 VDD.t76 VDD.n343 5.66767
R2480 VDD.t77 VDD.n395 5.66767
R2481 VDD.n2005 VDD.n1995 5.63343
R2482 VDD.n373 VDD.n372 5.62599
R2483 VDD.n2039 VDD.n2030 5.62352
R2484 VDD.n1 VDD.n0 5.61815
R2485 VDD.n2039 VDD.n2032 5.61485
R2486 VDD.n1925 VDD.n1924 4.88764
R2487 VDD.n1929 VDD.n1928 4.86486
R2488 VDD.n1927 VDD.n1926 4.86329
R2489 VDD.n1921 VDD.n1920 4.85307
R2490 VDD.n1940 VDD.n1939 4.84757
R2491 VDD.n1923 VDD.n1922 4.8405
R2492 VDD.n1919 VDD.n41 4.83186
R2493 VDD.n891 VDD.n890 4.5005
R2494 VDD.n472 VDD.n471 4.5005
R2495 VDD.n489 VDD.n488 4.5005
R2496 VDD.n504 VDD.n503 4.5005
R2497 VDD.n1921 VDD.n68 4.5005
R2498 VDD.n1919 VDD.n67 4.5005
R2499 VDD.n1939 VDD.n1938 4.5005
R2500 VDD.n1942 VDD.n1941 4.5005
R2501 VDD.n1923 VDD.n69 4.5005
R2502 VDD.n1925 VDD.n70 4.5005
R2503 VDD.n1927 VDD.n71 4.5005
R2504 VDD.n1930 VDD.n1929 4.5005
R2505 VDD.n2046 VDD.n14 4.50025
R2506 VDD.n112 VDD.n97 4.50025
R2507 VDD.n2089 VDD.n2083 4.50025
R2508 VDD.n131 VDD.n125 4.50025
R2509 VDD.n2048 VDD.n14 4.50025
R2510 VDD.n113 VDD.n112 4.50025
R2511 VDD.n2089 VDD.n2084 4.50025
R2512 VDD.n131 VDD.n126 4.50025
R2513 VDD.n2089 VDD.n2085 4.50025
R2514 VDD.n131 VDD.n127 4.50025
R2515 VDD.n2052 VDD.n14 4.50025
R2516 VDD.n117 VDD.n112 4.50025
R2517 VDD.n2089 VDD.n2086 4.50025
R2518 VDD.n131 VDD.n128 4.50025
R2519 VDD.n2054 VDD.n14 4.50025
R2520 VDD.n119 VDD.n112 4.50025
R2521 VDD.n2056 VDD.n14 4.50025
R2522 VDD.n121 VDD.n112 4.50025
R2523 VDD.n2089 VDD.n2088 4.50025
R2524 VDD.n131 VDD.n130 4.50025
R2525 VDD.n2058 VDD.n14 4.50025
R2526 VDD.n123 VDD.n112 4.50025
R2527 VDD.n2089 VDD.n2060 4.50025
R2528 VDD.n132 VDD.n131 4.50025
R2529 VDD.n531 VDD.n530 4.50025
R2530 VDD.n556 VDD.n551 4.50025
R2531 VDD.n944 VDD.n939 4.50025
R2532 VDD.n937 VDD.n936 4.50025
R2533 VDD.n538 VDD.n530 4.50025
R2534 VDD.n936 VDD.n933 4.50025
R2535 VDD.n556 VDD.n552 4.50025
R2536 VDD.n944 VDD.n940 4.50025
R2537 VDD.n556 VDD.n553 4.50025
R2538 VDD.n944 VDD.n941 4.50025
R2539 VDD.n542 VDD.n530 4.50025
R2540 VDD.n936 VDD.n931 4.50025
R2541 VDD.n556 VDD.n554 4.50025
R2542 VDD.n544 VDD.n530 4.50025
R2543 VDD.n936 VDD.n934 4.50025
R2544 VDD.n944 VDD.n938 4.50025
R2545 VDD.n546 VDD.n530 4.50025
R2546 VDD.n936 VDD.n930 4.50025
R2547 VDD.n556 VDD.n548 4.50025
R2548 VDD.n944 VDD.n912 4.50025
R2549 VDD.n549 VDD.n530 4.50025
R2550 VDD.n936 VDD.n913 4.50025
R2551 VDD.n556 VDD.n506 4.50025
R2552 VDD.n944 VDD.n943 4.50025
R2553 VDD.n2066 VDD.n2047 4.50013
R2554 VDD.n2069 VDD.n2047 4.50013
R2555 VDD.n2075 VDD.n2047 4.50013
R2556 VDD.n2078 VDD.n2047 4.50013
R2557 VDD.n2082 VDD.n2047 4.50013
R2558 VDD.n151 VDD.n103 4.50013
R2559 VDD.n151 VDD.n102 4.50013
R2560 VDD.n151 VDD.n100 4.50013
R2561 VDD.n151 VDD.n99 4.50013
R2562 VDD.n151 VDD.n98 4.50013
R2563 VDD.n2068 VDD.n13 4.50013
R2564 VDD.n2071 VDD.n13 4.50013
R2565 VDD.n2074 VDD.n13 4.50013
R2566 VDD.n2077 VDD.n13 4.50013
R2567 VDD.n138 VDD.n111 4.50013
R2568 VDD.n140 VDD.n111 4.50013
R2569 VDD.n142 VDD.n111 4.50013
R2570 VDD.n144 VDD.n111 4.50013
R2571 VDD.n2092 VDD.n2091 4.50013
R2572 VDD.n149 VDD.n148 4.50013
R2573 VDD.n537 VDD.n536 4.50013
R2574 VDD.n537 VDD.n535 4.50013
R2575 VDD.n537 VDD.n533 4.50013
R2576 VDD.n537 VDD.n532 4.50013
R2577 VDD.n550 VDD.n537 4.50013
R2578 VDD.n950 VDD.n906 4.50013
R2579 VDD.n950 VDD.n949 4.50013
R2580 VDD.n950 VDD.n947 4.50013
R2581 VDD.n950 VDD.n946 4.50013
R2582 VDD.n950 VDD.n945 4.50013
R2583 VDD.n529 VDD.n528 4.50013
R2584 VDD.n529 VDD.n527 4.50013
R2585 VDD.n529 VDD.n526 4.50013
R2586 VDD.n529 VDD.n525 4.50013
R2587 VDD.n919 VDD.n905 4.50013
R2588 VDD.n921 VDD.n905 4.50013
R2589 VDD.n923 VDD.n905 4.50013
R2590 VDD.n925 VDD.n905 4.50013
R2591 VDD.n560 VDD.n517 4.50013
R2592 VDD.n935 VDD.n423 4.50013
R2593 VDD.n2050 VDD.n14 4.49774
R2594 VDD.n115 VDD.n112 4.49774
R2595 VDD.n2089 VDD.n2087 4.49774
R2596 VDD.n131 VDD.n129 4.49774
R2597 VDD.n540 VDD.n530 4.49774
R2598 VDD.n936 VDD.n932 4.49774
R2599 VDD.n556 VDD.n555 4.49774
R2600 VDD.n944 VDD.n942 4.49774
R2601 VDD.n2072 VDD.n2047 4.49725
R2602 VDD.n151 VDD.n101 4.49725
R2603 VDD.n2080 VDD.n13 4.49725
R2604 VDD.n146 VDD.n111 4.49725
R2605 VDD.n537 VDD.n534 4.49725
R2606 VDD.n950 VDD.n948 4.49725
R2607 VDD.n529 VDD.n524 4.49725
R2608 VDD.n927 VDD.n905 4.49725
R2609 VDD.t1051 VDD.n768 4.20482
R2610 VDD.t732 VDD.n841 4.20482
R2611 VDD.t114 VDD.n817 4.20482
R2612 VDD.t272 VDD.n792 4.20482
R2613 VDD.t426 VDD.n75 4.20482
R2614 VDD.t587 VDD.n1873 4.20482
R2615 VDD.t723 VDD.n1897 4.20482
R2616 VDD.t981 VDD.n493 4.20482
R2617 VDD.t992 VDD.n477 4.20482
R2618 VDD.t1161 VDD.n460 4.20482
R2619 VDD.t802 VDD.n740 4.20482
R2620 VDD.t1062 VDD.n716 4.20482
R2621 VDD.t862 VDD.n691 4.20482
R2622 VDD.t99 VDD.n156 4.20482
R2623 VDD.t257 VDD.n1773 4.20482
R2624 VDD.t411 VDD.n1797 4.20482
R2625 VDD.t570 VDD.n1845 4.20482
R2626 VDD.t708 VDD.n1821 4.20482
R2627 VDD.t794 VDD.n665 4.20482
R2628 VDD.t898 VDD.n182 4.20482
R2629 VDD.t1222 VDD.n1624 4.20482
R2630 VDD.t83 VDD.n1648 4.20482
R2631 VDD.t242 VDD.n1745 4.20482
R2632 VDD.t396 VDD.n1721 4.20482
R2633 VDD.t555 VDD.n1696 4.20482
R2634 VDD.t693 VDD.n1672 4.20482
R2635 VDD.t989 VDD.n638 4.20482
R2636 VDD.t735 VDD.n208 4.20482
R2637 VDD.t982 VDD.n1595 4.20482
R2638 VDD.t58 VDD.n1570 4.20482
R2639 VDD.t227 VDD.n1544 4.20482
R2640 VDD.t381 VDD.n1519 4.20482
R2641 VDD.t540 VDD.n258 4.20482
R2642 VDD.t678 VDD.n233 4.20482
R2643 VDD.t994 VDD.n612 4.20482
R2644 VDD.t1216 VDD.n588 4.20482
R2645 VDD.t877 VDD.n563 4.20482
R2646 VDD.t42 VDD.n284 4.20482
R2647 VDD.t212 VDD.n1419 4.20482
R2648 VDD.t366 VDD.n1443 4.20482
R2649 VDD.t525 VDD.n1491 4.20482
R2650 VDD.t663 VDD.n1467 4.20482
R2651 VDD.t845 VDD.n427 4.20482
R2652 VDD.t764 VDD.n309 4.20482
R2653 VDD.t888 VDD.n1264 4.20482
R2654 VDD.t1126 VDD.n1289 4.20482
R2655 VDD.t199 VDD.n1390 4.20482
R2656 VDD.t351 VDD.n1365 4.20482
R2657 VDD.t510 VDD.n1339 4.20482
R2658 VDD.t648 VDD.n1314 4.20482
R2659 VDD.t763 VDD.n1088 4.20482
R2660 VDD.t1056 VDD.n1113 4.20482
R2661 VDD.t1220 VDD.n1236 4.20482
R2662 VDD.t18 VDD.n1212 4.20482
R2663 VDD.t186 VDD.n1187 4.20482
R2664 VDD.t336 VDD.n1162 4.20482
R2665 VDD.t495 VDD.n1137 4.20482
R2666 VDD.t633 VDD.n44 4.20482
R2667 VDD.t1023 VDD.n1061 4.20482
R2668 VDD.t753 VDD.n1037 4.20482
R2669 VDD.t962 VDD.n1012 4.20482
R2670 VDD.t766 VDD.n988 4.20482
R2671 VDD.t167 VDD.n962 4.20482
R2672 VDD.t321 VDD.n19 4.20482
R2673 VDD.t480 VDD.n1969 4.20482
R2674 VDD.t618 VDD.n1945 4.20482
R2675 VDD.t998 VDD.n878 4.20482
R2676 VDD.t1051 VDD.n769 4.17719
R2677 VDD.t732 VDD.n842 4.17719
R2678 VDD.t114 VDD.n818 4.17719
R2679 VDD.t272 VDD.n793 4.17719
R2680 VDD.t426 VDD.n76 4.17719
R2681 VDD.t587 VDD.n1874 4.17719
R2682 VDD.t723 VDD.n1898 4.17719
R2683 VDD.n502 VDD.t981 4.17719
R2684 VDD.n889 VDD.t998 4.17719
R2685 VDD.t802 VDD.n741 4.17719
R2686 VDD.t1062 VDD.n717 4.17719
R2687 VDD.t862 VDD.n692 4.17719
R2688 VDD.t99 VDD.n157 4.17719
R2689 VDD.t257 VDD.n1774 4.17719
R2690 VDD.t411 VDD.n1798 4.17719
R2691 VDD.t570 VDD.n1846 4.17719
R2692 VDD.t708 VDD.n1822 4.17719
R2693 VDD.t794 VDD.n666 4.17719
R2694 VDD.t898 VDD.n183 4.17719
R2695 VDD.t1222 VDD.n1625 4.17719
R2696 VDD.t83 VDD.n1649 4.17719
R2697 VDD.t242 VDD.n1746 4.17719
R2698 VDD.t396 VDD.n1722 4.17719
R2699 VDD.t555 VDD.n1697 4.17719
R2700 VDD.t693 VDD.n1673 4.17719
R2701 VDD.t989 VDD.n639 4.17719
R2702 VDD.t735 VDD.n209 4.17719
R2703 VDD.t982 VDD.n1596 4.17719
R2704 VDD.t58 VDD.n1571 4.17719
R2705 VDD.t227 VDD.n1545 4.17719
R2706 VDD.t381 VDD.n1520 4.17719
R2707 VDD.t540 VDD.n259 4.17719
R2708 VDD.t678 VDD.n234 4.17719
R2709 VDD.t994 VDD.n613 4.17719
R2710 VDD.t1216 VDD.n589 4.17719
R2711 VDD.t877 VDD.n564 4.17719
R2712 VDD.t42 VDD.n285 4.17719
R2713 VDD.t212 VDD.n1420 4.17719
R2714 VDD.t366 VDD.n1444 4.17719
R2715 VDD.t525 VDD.n1492 4.17719
R2716 VDD.t663 VDD.n1468 4.17719
R2717 VDD.t845 VDD.n428 4.17719
R2718 VDD.t764 VDD.n310 4.17719
R2719 VDD.t888 VDD.n1265 4.17719
R2720 VDD.t1126 VDD.n1290 4.17719
R2721 VDD.t199 VDD.n1391 4.17719
R2722 VDD.t351 VDD.n1366 4.17719
R2723 VDD.t510 VDD.n1340 4.17719
R2724 VDD.t648 VDD.n1315 4.17719
R2725 VDD.t763 VDD.n1089 4.17719
R2726 VDD.t1056 VDD.n1114 4.17719
R2727 VDD.t1220 VDD.n1237 4.17719
R2728 VDD.t18 VDD.n1213 4.17719
R2729 VDD.t186 VDD.n1188 4.17719
R2730 VDD.t336 VDD.n1163 4.17719
R2731 VDD.t495 VDD.n1138 4.17719
R2732 VDD.t633 VDD.n45 4.17719
R2733 VDD.t1023 VDD.n1062 4.17719
R2734 VDD.t753 VDD.n1038 4.17719
R2735 VDD.t962 VDD.n1013 4.17719
R2736 VDD.t766 VDD.n989 4.17719
R2737 VDD.t167 VDD.n963 4.17719
R2738 VDD.t321 VDD.n20 4.17719
R2739 VDD.t480 VDD.n1970 4.17719
R2740 VDD.t618 VDD.n1946 4.17719
R2741 VDD.n892 VDD.n891 3.56857
R2742 VDD.t1051 VDD.n777 3.40682
R2743 VDD.t732 VDD.n850 3.40682
R2744 VDD.t114 VDD.n826 3.40682
R2745 VDD.t272 VDD.n801 3.40682
R2746 VDD.t426 VDD.n84 3.40682
R2747 VDD.t587 VDD.n1882 3.40682
R2748 VDD.t723 VDD.n1906 3.40682
R2749 VDD.t802 VDD.n749 3.40682
R2750 VDD.t1062 VDD.n725 3.40682
R2751 VDD.t862 VDD.n700 3.40682
R2752 VDD.t99 VDD.n165 3.40682
R2753 VDD.t257 VDD.n1782 3.40682
R2754 VDD.t411 VDD.n1806 3.40682
R2755 VDD.t570 VDD.n1854 3.40682
R2756 VDD.t708 VDD.n1830 3.40682
R2757 VDD.t794 VDD.n673 3.40682
R2758 VDD.t898 VDD.n190 3.40682
R2759 VDD.t1222 VDD.n1632 3.40682
R2760 VDD.t83 VDD.n1656 3.40682
R2761 VDD.t242 VDD.n1753 3.40682
R2762 VDD.t396 VDD.n1729 3.40682
R2763 VDD.t555 VDD.n1704 3.40682
R2764 VDD.t693 VDD.n1680 3.40682
R2765 VDD.t989 VDD.n648 3.40682
R2766 VDD.t735 VDD.n218 3.40682
R2767 VDD.t982 VDD.n1605 3.40682
R2768 VDD.t58 VDD.n1580 3.40682
R2769 VDD.t227 VDD.n1554 3.40682
R2770 VDD.t381 VDD.n1529 3.40682
R2771 VDD.t540 VDD.n268 3.40682
R2772 VDD.t678 VDD.n243 3.40682
R2773 VDD.t994 VDD.n621 3.40682
R2774 VDD.t1216 VDD.n597 3.40682
R2775 VDD.t877 VDD.n572 3.40682
R2776 VDD.t42 VDD.n293 3.40682
R2777 VDD.t212 VDD.n1428 3.40682
R2778 VDD.t366 VDD.n1452 3.40682
R2779 VDD.t525 VDD.n1500 3.40682
R2780 VDD.t663 VDD.n1476 3.40682
R2781 VDD.t845 VDD.n437 3.40682
R2782 VDD.t764 VDD.n319 3.40682
R2783 VDD.t888 VDD.n1274 3.40682
R2784 VDD.t1126 VDD.n1299 3.40682
R2785 VDD.t199 VDD.n1400 3.40682
R2786 VDD.t351 VDD.n1375 3.40682
R2787 VDD.t510 VDD.n1349 3.40682
R2788 VDD.t648 VDD.n1324 3.40682
R2789 VDD.t763 VDD.n1098 3.40682
R2790 VDD.t1056 VDD.n1122 3.40682
R2791 VDD.t1220 VDD.n1245 3.40682
R2792 VDD.t18 VDD.n1221 3.40682
R2793 VDD.t186 VDD.n1196 3.40682
R2794 VDD.t336 VDD.n1172 3.40682
R2795 VDD.t495 VDD.n1146 3.40682
R2796 VDD.t633 VDD.n54 3.40682
R2797 VDD.t1023 VDD.n1070 3.40682
R2798 VDD.t753 VDD.n1046 3.40682
R2799 VDD.t962 VDD.n1021 3.40682
R2800 VDD.t766 VDD.n997 3.40682
R2801 VDD.t167 VDD.n971 3.40682
R2802 VDD.t321 VDD.n28 3.40682
R2803 VDD.t480 VDD.n1978 3.40682
R2804 VDD.t618 VDD.n1954 3.40682
R2805 VDD.n1 VDD.t610 3.4005
R2806 VDD.n334 VDD.t73 3.4005
R2807 VDD.t992 VDD.n481 3.30723
R2808 VDD.t1161 VDD.n464 3.30723
R2809 VDD.n875 VDD.n874 3.0005
R2810 VDD VDD.n2094 2.47232
R2811 VDD.n2044 VDD.n2043 2.2505
R2812 VDD.t71 VDD.n375 1.88989
R2813 VDD.n957 VDD.n956 1.85322
R2814 VDD.n896 VDD.n453 1.81594
R2815 VDD.n955 VDD.n954 1.81271
R2816 VDD.n897 VDD.n452 1.80978
R2817 VDD.n898 VDD.n451 1.80773
R2818 VDD.n894 VDD.n455 1.80685
R2819 VDD.n893 VDD.n456 1.80685
R2820 VDD.n895 VDD.n454 1.80069
R2821 VDD.n687 VDD.n454 1.76666
R2822 VDD.n765 VDD.n456 1.7605
R2823 VDD.n451 VDD.n450 1.75786
R2824 VDD.n762 VDD.n455 1.75287
R2825 VDD.n661 VDD.n453 1.75141
R2826 VDD.n634 VDD.n452 1.74994
R2827 VDD.n1935 VDD.n68 1.51234
R2828 VDD.n1936 VDD.n67 1.51234
R2829 VDD.n1938 VDD.n1937 1.51234
R2830 VDD.n1942 VDD.n6 1.51234
R2831 VDD.n1933 VDD.n70 1.51234
R2832 VDD.n1932 VDD.n71 1.51234
R2833 VDD.n1931 VDD.n1930 1.51234
R2834 VDD.n1934 VDD.n69 1.51205
R2835 VDD.n867 VDD.n764 1.43838
R2836 VDD.n866 VDD.n864 1.43779
R2837 VDD.n865 VDD.n178 1.43779
R2838 VDD.n1869 VDD.n152 1.43779
R2839 VDD.n2005 VDD.t434 1.41717
R2840 VDD.n2039 VDD.t286 1.41717
R2841 VDD.n2024 VDD.t597 1.41717
R2842 VDD.n421 VDD.n420 1.27308
R2843 VDD.n874 VDD.n868 1.22045
R2844 VDD.n1085 VDD.n421 1.20727
R2845 VDD.n1083 VDD.n1082 1.15186
R2846 VDD.n1083 VDD.n959 1.08556
R2847 VDD.n958 VDD.n332 1.08556
R2848 VDD.n984 VDD.n15 1.08402
R2849 VDD.n662 VDD.n661 1.0005
R2850 VDD.n635 VDD.n634 1.0005
R2851 VDD.n450 VDD.n422 1.0005
R2852 VDD.n1085 VDD.n1084 1.0005
R2853 VDD.n688 VDD.n687 1.0005
R2854 VDD.n1621 VDD.n1620 1.0005
R2855 VDD.n1619 VDD.n1618 1.0005
R2856 VDD.n585 VDD.n205 1.0005
R2857 VDD.n1261 VDD.n1260 1.0005
R2858 VDD.n1259 VDD.n1258 1.0005
R2859 VDD.n1034 VDD.n332 1.0005
R2860 VDD.n713 VDD.n204 1.0005
R2861 VDD.n763 VDD.n762 1.0005
R2862 VDD.n1770 VDD.n1769 1.0005
R2863 VDD.n1768 VDD.n1767 1.0005
R2864 VDD.n1567 VDD.n179 1.0005
R2865 VDD.n1416 VDD.n1415 1.0005
R2866 VDD.n1414 VDD.n1413 1.0005
R2867 VDD.n1209 VDD.n306 1.0005
R2868 VDD.n985 VDD.n984 1.0005
R2869 VDD.n872 VDD.n455 1.0005
R2870 VDD.n871 VDD.n454 1.0005
R2871 VDD.n870 VDD.n453 1.0005
R2872 VDD.n869 VDD.n452 1.0005
R2873 VDD.n451 VDD.n424 1.0005
R2874 VDD.n956 VDD.n955 1.0005
R2875 VDD.n1868 VDD.n1867 1.0005
R2876 VDD.n1718 VDD.n153 1.0005
R2877 VDD.n1516 VDD.n1515 1.0005
R2878 VDD.n1514 VDD.n1513 1.0005
R2879 VDD.n1362 VDD.n281 1.0005
R2880 VDD.n1159 VDD.n16 1.0005
R2881 VDD.n1992 VDD.n1991 1.0005
R2882 VDD.n873 VDD.n456 1.0005
R2883 VDD.n765 VDD.n764 1.0005
R2884 VDD.n864 VDD.n863 1.0005
R2885 VDD.n814 VDD.n178 1.0005
R2886 VDD.n1870 VDD.n1869 1.0005
R2887 VDD.n789 VDD.n765 0.970847
R2888 VDD.t992 VDD.n475 0.884415
R2889 VDD.t1161 VDD.n458 0.884415
R2890 VDD.n885 VDD.n883 0.854038
R2891 VDD.n782 VDD.n781 0.846432
R2892 VDD.n855 VDD.n854 0.846432
R2893 VDD.n831 VDD.n830 0.846432
R2894 VDD.n806 VDD.n805 0.846432
R2895 VDD.n89 VDD.n88 0.846432
R2896 VDD.n1887 VDD.n1886 0.846432
R2897 VDD.n1911 VDD.n1910 0.846432
R2898 VDD.n497 VDD.n496 0.846432
R2899 VDD.n754 VDD.n753 0.846432
R2900 VDD.n730 VDD.n729 0.846432
R2901 VDD.n705 VDD.n704 0.846432
R2902 VDD.n170 VDD.n169 0.846432
R2903 VDD.n1787 VDD.n1786 0.846432
R2904 VDD.n1811 VDD.n1810 0.846432
R2905 VDD.n1859 VDD.n1858 0.846432
R2906 VDD.n1835 VDD.n1834 0.846432
R2907 VDD.n678 VDD.n677 0.846432
R2908 VDD.n195 VDD.n194 0.846432
R2909 VDD.n1637 VDD.n1636 0.846432
R2910 VDD.n1661 VDD.n1660 0.846432
R2911 VDD.n1758 VDD.n1757 0.846432
R2912 VDD.n1734 VDD.n1733 0.846432
R2913 VDD.n1709 VDD.n1708 0.846432
R2914 VDD.n1685 VDD.n1684 0.846432
R2915 VDD.n653 VDD.n652 0.846432
R2916 VDD.n223 VDD.n222 0.846432
R2917 VDD.n1610 VDD.n1609 0.846432
R2918 VDD.n1585 VDD.n1584 0.846432
R2919 VDD.n1559 VDD.n1558 0.846432
R2920 VDD.n1534 VDD.n1533 0.846432
R2921 VDD.n273 VDD.n272 0.846432
R2922 VDD.n248 VDD.n247 0.846432
R2923 VDD.n626 VDD.n625 0.846432
R2924 VDD.n602 VDD.n601 0.846432
R2925 VDD.n577 VDD.n576 0.846432
R2926 VDD.n298 VDD.n297 0.846432
R2927 VDD.n1433 VDD.n1432 0.846432
R2928 VDD.n1457 VDD.n1456 0.846432
R2929 VDD.n1505 VDD.n1504 0.846432
R2930 VDD.n1481 VDD.n1480 0.846432
R2931 VDD.n442 VDD.n441 0.846432
R2932 VDD.n324 VDD.n323 0.846432
R2933 VDD.n1279 VDD.n1278 0.846432
R2934 VDD.n1304 VDD.n1303 0.846432
R2935 VDD.n1405 VDD.n1404 0.846432
R2936 VDD.n1380 VDD.n1379 0.846432
R2937 VDD.n1354 VDD.n1353 0.846432
R2938 VDD.n1329 VDD.n1328 0.846432
R2939 VDD.n1103 VDD.n1102 0.846432
R2940 VDD.n1127 VDD.n1126 0.846432
R2941 VDD.n1250 VDD.n1249 0.846432
R2942 VDD.n1226 VDD.n1225 0.846432
R2943 VDD.n1201 VDD.n1200 0.846432
R2944 VDD.n1177 VDD.n1176 0.846432
R2945 VDD.n1151 VDD.n1150 0.846432
R2946 VDD.n59 VDD.n58 0.846432
R2947 VDD.n1075 VDD.n1074 0.846432
R2948 VDD.n1051 VDD.n1050 0.846432
R2949 VDD.n1026 VDD.n1025 0.846432
R2950 VDD.n1002 VDD.n1001 0.846432
R2951 VDD.n976 VDD.n975 0.846432
R2952 VDD.n33 VDD.n32 0.846432
R2953 VDD.n1983 VDD.n1982 0.846432
R2954 VDD.n1959 VDD.n1958 0.846432
R2955 VDD.n488 VDD.n475 0.829209
R2956 VDD.n471 VDD.n458 0.829209
R2957 VDD.n686 VDD.n203 0.822127
R2958 VDD.n862 VDD.n838 0.822127
R2959 VDD.n633 VDD.n609 0.821833
R2960 VDD.n584 VDD.n305 0.821833
R2961 VDD.n1464 VDD.n1440 0.821833
R2962 VDD.n1512 VDD.n1488 0.821833
R2963 VDD.n449 VDD.n331 0.821833
R2964 VDD.n1311 VDD.n1286 0.821833
R2965 VDD.n1412 VDD.n1387 0.821833
R2966 VDD.n1361 VDD.n1336 0.821833
R2967 VDD.n1134 VDD.n1110 0.821833
R2968 VDD.n1257 VDD.n1233 0.821833
R2969 VDD.n1208 VDD.n1184 0.821833
R2970 VDD.n1158 VDD.n66 0.821833
R2971 VDD.n1082 VDD.n1058 0.821833
R2972 VDD.n1033 VDD.n1009 0.821833
R2973 VDD.n983 VDD.n40 0.821833
R2974 VDD.n1990 VDD.n1966 0.821833
R2975 VDD.n660 VDD.n230 0.821833
R2976 VDD.n1617 VDD.n1592 0.821833
R2977 VDD.n1566 VDD.n1541 0.821833
R2978 VDD.n280 VDD.n255 0.821833
R2979 VDD.n1669 VDD.n1645 0.821833
R2980 VDD.n1766 VDD.n1742 0.821833
R2981 VDD.n1717 VDD.n1693 0.821833
R2982 VDD.n761 VDD.n737 0.821833
R2983 VDD.n712 VDD.n177 0.821833
R2984 VDD.n1818 VDD.n1794 0.821833
R2985 VDD.n1866 VDD.n1842 0.821833
R2986 VDD.n813 VDD.n96 0.821833
R2987 VDD.n1918 VDD.n1894 0.821833
R2988 VDD.n781 VDD.n780 0.811538
R2989 VDD.n854 VDD.n853 0.811538
R2990 VDD.n830 VDD.n829 0.811538
R2991 VDD.n805 VDD.n804 0.811538
R2992 VDD.n88 VDD.n87 0.811538
R2993 VDD.n1886 VDD.n1885 0.811538
R2994 VDD.n1910 VDD.n1909 0.811538
R2995 VDD.n496 VDD.n495 0.811538
R2996 VDD.n753 VDD.n752 0.811538
R2997 VDD.n729 VDD.n728 0.811538
R2998 VDD.n704 VDD.n703 0.811538
R2999 VDD.n169 VDD.n168 0.811538
R3000 VDD.n1786 VDD.n1785 0.811538
R3001 VDD.n1810 VDD.n1809 0.811538
R3002 VDD.n1858 VDD.n1857 0.811538
R3003 VDD.n1834 VDD.n1833 0.811538
R3004 VDD.n677 VDD.n676 0.811538
R3005 VDD.n194 VDD.n193 0.811538
R3006 VDD.n1636 VDD.n1635 0.811538
R3007 VDD.n1660 VDD.n1659 0.811538
R3008 VDD.n1757 VDD.n1756 0.811538
R3009 VDD.n1733 VDD.n1732 0.811538
R3010 VDD.n1708 VDD.n1707 0.811538
R3011 VDD.n1684 VDD.n1683 0.811538
R3012 VDD.n652 VDD.n651 0.811538
R3013 VDD.n222 VDD.n221 0.811538
R3014 VDD.n1609 VDD.n1608 0.811538
R3015 VDD.n1584 VDD.n1583 0.811538
R3016 VDD.n1558 VDD.n1557 0.811538
R3017 VDD.n1533 VDD.n1532 0.811538
R3018 VDD.n272 VDD.n271 0.811538
R3019 VDD.n247 VDD.n246 0.811538
R3020 VDD.n625 VDD.n624 0.811538
R3021 VDD.n601 VDD.n600 0.811538
R3022 VDD.n576 VDD.n575 0.811538
R3023 VDD.n297 VDD.n296 0.811538
R3024 VDD.n1432 VDD.n1431 0.811538
R3025 VDD.n1456 VDD.n1455 0.811538
R3026 VDD.n1504 VDD.n1503 0.811538
R3027 VDD.n1480 VDD.n1479 0.811538
R3028 VDD.n441 VDD.n440 0.811538
R3029 VDD.n323 VDD.n322 0.811538
R3030 VDD.n1278 VDD.n1277 0.811538
R3031 VDD.n1303 VDD.n1302 0.811538
R3032 VDD.n1404 VDD.n1403 0.811538
R3033 VDD.n1379 VDD.n1378 0.811538
R3034 VDD.n1353 VDD.n1352 0.811538
R3035 VDD.n1328 VDD.n1327 0.811538
R3036 VDD.n1102 VDD.n1101 0.811538
R3037 VDD.n1126 VDD.n1125 0.811538
R3038 VDD.n1249 VDD.n1248 0.811538
R3039 VDD.n1225 VDD.n1224 0.811538
R3040 VDD.n1200 VDD.n1199 0.811538
R3041 VDD.n1176 VDD.n1175 0.811538
R3042 VDD.n1150 VDD.n1149 0.811538
R3043 VDD.n58 VDD.n57 0.811538
R3044 VDD.n1074 VDD.n1073 0.811538
R3045 VDD.n1050 VDD.n1049 0.811538
R3046 VDD.n1025 VDD.n1024 0.811538
R3047 VDD.n1001 VDD.n1000 0.811538
R3048 VDD.n975 VDD.n974 0.811538
R3049 VDD.n32 VDD.n31 0.811538
R3050 VDD.n1982 VDD.n1981 0.811538
R3051 VDD.n1958 VDD.n1957 0.811538
R3052 VDD.n482 VDD.n475 0.806015
R3053 VDD.n465 VDD.n458 0.806015
R3054 VDD.n885 VDD.n884 0.803932
R3055 VDD.t1051 VDD.n781 0.802654
R3056 VDD.t732 VDD.n854 0.802654
R3057 VDD.t114 VDD.n830 0.802654
R3058 VDD.t272 VDD.n805 0.802654
R3059 VDD.t426 VDD.n88 0.802654
R3060 VDD.t587 VDD.n1886 0.802654
R3061 VDD.t723 VDD.n1910 0.802654
R3062 VDD.t981 VDD.n496 0.802654
R3063 VDD.t998 VDD.n885 0.802654
R3064 VDD.t802 VDD.n753 0.802654
R3065 VDD.t1062 VDD.n729 0.802654
R3066 VDD.t862 VDD.n704 0.802654
R3067 VDD.t99 VDD.n169 0.802654
R3068 VDD.t257 VDD.n1786 0.802654
R3069 VDD.t411 VDD.n1810 0.802654
R3070 VDD.t570 VDD.n1858 0.802654
R3071 VDD.t708 VDD.n1834 0.802654
R3072 VDD.t794 VDD.n677 0.802654
R3073 VDD.t898 VDD.n194 0.802654
R3074 VDD.t1222 VDD.n1636 0.802654
R3075 VDD.t83 VDD.n1660 0.802654
R3076 VDD.t242 VDD.n1757 0.802654
R3077 VDD.t396 VDD.n1733 0.802654
R3078 VDD.t555 VDD.n1708 0.802654
R3079 VDD.t693 VDD.n1684 0.802654
R3080 VDD.t989 VDD.n652 0.802654
R3081 VDD.t735 VDD.n222 0.802654
R3082 VDD.t982 VDD.n1609 0.802654
R3083 VDD.t58 VDD.n1584 0.802654
R3084 VDD.t227 VDD.n1558 0.802654
R3085 VDD.t381 VDD.n1533 0.802654
R3086 VDD.t540 VDD.n272 0.802654
R3087 VDD.t678 VDD.n247 0.802654
R3088 VDD.t994 VDD.n625 0.802654
R3089 VDD.t1216 VDD.n601 0.802654
R3090 VDD.t877 VDD.n576 0.802654
R3091 VDD.t42 VDD.n297 0.802654
R3092 VDD.t212 VDD.n1432 0.802654
R3093 VDD.t366 VDD.n1456 0.802654
R3094 VDD.t525 VDD.n1504 0.802654
R3095 VDD.t663 VDD.n1480 0.802654
R3096 VDD.t845 VDD.n441 0.802654
R3097 VDD.t764 VDD.n323 0.802654
R3098 VDD.t888 VDD.n1278 0.802654
R3099 VDD.t1126 VDD.n1303 0.802654
R3100 VDD.t199 VDD.n1404 0.802654
R3101 VDD.t351 VDD.n1379 0.802654
R3102 VDD.t510 VDD.n1353 0.802654
R3103 VDD.t648 VDD.n1328 0.802654
R3104 VDD.t763 VDD.n1102 0.802654
R3105 VDD.t1056 VDD.n1126 0.802654
R3106 VDD.t1220 VDD.n1249 0.802654
R3107 VDD.t18 VDD.n1225 0.802654
R3108 VDD.t186 VDD.n1200 0.802654
R3109 VDD.t336 VDD.n1176 0.802654
R3110 VDD.t495 VDD.n1150 0.802654
R3111 VDD.t633 VDD.n58 0.802654
R3112 VDD.t1023 VDD.n1074 0.802654
R3113 VDD.t753 VDD.n1050 0.802654
R3114 VDD.t962 VDD.n1025 0.802654
R3115 VDD.t766 VDD.n1001 0.802654
R3116 VDD.t167 VDD.n975 0.802654
R3117 VDD.t321 VDD.n32 0.802654
R3118 VDD.t480 VDD.n1982 0.802654
R3119 VDD.t618 VDD.n1958 0.802654
R3120 VDD.n1620 VDD.n1619 0.779743
R3121 VDD.n1768 VDD.n179 0.779743
R3122 VDD.n688 VDD.n662 0.778207
R3123 VDD.n871 VDD.n870 0.776672
R3124 VDD.n869 VDD.n424 0.775609
R3125 VDD.n1260 VDD.n205 0.775136
R3126 VDD.n1515 VDD.n153 0.775136
R3127 VDD.n635 VDD.n422 0.774664
R3128 VDD.n1415 VDD.n1414 0.772892
R3129 VDD.n1869 VDD.n1868 0.772892
R3130 VDD.n1514 VDD.n281 0.772892
R3131 VDD.n764 VDD.n763 0.772065
R3132 VDD.n864 VDD.n204 0.770648
R3133 VDD.n1769 VDD.n178 0.770648
R3134 VDD.n1515 VDD.n1514 0.770648
R3135 VDD.n873 VDD.n872 0.770411
R3136 VDD.n1992 VDD.n16 0.769939
R3137 VDD.n1084 VDD.n1083 0.769821
R3138 VDD.n872 VDD.n871 0.769348
R3139 VDD.n984 VDD.n306 0.76923
R3140 VDD.n1260 VDD.n1259 0.768403
R3141 VDD.n1414 VDD.n306 0.768403
R3142 VDD.n1620 VDD.n204 0.768285
R3143 VDD.n1769 VDD.n1768 0.768285
R3144 VDD.n1415 VDD.n179 0.768285
R3145 VDD.n1868 VDD.n153 0.768285
R3146 VDD.n662 VDD.n635 0.768167
R3147 VDD.n870 VDD.n869 0.767931
R3148 VDD.n1259 VDD.n332 0.767695
R3149 VDD.n1084 VDD.n422 0.76734
R3150 VDD.n956 VDD.n424 0.76734
R3151 VDD.n281 VDD.n16 0.766159
R3152 VDD.n1619 VDD.n205 0.766041
R3153 VDD.n763 VDD.n688 0.765096
R3154 VDD.n392 VDD.n371 0.740189
R3155 VDD.n2042 VDD.n2027 0.740189
R3156 VDD.n371 VDD.n339 0.7397
R3157 VDD.n2027 VDD.n5 0.7397
R3158 VDD.n420 VDD.n392 0.739211
R3159 VDD.n1941 VDD 0.723357
R3160 VDD.n1618 VDD.n230 0.687487
R3161 VDD.n1387 VDD.n1362 0.677513
R3162 VDD.n2043 VDD.n2042 0.677122
R3163 VDD.n1767 VDD.n1669 0.676633
R3164 VDD.n609 VDD.n585 0.676047
R3165 VDD.n1009 VDD.n985 0.675167
R3166 VDD.n1991 VDD.n40 0.673407
R3167 VDD.n1058 VDD.n1034 0.67282
R3168 VDD.n1867 VDD.n1818 0.671647
R3169 VDD.n1261 VDD.n331 0.670473
R3170 VDD.n1621 VDD.n203 0.670473
R3171 VDD.n863 VDD.n789 0.670473
R3172 VDD.n1184 VDD.n1159 0.666073
R3173 VDD.n1413 VDD.n1311 0.665487
R3174 VDD.n1233 VDD.n1209 0.665487
R3175 VDD.n838 VDD.n814 0.665193
R3176 VDD.n1258 VDD.n1134 0.6649
R3177 VDD.n1513 VDD.n1464 0.6605
R3178 VDD.n1541 VDD.n1516 0.6605
R3179 VDD.n1742 VDD.n1718 0.6605
R3180 VDD.n1770 VDD.n177 0.659913
R3181 VDD.n1870 VDD.n96 0.654927
R3182 VDD.n1416 VDD.n305 0.65434
R3183 VDD.n1592 VDD.n1567 0.65434
R3184 VDD.n737 VDD.n713 0.64818
R3185 VDD.n2045 VDD.n2044 0.619925
R3186 VDD.n954 VDD.n953 0.58161
R3187 VDD.t981 VDD.t13 0.567167
R3188 VDD.t992 VDD.t813 0.567167
R3189 VDD.t1161 VDD.t760 0.567167
R3190 VDD.t998 VDD.t14 0.567167
R3191 VDD.n955 VDD.n421 0.53906
R3192 VDD.n504 VDD.n489 0.480051
R3193 VDD.n2044 VDD.n1992 0.466132
R3194 VDD.n1931 VDD.n72 0.455251
R3195 VDD.t1051 VDD.t905 0.405262
R3196 VDD.t732 VDD.t3 0.405262
R3197 VDD.t114 VDD.t1 0.405262
R3198 VDD.t272 VDD.t2 0.405262
R3199 VDD.t426 VDD.t0 0.405262
R3200 VDD.t587 VDD.t293 0.405262
R3201 VDD.t723 VDD.t4 0.405262
R3202 VDD.t802 VDD.t801 0.405262
R3203 VDD.t1062 VDD.t812 0.405262
R3204 VDD.t862 VDD.t810 0.405262
R3205 VDD.t99 VDD.t91 0.405262
R3206 VDD.t257 VDD.t147 0.405262
R3207 VDD.t411 VDD.t125 0.405262
R3208 VDD.t570 VDD.t282 0.405262
R3209 VDD.t708 VDD.t448 0.405262
R3210 VDD.t794 VDD.t793 0.405262
R3211 VDD.t898 VDD.t893 0.405262
R3212 VDD.t1222 VDD.t846 0.405262
R3213 VDD.t83 VDD.t66 0.405262
R3214 VDD.t242 VDD.t150 0.405262
R3215 VDD.t396 VDD.t135 0.405262
R3216 VDD.t555 VDD.t290 0.405262
R3217 VDD.t693 VDD.t454 0.405262
R3218 VDD.t989 VDD.t9 0.405262
R3219 VDD.t735 VDD.t733 0.405262
R3220 VDD.t982 VDD.t884 0.405262
R3221 VDD.t58 VDD.t50 0.405262
R3222 VDD.t227 VDD.t153 0.405262
R3223 VDD.t381 VDD.t137 0.405262
R3224 VDD.t540 VDD.t295 0.405262
R3225 VDD.t678 VDD.t456 0.405262
R3226 VDD.t994 VDD.t11 0.405262
R3227 VDD.t1216 VDD.t737 0.405262
R3228 VDD.t877 VDD.t736 0.405262
R3229 VDD.t42 VDD.t34 0.405262
R3230 VDD.t212 VDD.t156 0.405262
R3231 VDD.t366 VDD.t139 0.405262
R3232 VDD.t525 VDD.t297 0.405262
R3233 VDD.t663 VDD.t458 0.405262
R3234 VDD.t845 VDD.t7 0.405262
R3235 VDD.t764 VDD.t748 0.405262
R3236 VDD.t888 VDD.t887 0.405262
R3237 VDD.t1126 VDD.t25 0.405262
R3238 VDD.t199 VDD.t159 0.405262
R3239 VDD.t351 VDD.t127 0.405262
R3240 VDD.t510 VDD.t299 0.405262
R3241 VDD.t648 VDD.t444 0.405262
R3242 VDD.t763 VDD.t762 0.405262
R3243 VDD.t1056 VDD.t741 0.405262
R3244 VDD.t1220 VDD.t912 0.405262
R3245 VDD.t18 VDD.t17 0.405262
R3246 VDD.t186 VDD.t162 0.405262
R3247 VDD.t336 VDD.t141 0.405262
R3248 VDD.t495 VDD.t301 0.405262
R3249 VDD.t633 VDD.t460 0.405262
R3250 VDD.t1023 VDD.t5 0.405262
R3251 VDD.t753 VDD.t752 0.405262
R3252 VDD.t962 VDD.t817 0.405262
R3253 VDD.t766 VDD.t765 0.405262
R3254 VDD.t167 VDD.t122 0.405262
R3255 VDD.t321 VDD.t143 0.405262
R3256 VDD.t480 VDD.t303 0.405262
R3257 VDD.t618 VDD.t462 0.405262
R3258 VDD.n472 VDD 0.396006
R3259 VDD.n892 VDD.n457 0.389663
R3260 VDD.n474 VDD.n473 0.373264
R3261 VDD.n481 VDD.n476 0.335195
R3262 VDD.n464 VDD.n459 0.335195
R3263 VDD.n255 VDD.n69 0.335193
R3264 VDD.n1488 VDD.n68 0.3349
R3265 VDD.n1336 VDD.n67 0.3349
R3266 VDD.n1938 VDD.n66 0.3349
R3267 VDD.n1966 VDD.n1942 0.3349
R3268 VDD.n1693 VDD.n70 0.3349
R3269 VDD.n1842 VDD.n71 0.3349
R3270 VDD.n1930 VDD.n1918 0.3349
R3271 VDD.n481 VDD.n480 0.333933
R3272 VDD.n464 VDD.n463 0.333933
R3273 VDD.n152 VDD.n151 0.308829
R3274 VDD.n2047 VDD.n2045 0.307951
R3275 VDD.n1920 VDD.n1919 0.292
R3276 VDD.n1924 VDD.n1923 0.283357
R3277 VDD.n1939 VDD.n41 0.276286
R3278 VDD.n771 VDD.n769 0.27528
R3279 VDD.n844 VDD.n842 0.27528
R3280 VDD.n820 VDD.n818 0.27528
R3281 VDD.n795 VDD.n793 0.27528
R3282 VDD.n78 VDD.n76 0.27528
R3283 VDD.n1876 VDD.n1874 0.27528
R3284 VDD.n1900 VDD.n1898 0.27528
R3285 VDD.n502 VDD.n492 0.27528
R3286 VDD.n743 VDD.n741 0.27528
R3287 VDD.n719 VDD.n717 0.27528
R3288 VDD.n694 VDD.n692 0.27528
R3289 VDD.n159 VDD.n157 0.27528
R3290 VDD.n1776 VDD.n1774 0.27528
R3291 VDD.n1800 VDD.n1798 0.27528
R3292 VDD.n1848 VDD.n1846 0.27528
R3293 VDD.n1824 VDD.n1822 0.27528
R3294 VDD.n668 VDD.n666 0.27528
R3295 VDD.n185 VDD.n183 0.27528
R3296 VDD.n1627 VDD.n1625 0.27528
R3297 VDD.n1651 VDD.n1649 0.27528
R3298 VDD.n1748 VDD.n1746 0.27528
R3299 VDD.n1724 VDD.n1722 0.27528
R3300 VDD.n1699 VDD.n1697 0.27528
R3301 VDD.n1675 VDD.n1673 0.27528
R3302 VDD.n641 VDD.n639 0.27528
R3303 VDD.n211 VDD.n209 0.27528
R3304 VDD.n1598 VDD.n1596 0.27528
R3305 VDD.n1573 VDD.n1571 0.27528
R3306 VDD.n1547 VDD.n1545 0.27528
R3307 VDD.n1522 VDD.n1520 0.27528
R3308 VDD.n261 VDD.n259 0.27528
R3309 VDD.n236 VDD.n234 0.27528
R3310 VDD.n615 VDD.n613 0.27528
R3311 VDD.n591 VDD.n589 0.27528
R3312 VDD.n566 VDD.n564 0.27528
R3313 VDD.n287 VDD.n285 0.27528
R3314 VDD.n1422 VDD.n1420 0.27528
R3315 VDD.n1446 VDD.n1444 0.27528
R3316 VDD.n1494 VDD.n1492 0.27528
R3317 VDD.n1470 VDD.n1468 0.27528
R3318 VDD.n430 VDD.n428 0.27528
R3319 VDD.n312 VDD.n310 0.27528
R3320 VDD.n1267 VDD.n1265 0.27528
R3321 VDD.n1292 VDD.n1290 0.27528
R3322 VDD.n1393 VDD.n1391 0.27528
R3323 VDD.n1368 VDD.n1366 0.27528
R3324 VDD.n1342 VDD.n1340 0.27528
R3325 VDD.n1317 VDD.n1315 0.27528
R3326 VDD.n1091 VDD.n1089 0.27528
R3327 VDD.n1116 VDD.n1114 0.27528
R3328 VDD.n1239 VDD.n1237 0.27528
R3329 VDD.n1215 VDD.n1213 0.27528
R3330 VDD.n1190 VDD.n1188 0.27528
R3331 VDD.n1165 VDD.n1163 0.27528
R3332 VDD.n1140 VDD.n1138 0.27528
R3333 VDD.n47 VDD.n45 0.27528
R3334 VDD.n1064 VDD.n1062 0.27528
R3335 VDD.n1040 VDD.n1038 0.27528
R3336 VDD.n1015 VDD.n1013 0.27528
R3337 VDD.n991 VDD.n989 0.27528
R3338 VDD.n965 VDD.n963 0.27528
R3339 VDD.n22 VDD.n20 0.27528
R3340 VDD.n1972 VDD.n1970 0.27528
R3341 VDD.n1948 VDD.n1946 0.27528
R3342 VDD.n889 VDD.n888 0.274511
R3343 VDD.n1922 VDD.n1921 0.270786
R3344 VDD.n1941 VDD.n1940 0.2645
R3345 VDD.n1928 VDD.n1927 0.260571
R3346 VDD.n778 VDD.n769 0.254511
R3347 VDD.n851 VDD.n842 0.254511
R3348 VDD.n827 VDD.n818 0.254511
R3349 VDD.n802 VDD.n793 0.254511
R3350 VDD.n85 VDD.n76 0.254511
R3351 VDD.n1883 VDD.n1874 0.254511
R3352 VDD.n1907 VDD.n1898 0.254511
R3353 VDD.n750 VDD.n741 0.254511
R3354 VDD.n726 VDD.n717 0.254511
R3355 VDD.n701 VDD.n692 0.254511
R3356 VDD.n166 VDD.n157 0.254511
R3357 VDD.n1783 VDD.n1774 0.254511
R3358 VDD.n1807 VDD.n1798 0.254511
R3359 VDD.n1855 VDD.n1846 0.254511
R3360 VDD.n1831 VDD.n1822 0.254511
R3361 VDD.n674 VDD.n666 0.254511
R3362 VDD.n191 VDD.n183 0.254511
R3363 VDD.n1633 VDD.n1625 0.254511
R3364 VDD.n1657 VDD.n1649 0.254511
R3365 VDD.n1754 VDD.n1746 0.254511
R3366 VDD.n1730 VDD.n1722 0.254511
R3367 VDD.n1705 VDD.n1697 0.254511
R3368 VDD.n1681 VDD.n1673 0.254511
R3369 VDD.n649 VDD.n639 0.254511
R3370 VDD.n219 VDD.n209 0.254511
R3371 VDD.n1606 VDD.n1596 0.254511
R3372 VDD.n1581 VDD.n1571 0.254511
R3373 VDD.n1555 VDD.n1545 0.254511
R3374 VDD.n1530 VDD.n1520 0.254511
R3375 VDD.n269 VDD.n259 0.254511
R3376 VDD.n244 VDD.n234 0.254511
R3377 VDD.n622 VDD.n613 0.254511
R3378 VDD.n598 VDD.n589 0.254511
R3379 VDD.n573 VDD.n564 0.254511
R3380 VDD.n294 VDD.n285 0.254511
R3381 VDD.n1429 VDD.n1420 0.254511
R3382 VDD.n1453 VDD.n1444 0.254511
R3383 VDD.n1501 VDD.n1492 0.254511
R3384 VDD.n1477 VDD.n1468 0.254511
R3385 VDD.n438 VDD.n428 0.254511
R3386 VDD.n320 VDD.n310 0.254511
R3387 VDD.n1275 VDD.n1265 0.254511
R3388 VDD.n1300 VDD.n1290 0.254511
R3389 VDD.n1401 VDD.n1391 0.254511
R3390 VDD.n1376 VDD.n1366 0.254511
R3391 VDD.n1350 VDD.n1340 0.254511
R3392 VDD.n1325 VDD.n1315 0.254511
R3393 VDD.n1099 VDD.n1089 0.254511
R3394 VDD.n1123 VDD.n1114 0.254511
R3395 VDD.n1246 VDD.n1237 0.254511
R3396 VDD.n1222 VDD.n1213 0.254511
R3397 VDD.n1197 VDD.n1188 0.254511
R3398 VDD.n1173 VDD.n1163 0.254511
R3399 VDD.n1147 VDD.n1138 0.254511
R3400 VDD.n55 VDD.n45 0.254511
R3401 VDD.n1071 VDD.n1062 0.254511
R3402 VDD.n1047 VDD.n1038 0.254511
R3403 VDD.n1022 VDD.n1013 0.254511
R3404 VDD.n998 VDD.n989 0.254511
R3405 VDD.n972 VDD.n963 0.254511
R3406 VDD.n29 VDD.n20 0.254511
R3407 VDD.n1979 VDD.n1970 0.254511
R3408 VDD.n1955 VDD.n1946 0.254511
R3409 VDD.n896 VDD.n895 0.237909
R3410 VDD.n1934 VDD.n1933 0.237811
R3411 VDD.n898 VDD.n897 0.236826
R3412 VDD.n1936 VDD.n1935 0.23673
R3413 VDD.n1926 VDD.n1925 0.236214
R3414 VDD.n894 VDD.n893 0.235744
R3415 VDD.n1932 VDD.n1931 0.235648
R3416 VDD.n895 VDD.n894 0.235022
R3417 VDD.n897 VDD.n896 0.235022
R3418 VDD.n954 VDD.n898 0.235022
R3419 VDD.n1933 VDD.n1932 0.234926
R3420 VDD.n1935 VDD.n1934 0.234926
R3421 VDD.n1937 VDD.n1936 0.234926
R3422 VDD.n1937 VDD.n6 0.234926
R3423 VDD.n777 VDD.n767 0.231362
R3424 VDD.n850 VDD.n840 0.231362
R3425 VDD.n826 VDD.n816 0.231362
R3426 VDD.n801 VDD.n791 0.231362
R3427 VDD.n84 VDD.n74 0.231362
R3428 VDD.n1882 VDD.n1872 0.231362
R3429 VDD.n1906 VDD.n1896 0.231362
R3430 VDD.n749 VDD.n739 0.231362
R3431 VDD.n725 VDD.n715 0.231362
R3432 VDD.n700 VDD.n690 0.231362
R3433 VDD.n165 VDD.n155 0.231362
R3434 VDD.n1782 VDD.n1772 0.231362
R3435 VDD.n1806 VDD.n1796 0.231362
R3436 VDD.n1854 VDD.n1844 0.231362
R3437 VDD.n1830 VDD.n1820 0.231362
R3438 VDD.n673 VDD.n664 0.231362
R3439 VDD.n190 VDD.n181 0.231362
R3440 VDD.n1632 VDD.n1623 0.231362
R3441 VDD.n1656 VDD.n1647 0.231362
R3442 VDD.n1753 VDD.n1744 0.231362
R3443 VDD.n1729 VDD.n1720 0.231362
R3444 VDD.n1704 VDD.n1695 0.231362
R3445 VDD.n1680 VDD.n1671 0.231362
R3446 VDD.n648 VDD.n637 0.231362
R3447 VDD.n218 VDD.n207 0.231362
R3448 VDD.n1605 VDD.n1594 0.231362
R3449 VDD.n1580 VDD.n1569 0.231362
R3450 VDD.n1554 VDD.n1543 0.231362
R3451 VDD.n1529 VDD.n1518 0.231362
R3452 VDD.n268 VDD.n257 0.231362
R3453 VDD.n243 VDD.n232 0.231362
R3454 VDD.n621 VDD.n611 0.231362
R3455 VDD.n597 VDD.n587 0.231362
R3456 VDD.n572 VDD.n562 0.231362
R3457 VDD.n293 VDD.n283 0.231362
R3458 VDD.n1428 VDD.n1418 0.231362
R3459 VDD.n1452 VDD.n1442 0.231362
R3460 VDD.n1500 VDD.n1490 0.231362
R3461 VDD.n1476 VDD.n1466 0.231362
R3462 VDD.n437 VDD.n426 0.231362
R3463 VDD.n319 VDD.n308 0.231362
R3464 VDD.n1274 VDD.n1263 0.231362
R3465 VDD.n1299 VDD.n1288 0.231362
R3466 VDD.n1400 VDD.n1389 0.231362
R3467 VDD.n1375 VDD.n1364 0.231362
R3468 VDD.n1349 VDD.n1338 0.231362
R3469 VDD.n1324 VDD.n1313 0.231362
R3470 VDD.n1098 VDD.n1087 0.231362
R3471 VDD.n1122 VDD.n1112 0.231362
R3472 VDD.n1245 VDD.n1235 0.231362
R3473 VDD.n1221 VDD.n1211 0.231362
R3474 VDD.n1196 VDD.n1186 0.231362
R3475 VDD.n1172 VDD.n1161 0.231362
R3476 VDD.n1146 VDD.n1136 0.231362
R3477 VDD.n54 VDD.n43 0.231362
R3478 VDD.n1070 VDD.n1060 0.231362
R3479 VDD.n1046 VDD.n1036 0.231362
R3480 VDD.n1021 VDD.n1011 0.231362
R3481 VDD.n997 VDD.n987 0.231362
R3482 VDD.n971 VDD.n961 0.231362
R3483 VDD.n28 VDD.n18 0.231362
R3484 VDD.n1978 VDD.n1968 0.231362
R3485 VDD.n1954 VDD.n1944 0.231362
R3486 VDD.n890 VDD.n889 0.22028
R3487 VDD.n503 VDD.n502 0.219511
R3488 VDD.n874 VDD.n873 0.218315
R3489 VDD VDD.n2032 0.215825
R3490 VDD.n875 VDD.n505 0.207646
R3491 VDD.n2094 VDD.n2093 0.203838
R3492 VDD.n891 VDD.n876 0.203691
R3493 VDD.n489 VDD.n474 0.203197
R3494 VDD.n868 VDD.n560 0.202696
R3495 VDD.n957 VDD.n423 0.202539
R3496 VDD.n505 VDD.n504 0.202208
R3497 VDD.n473 VDD.n472 0.201219
R3498 VDD.n959 VDD.n957 0.188735
R3499 VDD.n868 VDD.n867 0.188735
R3500 VDD.n2031 VDD.n2030 0.182157
R3501 VDD.n384 VDD.n383 0.180789
R3502 VDD.n959 VDD.n958 0.176186
R3503 VDD.n958 VDD.n15 0.176186
R3504 VDD.n2045 VDD.n15 0.176186
R3505 VDD.n867 VDD.n866 0.176186
R3506 VDD.n866 VDD.n865 0.176186
R3507 VDD.n865 VDD.n152 0.176186
R3508 VDD.n713 VDD.n712 0.174153
R3509 VDD.n1996 VDD.n1995 0.1735
R3510 VDD.n786 VDD.n785 0.172039
R3511 VDD.n859 VDD.n858 0.172039
R3512 VDD.n835 VDD.n834 0.172039
R3513 VDD.n810 VDD.n809 0.172039
R3514 VDD.n93 VDD.n92 0.172039
R3515 VDD.n1891 VDD.n1890 0.172039
R3516 VDD.n1915 VDD.n1914 0.172039
R3517 VDD.n501 VDD.n500 0.172039
R3518 VDD.n486 VDD.n485 0.172039
R3519 VDD.n469 VDD.n468 0.172039
R3520 VDD.n880 VDD.n879 0.172039
R3521 VDD.n758 VDD.n757 0.172039
R3522 VDD.n734 VDD.n733 0.172039
R3523 VDD.n709 VDD.n708 0.172039
R3524 VDD.n174 VDD.n173 0.172039
R3525 VDD.n1791 VDD.n1790 0.172039
R3526 VDD.n1815 VDD.n1814 0.172039
R3527 VDD.n1863 VDD.n1862 0.172039
R3528 VDD.n1839 VDD.n1838 0.172039
R3529 VDD.n682 VDD.n681 0.172039
R3530 VDD.n199 VDD.n198 0.172039
R3531 VDD.n1641 VDD.n1640 0.172039
R3532 VDD.n1665 VDD.n1664 0.172039
R3533 VDD.n1762 VDD.n1761 0.172039
R3534 VDD.n1738 VDD.n1737 0.172039
R3535 VDD.n1713 VDD.n1712 0.172039
R3536 VDD.n1689 VDD.n1688 0.172039
R3537 VDD.n657 VDD.n656 0.172039
R3538 VDD.n227 VDD.n226 0.172039
R3539 VDD.n1614 VDD.n1613 0.172039
R3540 VDD.n1589 VDD.n1588 0.172039
R3541 VDD.n1563 VDD.n1562 0.172039
R3542 VDD.n1538 VDD.n1537 0.172039
R3543 VDD.n277 VDD.n276 0.172039
R3544 VDD.n252 VDD.n251 0.172039
R3545 VDD.n630 VDD.n629 0.172039
R3546 VDD.n606 VDD.n605 0.172039
R3547 VDD.n581 VDD.n580 0.172039
R3548 VDD.n302 VDD.n301 0.172039
R3549 VDD.n1437 VDD.n1436 0.172039
R3550 VDD.n1461 VDD.n1460 0.172039
R3551 VDD.n1509 VDD.n1508 0.172039
R3552 VDD.n1485 VDD.n1484 0.172039
R3553 VDD.n446 VDD.n445 0.172039
R3554 VDD.n328 VDD.n327 0.172039
R3555 VDD.n1283 VDD.n1282 0.172039
R3556 VDD.n1308 VDD.n1307 0.172039
R3557 VDD.n1409 VDD.n1408 0.172039
R3558 VDD.n1384 VDD.n1383 0.172039
R3559 VDD.n1358 VDD.n1357 0.172039
R3560 VDD.n1333 VDD.n1332 0.172039
R3561 VDD.n1107 VDD.n1106 0.172039
R3562 VDD.n1131 VDD.n1130 0.172039
R3563 VDD.n1254 VDD.n1253 0.172039
R3564 VDD.n1230 VDD.n1229 0.172039
R3565 VDD.n1205 VDD.n1204 0.172039
R3566 VDD.n1181 VDD.n1180 0.172039
R3567 VDD.n1155 VDD.n1154 0.172039
R3568 VDD.n63 VDD.n62 0.172039
R3569 VDD.n1079 VDD.n1078 0.172039
R3570 VDD.n1055 VDD.n1054 0.172039
R3571 VDD.n1030 VDD.n1029 0.172039
R3572 VDD.n1006 VDD.n1005 0.172039
R3573 VDD.n980 VDD.n979 0.172039
R3574 VDD.n37 VDD.n36 0.172039
R3575 VDD.n1987 VDD.n1986 0.172039
R3576 VDD.n1963 VDD.n1962 0.172039
R3577 VDD.n337 VDD.n336 0.170789
R3578 VDD.n2032 VDD.n2031 0.170486
R3579 VDD.n1440 VDD.n1416 0.167993
R3580 VDD.n1567 VDD.n1566 0.167993
R3581 VDD.n1894 VDD.n1870 0.167407
R3582 VDD.n342 VDD.n340 0.163973
R3583 VDD.n1794 VDD.n1770 0.16242
R3584 VDD.n1513 VDD.n1512 0.161833
R3585 VDD.n1516 VDD.n280 0.161833
R3586 VDD.n1718 VDD.n1717 0.161833
R3587 VDD.n785 VDD.n768 0.161393
R3588 VDD.n858 VDD.n841 0.161393
R3589 VDD.n834 VDD.n817 0.161393
R3590 VDD.n809 VDD.n792 0.161393
R3591 VDD.n92 VDD.n75 0.161393
R3592 VDD.n1890 VDD.n1873 0.161393
R3593 VDD.n1914 VDD.n1897 0.161393
R3594 VDD.n500 VDD.n493 0.161393
R3595 VDD.n485 VDD.n477 0.161393
R3596 VDD.n468 VDD.n460 0.161393
R3597 VDD.n757 VDD.n740 0.161393
R3598 VDD.n733 VDD.n716 0.161393
R3599 VDD.n708 VDD.n691 0.161393
R3600 VDD.n173 VDD.n156 0.161393
R3601 VDD.n1790 VDD.n1773 0.161393
R3602 VDD.n1814 VDD.n1797 0.161393
R3603 VDD.n1862 VDD.n1845 0.161393
R3604 VDD.n1838 VDD.n1821 0.161393
R3605 VDD.n681 VDD.n665 0.161393
R3606 VDD.n198 VDD.n182 0.161393
R3607 VDD.n1640 VDD.n1624 0.161393
R3608 VDD.n1664 VDD.n1648 0.161393
R3609 VDD.n1761 VDD.n1745 0.161393
R3610 VDD.n1737 VDD.n1721 0.161393
R3611 VDD.n1712 VDD.n1696 0.161393
R3612 VDD.n1688 VDD.n1672 0.161393
R3613 VDD.n656 VDD.n638 0.161393
R3614 VDD.n226 VDD.n208 0.161393
R3615 VDD.n1613 VDD.n1595 0.161393
R3616 VDD.n1588 VDD.n1570 0.161393
R3617 VDD.n1562 VDD.n1544 0.161393
R3618 VDD.n1537 VDD.n1519 0.161393
R3619 VDD.n276 VDD.n258 0.161393
R3620 VDD.n251 VDD.n233 0.161393
R3621 VDD.n629 VDD.n612 0.161393
R3622 VDD.n605 VDD.n588 0.161393
R3623 VDD.n580 VDD.n563 0.161393
R3624 VDD.n301 VDD.n284 0.161393
R3625 VDD.n1436 VDD.n1419 0.161393
R3626 VDD.n1460 VDD.n1443 0.161393
R3627 VDD.n1508 VDD.n1491 0.161393
R3628 VDD.n1484 VDD.n1467 0.161393
R3629 VDD.n445 VDD.n427 0.161393
R3630 VDD.n327 VDD.n309 0.161393
R3631 VDD.n1282 VDD.n1264 0.161393
R3632 VDD.n1307 VDD.n1289 0.161393
R3633 VDD.n1408 VDD.n1390 0.161393
R3634 VDD.n1383 VDD.n1365 0.161393
R3635 VDD.n1357 VDD.n1339 0.161393
R3636 VDD.n1332 VDD.n1314 0.161393
R3637 VDD.n1106 VDD.n1088 0.161393
R3638 VDD.n1130 VDD.n1113 0.161393
R3639 VDD.n1253 VDD.n1236 0.161393
R3640 VDD.n1229 VDD.n1212 0.161393
R3641 VDD.n1204 VDD.n1187 0.161393
R3642 VDD.n1180 VDD.n1162 0.161393
R3643 VDD.n1154 VDD.n1137 0.161393
R3644 VDD.n62 VDD.n44 0.161393
R3645 VDD.n1078 VDD.n1061 0.161393
R3646 VDD.n1054 VDD.n1037 0.161393
R3647 VDD.n1029 VDD.n1012 0.161393
R3648 VDD.n1005 VDD.n988 0.161393
R3649 VDD.n979 VDD.n962 0.161393
R3650 VDD.n36 VDD.n19 0.161393
R3651 VDD.n1986 VDD.n1969 0.161393
R3652 VDD.n1962 VDD.n1945 0.161393
R3653 VDD.n879 VDD.n878 0.160629
R3654 VDD.n419 VDD.n393 0.158973
R3655 VDD.n1110 VDD.n1085 0.158313
R3656 VDD.n1258 VDD.n1257 0.157433
R3657 VDD.n634 VDD.n633 0.15714
R3658 VDD.n762 VDD.n761 0.15714
R3659 VDD.n1413 VDD.n1412 0.156847
R3660 VDD.n1209 VDD.n1208 0.156847
R3661 VDD.n814 VDD.n813 0.156847
R3662 VDD.n1159 VDD.n1158 0.15626
R3663 VDD VDD.n384 0.155789
R3664 VDD.n1286 VDD.n1261 0.15186
R3665 VDD.n1645 VDD.n1621 0.15186
R3666 VDD.n863 VDD.n862 0.15186
R3667 VDD.n450 VDD.n449 0.151273
R3668 VDD.n774 VDD.n773 0.150789
R3669 VDD.n847 VDD.n846 0.150789
R3670 VDD.n823 VDD.n822 0.150789
R3671 VDD.n798 VDD.n797 0.150789
R3672 VDD.n81 VDD.n80 0.150789
R3673 VDD.n1879 VDD.n1878 0.150789
R3674 VDD.n1903 VDD.n1902 0.150789
R3675 VDD.n746 VDD.n745 0.150789
R3676 VDD.n722 VDD.n721 0.150789
R3677 VDD.n697 VDD.n696 0.150789
R3678 VDD.n162 VDD.n161 0.150789
R3679 VDD.n1779 VDD.n1778 0.150789
R3680 VDD.n1803 VDD.n1802 0.150789
R3681 VDD.n1851 VDD.n1850 0.150789
R3682 VDD.n1827 VDD.n1826 0.150789
R3683 VDD.n672 VDD.n671 0.150789
R3684 VDD.n189 VDD.n188 0.150789
R3685 VDD.n1631 VDD.n1630 0.150789
R3686 VDD.n1655 VDD.n1654 0.150789
R3687 VDD.n1752 VDD.n1751 0.150789
R3688 VDD.n1728 VDD.n1727 0.150789
R3689 VDD.n1703 VDD.n1702 0.150789
R3690 VDD.n1679 VDD.n1678 0.150789
R3691 VDD.n644 VDD.n643 0.150789
R3692 VDD.n214 VDD.n213 0.150789
R3693 VDD.n1601 VDD.n1600 0.150789
R3694 VDD.n1576 VDD.n1575 0.150789
R3695 VDD.n1550 VDD.n1549 0.150789
R3696 VDD.n1525 VDD.n1524 0.150789
R3697 VDD.n264 VDD.n263 0.150789
R3698 VDD.n239 VDD.n238 0.150789
R3699 VDD.n618 VDD.n617 0.150789
R3700 VDD.n594 VDD.n593 0.150789
R3701 VDD.n569 VDD.n568 0.150789
R3702 VDD.n290 VDD.n289 0.150789
R3703 VDD.n1425 VDD.n1424 0.150789
R3704 VDD.n1449 VDD.n1448 0.150789
R3705 VDD.n1497 VDD.n1496 0.150789
R3706 VDD.n1473 VDD.n1472 0.150789
R3707 VDD.n433 VDD.n432 0.150789
R3708 VDD.n315 VDD.n314 0.150789
R3709 VDD.n1270 VDD.n1269 0.150789
R3710 VDD.n1295 VDD.n1294 0.150789
R3711 VDD.n1396 VDD.n1395 0.150789
R3712 VDD.n1371 VDD.n1370 0.150789
R3713 VDD.n1345 VDD.n1344 0.150789
R3714 VDD.n1320 VDD.n1319 0.150789
R3715 VDD.n1094 VDD.n1093 0.150789
R3716 VDD.n1119 VDD.n1118 0.150789
R3717 VDD.n1242 VDD.n1241 0.150789
R3718 VDD.n1218 VDD.n1217 0.150789
R3719 VDD.n1193 VDD.n1192 0.150789
R3720 VDD.n1168 VDD.n1167 0.150789
R3721 VDD.n1143 VDD.n1142 0.150789
R3722 VDD.n50 VDD.n49 0.150789
R3723 VDD.n1067 VDD.n1066 0.150789
R3724 VDD.n1043 VDD.n1042 0.150789
R3725 VDD.n1018 VDD.n1017 0.150789
R3726 VDD.n994 VDD.n993 0.150789
R3727 VDD.n968 VDD.n967 0.150789
R3728 VDD.n25 VDD.n24 0.150789
R3729 VDD.n1975 VDD.n1974 0.150789
R3730 VDD.n1951 VDD.n1950 0.150789
R3731 VDD.n1867 VDD.n1866 0.150687
R3732 VDD.n1034 VDD.n1033 0.149513
R3733 VDD.n661 VDD.n660 0.149513
R3734 VDD.n687 VDD.n686 0.14922
R3735 VDD.n1991 VDD.n1990 0.148927
R3736 VDD.n985 VDD.n983 0.147167
R3737 VDD.n1998 VDD.n1997 0.147039
R3738 VDD.n2040 VDD.n2029 0.147039
R3739 VDD.n2014 VDD.n2013 0.147039
R3740 VDD.n2025 VDD.n2009 0.147039
R3741 VDD.n585 VDD.n584 0.146287
R3742 VDD.n1767 VDD.n1766 0.1457
R3743 VDD.n1362 VDD.n1361 0.14482
R3744 VDD.n2094 VDD.n6 0.142634
R3745 VDD.n784 VDD.n783 0.140789
R3746 VDD.n857 VDD.n856 0.140789
R3747 VDD.n833 VDD.n832 0.140789
R3748 VDD.n808 VDD.n807 0.140789
R3749 VDD.n91 VDD.n90 0.140789
R3750 VDD.n1889 VDD.n1888 0.140789
R3751 VDD.n1913 VDD.n1912 0.140789
R3752 VDD.n499 VDD.n498 0.140789
R3753 VDD.n484 VDD.n483 0.140789
R3754 VDD.n467 VDD.n466 0.140789
R3755 VDD.n882 VDD.n881 0.140789
R3756 VDD.n756 VDD.n755 0.140789
R3757 VDD.n732 VDD.n731 0.140789
R3758 VDD.n707 VDD.n706 0.140789
R3759 VDD.n172 VDD.n171 0.140789
R3760 VDD.n1789 VDD.n1788 0.140789
R3761 VDD.n1813 VDD.n1812 0.140789
R3762 VDD.n1861 VDD.n1860 0.140789
R3763 VDD.n1837 VDD.n1836 0.140789
R3764 VDD.n680 VDD.n679 0.140789
R3765 VDD.n197 VDD.n196 0.140789
R3766 VDD.n1639 VDD.n1638 0.140789
R3767 VDD.n1663 VDD.n1662 0.140789
R3768 VDD.n1760 VDD.n1759 0.140789
R3769 VDD.n1736 VDD.n1735 0.140789
R3770 VDD.n1711 VDD.n1710 0.140789
R3771 VDD.n1687 VDD.n1686 0.140789
R3772 VDD.n655 VDD.n654 0.140789
R3773 VDD.n225 VDD.n224 0.140789
R3774 VDD.n1612 VDD.n1611 0.140789
R3775 VDD.n1587 VDD.n1586 0.140789
R3776 VDD.n1561 VDD.n1560 0.140789
R3777 VDD.n1536 VDD.n1535 0.140789
R3778 VDD.n275 VDD.n274 0.140789
R3779 VDD.n250 VDD.n249 0.140789
R3780 VDD.n628 VDD.n627 0.140789
R3781 VDD.n604 VDD.n603 0.140789
R3782 VDD.n579 VDD.n578 0.140789
R3783 VDD.n300 VDD.n299 0.140789
R3784 VDD.n1435 VDD.n1434 0.140789
R3785 VDD.n1459 VDD.n1458 0.140789
R3786 VDD.n1507 VDD.n1506 0.140789
R3787 VDD.n1483 VDD.n1482 0.140789
R3788 VDD.n444 VDD.n443 0.140789
R3789 VDD.n326 VDD.n325 0.140789
R3790 VDD.n1281 VDD.n1280 0.140789
R3791 VDD.n1306 VDD.n1305 0.140789
R3792 VDD.n1407 VDD.n1406 0.140789
R3793 VDD.n1382 VDD.n1381 0.140789
R3794 VDD.n1356 VDD.n1355 0.140789
R3795 VDD.n1331 VDD.n1330 0.140789
R3796 VDD.n1105 VDD.n1104 0.140789
R3797 VDD.n1129 VDD.n1128 0.140789
R3798 VDD.n1252 VDD.n1251 0.140789
R3799 VDD.n1228 VDD.n1227 0.140789
R3800 VDD.n1203 VDD.n1202 0.140789
R3801 VDD.n1179 VDD.n1178 0.140789
R3802 VDD.n1153 VDD.n1152 0.140789
R3803 VDD.n61 VDD.n60 0.140789
R3804 VDD.n1077 VDD.n1076 0.140789
R3805 VDD.n1053 VDD.n1052 0.140789
R3806 VDD.n1028 VDD.n1027 0.140789
R3807 VDD.n1004 VDD.n1003 0.140789
R3808 VDD.n978 VDD.n977 0.140789
R3809 VDD.n35 VDD.n34 0.140789
R3810 VDD.n1985 VDD.n1984 0.140789
R3811 VDD.n1961 VDD.n1960 0.140789
R3812 VDD.n876 VDD.n875 0.138927
R3813 VDD.n771 VDD.n770 0.136382
R3814 VDD.n844 VDD.n843 0.136382
R3815 VDD.n820 VDD.n819 0.136382
R3816 VDD.n795 VDD.n794 0.136382
R3817 VDD.n78 VDD.n77 0.136382
R3818 VDD.n1876 VDD.n1875 0.136382
R3819 VDD.n1900 VDD.n1899 0.136382
R3820 VDD.n492 VDD.n491 0.136382
R3821 VDD.n480 VDD.n479 0.136382
R3822 VDD.n463 VDD.n462 0.136382
R3823 VDD.n888 VDD.n886 0.136382
R3824 VDD.n743 VDD.n742 0.136382
R3825 VDD.n719 VDD.n718 0.136382
R3826 VDD.n694 VDD.n693 0.136382
R3827 VDD.n159 VDD.n158 0.136382
R3828 VDD.n1776 VDD.n1775 0.136382
R3829 VDD.n1800 VDD.n1799 0.136382
R3830 VDD.n1848 VDD.n1847 0.136382
R3831 VDD.n1824 VDD.n1823 0.136382
R3832 VDD.n668 VDD.n667 0.136382
R3833 VDD.n185 VDD.n184 0.136382
R3834 VDD.n1627 VDD.n1626 0.136382
R3835 VDD.n1651 VDD.n1650 0.136382
R3836 VDD.n1748 VDD.n1747 0.136382
R3837 VDD.n1724 VDD.n1723 0.136382
R3838 VDD.n1699 VDD.n1698 0.136382
R3839 VDD.n1675 VDD.n1674 0.136382
R3840 VDD.n641 VDD.n640 0.136382
R3841 VDD.n211 VDD.n210 0.136382
R3842 VDD.n1598 VDD.n1597 0.136382
R3843 VDD.n1573 VDD.n1572 0.136382
R3844 VDD.n1547 VDD.n1546 0.136382
R3845 VDD.n1522 VDD.n1521 0.136382
R3846 VDD.n261 VDD.n260 0.136382
R3847 VDD.n236 VDD.n235 0.136382
R3848 VDD.n615 VDD.n614 0.136382
R3849 VDD.n591 VDD.n590 0.136382
R3850 VDD.n566 VDD.n565 0.136382
R3851 VDD.n287 VDD.n286 0.136382
R3852 VDD.n1422 VDD.n1421 0.136382
R3853 VDD.n1446 VDD.n1445 0.136382
R3854 VDD.n1494 VDD.n1493 0.136382
R3855 VDD.n1470 VDD.n1469 0.136382
R3856 VDD.n430 VDD.n429 0.136382
R3857 VDD.n312 VDD.n311 0.136382
R3858 VDD.n1267 VDD.n1266 0.136382
R3859 VDD.n1292 VDD.n1291 0.136382
R3860 VDD.n1393 VDD.n1392 0.136382
R3861 VDD.n1368 VDD.n1367 0.136382
R3862 VDD.n1342 VDD.n1341 0.136382
R3863 VDD.n1317 VDD.n1316 0.136382
R3864 VDD.n1091 VDD.n1090 0.136382
R3865 VDD.n1116 VDD.n1115 0.136382
R3866 VDD.n1239 VDD.n1238 0.136382
R3867 VDD.n1215 VDD.n1214 0.136382
R3868 VDD.n1190 VDD.n1189 0.136382
R3869 VDD.n1165 VDD.n1164 0.136382
R3870 VDD.n1140 VDD.n1139 0.136382
R3871 VDD.n47 VDD.n46 0.136382
R3872 VDD.n1064 VDD.n1063 0.136382
R3873 VDD.n1040 VDD.n1039 0.136382
R3874 VDD.n1015 VDD.n1014 0.136382
R3875 VDD.n991 VDD.n990 0.136382
R3876 VDD.n965 VDD.n964 0.136382
R3877 VDD.n22 VDD.n21 0.136382
R3878 VDD.n1972 VDD.n1971 0.136382
R3879 VDD.n1948 VDD.n1947 0.136382
R3880 VDD.n1618 VDD.n1617 0.134847
R3881 VDD.n776 VDD.n775 0.133289
R3882 VDD.n849 VDD.n848 0.133289
R3883 VDD.n825 VDD.n824 0.133289
R3884 VDD.n800 VDD.n799 0.133289
R3885 VDD.n83 VDD.n82 0.133289
R3886 VDD.n1881 VDD.n1880 0.133289
R3887 VDD.n1905 VDD.n1904 0.133289
R3888 VDD.n748 VDD.n747 0.133289
R3889 VDD.n724 VDD.n723 0.133289
R3890 VDD.n699 VDD.n698 0.133289
R3891 VDD.n164 VDD.n163 0.133289
R3892 VDD.n1781 VDD.n1780 0.133289
R3893 VDD.n1805 VDD.n1804 0.133289
R3894 VDD.n1853 VDD.n1852 0.133289
R3895 VDD.n1829 VDD.n1828 0.133289
R3896 VDD.n670 VDD.n663 0.133289
R3897 VDD.n187 VDD.n180 0.133289
R3898 VDD.n1629 VDD.n1622 0.133289
R3899 VDD.n1653 VDD.n1646 0.133289
R3900 VDD.n1750 VDD.n1743 0.133289
R3901 VDD.n1726 VDD.n1719 0.133289
R3902 VDD.n1701 VDD.n1694 0.133289
R3903 VDD.n1677 VDD.n1670 0.133289
R3904 VDD.n647 VDD.n646 0.133289
R3905 VDD.n217 VDD.n216 0.133289
R3906 VDD.n1604 VDD.n1603 0.133289
R3907 VDD.n1579 VDD.n1578 0.133289
R3908 VDD.n1553 VDD.n1552 0.133289
R3909 VDD.n1528 VDD.n1527 0.133289
R3910 VDD.n267 VDD.n266 0.133289
R3911 VDD.n242 VDD.n241 0.133289
R3912 VDD.n620 VDD.n619 0.133289
R3913 VDD.n596 VDD.n595 0.133289
R3914 VDD.n571 VDD.n570 0.133289
R3915 VDD.n292 VDD.n291 0.133289
R3916 VDD.n1427 VDD.n1426 0.133289
R3917 VDD.n1451 VDD.n1450 0.133289
R3918 VDD.n1499 VDD.n1498 0.133289
R3919 VDD.n1475 VDD.n1474 0.133289
R3920 VDD.n436 VDD.n435 0.133289
R3921 VDD.n318 VDD.n317 0.133289
R3922 VDD.n1273 VDD.n1272 0.133289
R3923 VDD.n1298 VDD.n1297 0.133289
R3924 VDD.n1399 VDD.n1398 0.133289
R3925 VDD.n1374 VDD.n1373 0.133289
R3926 VDD.n1348 VDD.n1347 0.133289
R3927 VDD.n1323 VDD.n1322 0.133289
R3928 VDD.n1097 VDD.n1096 0.133289
R3929 VDD.n1121 VDD.n1120 0.133289
R3930 VDD.n1244 VDD.n1243 0.133289
R3931 VDD.n1220 VDD.n1219 0.133289
R3932 VDD.n1195 VDD.n1194 0.133289
R3933 VDD.n1171 VDD.n1170 0.133289
R3934 VDD.n1145 VDD.n1144 0.133289
R3935 VDD.n53 VDD.n52 0.133289
R3936 VDD.n1069 VDD.n1068 0.133289
R3937 VDD.n1045 VDD.n1044 0.133289
R3938 VDD.n1020 VDD.n1019 0.133289
R3939 VDD.n996 VDD.n995 0.133289
R3940 VDD.n970 VDD.n969 0.133289
R3941 VDD.n27 VDD.n26 0.133289
R3942 VDD.n1977 VDD.n1976 0.133289
R3943 VDD.n1953 VDD.n1952 0.133289
R3944 VDD.n2001 VDD.n2000 0.132039
R3945 VDD.n2034 VDD.n2033 0.130789
R3946 VDD.n2011 VDD.n2010 0.130789
R3947 VDD.n2017 VDD.n2016 0.130789
R3948 VDD.n389 VDD.n388 0.130789
R3949 VDD.n776 VDD.n766 0.128289
R3950 VDD.n849 VDD.n839 0.128289
R3951 VDD.n825 VDD.n815 0.128289
R3952 VDD.n800 VDD.n790 0.128289
R3953 VDD.n83 VDD.n73 0.128289
R3954 VDD.n1881 VDD.n1871 0.128289
R3955 VDD.n1905 VDD.n1895 0.128289
R3956 VDD.n748 VDD.n738 0.128289
R3957 VDD.n724 VDD.n714 0.128289
R3958 VDD.n699 VDD.n689 0.128289
R3959 VDD.n164 VDD.n154 0.128289
R3960 VDD.n1781 VDD.n1771 0.128289
R3961 VDD.n1805 VDD.n1795 0.128289
R3962 VDD.n1853 VDD.n1843 0.128289
R3963 VDD.n1829 VDD.n1819 0.128289
R3964 VDD.n647 VDD.n645 0.128289
R3965 VDD.n217 VDD.n215 0.128289
R3966 VDD.n1604 VDD.n1602 0.128289
R3967 VDD.n1579 VDD.n1577 0.128289
R3968 VDD.n1553 VDD.n1551 0.128289
R3969 VDD.n1528 VDD.n1526 0.128289
R3970 VDD.n267 VDD.n265 0.128289
R3971 VDD.n242 VDD.n240 0.128289
R3972 VDD.n620 VDD.n610 0.128289
R3973 VDD.n596 VDD.n586 0.128289
R3974 VDD.n571 VDD.n561 0.128289
R3975 VDD.n292 VDD.n282 0.128289
R3976 VDD.n1427 VDD.n1417 0.128289
R3977 VDD.n1451 VDD.n1441 0.128289
R3978 VDD.n1499 VDD.n1489 0.128289
R3979 VDD.n1475 VDD.n1465 0.128289
R3980 VDD.n436 VDD.n434 0.128289
R3981 VDD.n318 VDD.n316 0.128289
R3982 VDD.n1273 VDD.n1271 0.128289
R3983 VDD.n1298 VDD.n1296 0.128289
R3984 VDD.n1399 VDD.n1397 0.128289
R3985 VDD.n1374 VDD.n1372 0.128289
R3986 VDD.n1348 VDD.n1346 0.128289
R3987 VDD.n1323 VDD.n1321 0.128289
R3988 VDD.n1097 VDD.n1095 0.128289
R3989 VDD.n1121 VDD.n1111 0.128289
R3990 VDD.n1244 VDD.n1234 0.128289
R3991 VDD.n1220 VDD.n1210 0.128289
R3992 VDD.n1195 VDD.n1185 0.128289
R3993 VDD.n1171 VDD.n1169 0.128289
R3994 VDD.n1145 VDD.n1135 0.128289
R3995 VDD.n53 VDD.n51 0.128289
R3996 VDD.n1069 VDD.n1059 0.128289
R3997 VDD.n1045 VDD.n1035 0.128289
R3998 VDD.n1020 VDD.n1010 0.128289
R3999 VDD.n996 VDD.n986 0.128289
R4000 VDD.n970 VDD.n960 0.128289
R4001 VDD.n27 VDD.n17 0.128289
R4002 VDD.n1977 VDD.n1967 0.128289
R4003 VDD.n1953 VDD.n1943 0.128289
R4004 VDD.n2003 VDD.n2001 0.124539
R4005 VDD.n2036 VDD.n2034 0.124539
R4006 VDD.n2022 VDD.n2010 0.124539
R4007 VDD.n2019 VDD.n2017 0.124539
R4008 VDD.n1692 VDD.n1670 0.124539
R4009 VDD.n388 VDD.n387 0.124539
R4010 VDD.n2 VDD 0.120789
R4011 VDD.n367 VDD.n341 0.1205
R4012 VDD.n355 VDD.n354 0.1205
R4013 VDD.n359 VDD.n358 0.1205
R4014 VDD.n381 VDD.n380 0.1205
R4015 VDD.n416 VDD.n415 0.1205
R4016 VDD.n410 VDD.n409 0.1205
R4017 VDD.n407 VDD.n406 0.1205
R4018 VDD.n1765 VDD.n1743 0.119539
R4019 VDD.n65 VDD.n64 0.118
R4020 VDD.n4 VDD.n0 0.117523
R4021 VDD.n685 VDD.n663 0.117039
R4022 VDD.n783 VDD.n782 0.115789
R4023 VDD.n856 VDD.n855 0.115789
R4024 VDD.n832 VDD.n831 0.115789
R4025 VDD.n807 VDD.n806 0.115789
R4026 VDD.n90 VDD.n89 0.115789
R4027 VDD.n1888 VDD.n1887 0.115789
R4028 VDD.n1912 VDD.n1911 0.115789
R4029 VDD.n498 VDD.n497 0.115789
R4030 VDD.n483 VDD.n482 0.115789
R4031 VDD.n466 VDD.n465 0.115789
R4032 VDD.n883 VDD.n882 0.115789
R4033 VDD.n755 VDD.n754 0.115789
R4034 VDD.n731 VDD.n730 0.115789
R4035 VDD.n706 VDD.n705 0.115789
R4036 VDD.n171 VDD.n170 0.115789
R4037 VDD.n1788 VDD.n1787 0.115789
R4038 VDD.n1812 VDD.n1811 0.115789
R4039 VDD.n1860 VDD.n1859 0.115789
R4040 VDD.n1836 VDD.n1835 0.115789
R4041 VDD.n679 VDD.n678 0.115789
R4042 VDD.n196 VDD.n195 0.115789
R4043 VDD.n1638 VDD.n1637 0.115789
R4044 VDD.n1662 VDD.n1661 0.115789
R4045 VDD.n1759 VDD.n1758 0.115789
R4046 VDD.n1735 VDD.n1734 0.115789
R4047 VDD.n1710 VDD.n1709 0.115789
R4048 VDD.n1686 VDD.n1685 0.115789
R4049 VDD.n654 VDD.n653 0.115789
R4050 VDD.n224 VDD.n223 0.115789
R4051 VDD.n1611 VDD.n1610 0.115789
R4052 VDD.n1586 VDD.n1585 0.115789
R4053 VDD.n1560 VDD.n1559 0.115789
R4054 VDD.n1535 VDD.n1534 0.115789
R4055 VDD.n274 VDD.n273 0.115789
R4056 VDD.n249 VDD.n248 0.115789
R4057 VDD.n627 VDD.n626 0.115789
R4058 VDD.n603 VDD.n602 0.115789
R4059 VDD.n578 VDD.n577 0.115789
R4060 VDD.n299 VDD.n298 0.115789
R4061 VDD.n1434 VDD.n1433 0.115789
R4062 VDD.n1458 VDD.n1457 0.115789
R4063 VDD.n1506 VDD.n1505 0.115789
R4064 VDD.n1482 VDD.n1481 0.115789
R4065 VDD.n443 VDD.n442 0.115789
R4066 VDD.n325 VDD.n324 0.115789
R4067 VDD.n1280 VDD.n1279 0.115789
R4068 VDD.n1305 VDD.n1304 0.115789
R4069 VDD.n1406 VDD.n1405 0.115789
R4070 VDD.n1381 VDD.n1380 0.115789
R4071 VDD.n1355 VDD.n1354 0.115789
R4072 VDD.n1330 VDD.n1329 0.115789
R4073 VDD.n1104 VDD.n1103 0.115789
R4074 VDD.n1128 VDD.n1127 0.115789
R4075 VDD.n1251 VDD.n1250 0.115789
R4076 VDD.n1227 VDD.n1226 0.115789
R4077 VDD.n1202 VDD.n1201 0.115789
R4078 VDD.n1178 VDD.n1177 0.115789
R4079 VDD.n1152 VDD.n1151 0.115789
R4080 VDD.n60 VDD.n59 0.115789
R4081 VDD.n1076 VDD.n1075 0.115789
R4082 VDD.n1052 VDD.n1051 0.115789
R4083 VDD.n1027 VDD.n1026 0.115789
R4084 VDD.n1003 VDD.n1002 0.115789
R4085 VDD.n977 VDD.n976 0.115789
R4086 VDD.n34 VDD.n33 0.115789
R4087 VDD.n1984 VDD.n1983 0.115789
R4088 VDD.n1960 VDD.n1959 0.115789
R4089 VDD.n2007 VDD.n2006 0.1155
R4090 VDD.n1109 VDD.n1108 0.1155
R4091 VDD.n202 VDD.n180 0.114539
R4092 VDD.n1591 VDD.n1590 0.11425
R4093 VDD.n684 VDD.n683 0.113289
R4094 VDD.n201 VDD.n200 0.113289
R4095 VDD.n1643 VDD.n1642 0.113289
R4096 VDD.n1668 VDD.n1646 0.113289
R4097 VDD.n1667 VDD.n1666 0.113289
R4098 VDD.n1764 VDD.n1763 0.113289
R4099 VDD.n1740 VDD.n1739 0.113289
R4100 VDD.n1715 VDD.n1714 0.113289
R4101 VDD.n1691 VDD.n1690 0.113289
R4102 VDD.n229 VDD.n228 0.113
R4103 VDD.n1540 VDD.n1539 0.113
R4104 VDD.n1183 VDD.n1182 0.113
R4105 VDD.n1716 VDD.n1694 0.112039
R4106 VDD.n1997 VDD.n1996 0.109539
R4107 VDD.n2013 VDD.n2012 0.109539
R4108 VDD.n176 VDD.n175 0.109539
R4109 VDD.n1644 VDD.n1622 0.109539
R4110 VDD.n1741 VDD.n1719 0.109539
R4111 VDD.n391 VDD.n372 0.109341
R4112 VDD.n775 VDD.n774 0.108289
R4113 VDD.n848 VDD.n847 0.108289
R4114 VDD.n861 VDD.n860 0.108289
R4115 VDD.n824 VDD.n823 0.108289
R4116 VDD.n799 VDD.n798 0.108289
R4117 VDD.n82 VDD.n81 0.108289
R4118 VDD.n1880 VDD.n1879 0.108289
R4119 VDD.n1904 VDD.n1903 0.108289
R4120 VDD.n747 VDD.n746 0.108289
R4121 VDD.n723 VDD.n722 0.108289
R4122 VDD.n698 VDD.n697 0.108289
R4123 VDD.n163 VDD.n162 0.108289
R4124 VDD.n1780 VDD.n1779 0.108289
R4125 VDD.n1804 VDD.n1803 0.108289
R4126 VDD.n1852 VDD.n1851 0.108289
R4127 VDD.n1828 VDD.n1827 0.108289
R4128 VDD.n672 VDD.n670 0.108289
R4129 VDD.n189 VDD.n187 0.108289
R4130 VDD.n1631 VDD.n1629 0.108289
R4131 VDD.n1655 VDD.n1653 0.108289
R4132 VDD.n1752 VDD.n1750 0.108289
R4133 VDD.n1728 VDD.n1726 0.108289
R4134 VDD.n1703 VDD.n1701 0.108289
R4135 VDD.n1679 VDD.n1677 0.108289
R4136 VDD.n646 VDD.n644 0.108289
R4137 VDD.n216 VDD.n214 0.108289
R4138 VDD.n1603 VDD.n1601 0.108289
R4139 VDD.n1578 VDD.n1576 0.108289
R4140 VDD.n1552 VDD.n1550 0.108289
R4141 VDD.n1527 VDD.n1525 0.108289
R4142 VDD.n266 VDD.n264 0.108289
R4143 VDD.n241 VDD.n239 0.108289
R4144 VDD.n619 VDD.n618 0.108289
R4145 VDD.n595 VDD.n594 0.108289
R4146 VDD.n570 VDD.n569 0.108289
R4147 VDD.n291 VDD.n290 0.108289
R4148 VDD.n1426 VDD.n1425 0.108289
R4149 VDD.n1450 VDD.n1449 0.108289
R4150 VDD.n1498 VDD.n1497 0.108289
R4151 VDD.n1474 VDD.n1473 0.108289
R4152 VDD.n435 VDD.n433 0.108289
R4153 VDD.n317 VDD.n315 0.108289
R4154 VDD.n1272 VDD.n1270 0.108289
R4155 VDD.n1297 VDD.n1295 0.108289
R4156 VDD.n1398 VDD.n1396 0.108289
R4157 VDD.n1373 VDD.n1371 0.108289
R4158 VDD.n1347 VDD.n1345 0.108289
R4159 VDD.n1322 VDD.n1320 0.108289
R4160 VDD.n1096 VDD.n1094 0.108289
R4161 VDD.n1120 VDD.n1119 0.108289
R4162 VDD.n1243 VDD.n1242 0.108289
R4163 VDD.n1219 VDD.n1218 0.108289
R4164 VDD.n1194 VDD.n1193 0.108289
R4165 VDD.n1170 VDD.n1168 0.108289
R4166 VDD.n1144 VDD.n1143 0.108289
R4167 VDD.n52 VDD.n50 0.108289
R4168 VDD.n1068 VDD.n1067 0.108289
R4169 VDD.n1044 VDD.n1043 0.108289
R4170 VDD.n1019 VDD.n1018 0.108289
R4171 VDD.n995 VDD.n994 0.108289
R4172 VDD.n969 VDD.n968 0.108289
R4173 VDD.n26 VDD.n25 0.108289
R4174 VDD.n1976 VDD.n1975 0.108289
R4175 VDD.n1952 VDD.n1951 0.108289
R4176 VDD.n837 VDD.n836 0.107039
R4177 VDD.n95 VDD.n94 0.107039
R4178 VDD.n1616 VDD.n1615 0.10675
R4179 VDD.n1285 VDD.n1284 0.10675
R4180 VDD.n279 VDD.n278 0.1055
R4181 VDD.n4 VDD.n3 0.10425
R4182 VDD.n659 VDD.n658 0.10425
R4183 VDD.n338 VDD.n333 0.10425
R4184 VDD.n812 VDD.n811 0.103289
R4185 VDD.n760 VDD.n759 0.103289
R4186 VDD.n711 VDD.n710 0.103289
R4187 VDD.n788 VDD.n787 0.102039
R4188 VDD.n1841 VDD.n1840 0.102039
R4189 VDD.n786 VDD.n784 0.100789
R4190 VDD.n859 VDD.n857 0.100789
R4191 VDD.n835 VDD.n833 0.100789
R4192 VDD.n810 VDD.n808 0.100789
R4193 VDD.n93 VDD.n91 0.100789
R4194 VDD.n1891 VDD.n1889 0.100789
R4195 VDD.n1915 VDD.n1913 0.100789
R4196 VDD.n501 VDD.n499 0.100789
R4197 VDD.n486 VDD.n484 0.100789
R4198 VDD.n469 VDD.n467 0.100789
R4199 VDD.n881 VDD.n880 0.100789
R4200 VDD.n758 VDD.n756 0.100789
R4201 VDD.n734 VDD.n732 0.100789
R4202 VDD.n709 VDD.n707 0.100789
R4203 VDD.n174 VDD.n172 0.100789
R4204 VDD.n1791 VDD.n1789 0.100789
R4205 VDD.n1815 VDD.n1813 0.100789
R4206 VDD.n1863 VDD.n1861 0.100789
R4207 VDD.n1839 VDD.n1837 0.100789
R4208 VDD.n682 VDD.n680 0.100789
R4209 VDD.n199 VDD.n197 0.100789
R4210 VDD.n1641 VDD.n1639 0.100789
R4211 VDD.n1665 VDD.n1663 0.100789
R4212 VDD.n1762 VDD.n1760 0.100789
R4213 VDD.n1738 VDD.n1736 0.100789
R4214 VDD.n1713 VDD.n1711 0.100789
R4215 VDD.n1689 VDD.n1687 0.100789
R4216 VDD.n657 VDD.n655 0.100789
R4217 VDD.n227 VDD.n225 0.100789
R4218 VDD.n1614 VDD.n1612 0.100789
R4219 VDD.n1589 VDD.n1587 0.100789
R4220 VDD.n1563 VDD.n1561 0.100789
R4221 VDD.n1538 VDD.n1536 0.100789
R4222 VDD.n277 VDD.n275 0.100789
R4223 VDD.n252 VDD.n250 0.100789
R4224 VDD.n630 VDD.n628 0.100789
R4225 VDD.n606 VDD.n604 0.100789
R4226 VDD.n581 VDD.n579 0.100789
R4227 VDD.n302 VDD.n300 0.100789
R4228 VDD.n1437 VDD.n1435 0.100789
R4229 VDD.n1461 VDD.n1459 0.100789
R4230 VDD.n1509 VDD.n1507 0.100789
R4231 VDD.n1485 VDD.n1483 0.100789
R4232 VDD.n446 VDD.n444 0.100789
R4233 VDD.n328 VDD.n326 0.100789
R4234 VDD.n1283 VDD.n1281 0.100789
R4235 VDD.n1308 VDD.n1306 0.100789
R4236 VDD.n1409 VDD.n1407 0.100789
R4237 VDD.n1384 VDD.n1382 0.100789
R4238 VDD.n1358 VDD.n1356 0.100789
R4239 VDD.n1333 VDD.n1331 0.100789
R4240 VDD.n1107 VDD.n1105 0.100789
R4241 VDD.n1131 VDD.n1129 0.100789
R4242 VDD.n1254 VDD.n1252 0.100789
R4243 VDD.n1230 VDD.n1228 0.100789
R4244 VDD.n1205 VDD.n1203 0.100789
R4245 VDD.n1181 VDD.n1179 0.100789
R4246 VDD.n1155 VDD.n1153 0.100789
R4247 VDD.n63 VDD.n61 0.100789
R4248 VDD.n1079 VDD.n1077 0.100789
R4249 VDD.n1055 VDD.n1053 0.100789
R4250 VDD.n1030 VDD.n1028 0.100789
R4251 VDD.n1006 VDD.n1004 0.100789
R4252 VDD.n980 VDD.n978 0.100789
R4253 VDD.n37 VDD.n35 0.100789
R4254 VDD.n1987 VDD.n1985 0.100789
R4255 VDD.n1963 VDD.n1961 0.100789
R4256 VDD.n1565 VDD.n1564 0.1005
R4257 VDD.n1893 VDD.n1892 0.099539
R4258 VDD.n1865 VDD.n1864 0.099539
R4259 VDD.n254 VDD.n253 0.09925
R4260 VDD.n1386 VDD.n1385 0.09925
R4261 VDD.n1335 VDD.n1334 0.09925
R4262 VDD.n736 VDD.n735 0.098289
R4263 VDD.n1817 VDD.n1816 0.098289
R4264 VDD.n1032 VDD.n1031 0.098289
R4265 VDD.n780 VDD.n779 0.098
R4266 VDD.n853 VDD.n852 0.098
R4267 VDD.n829 VDD.n828 0.098
R4268 VDD.n804 VDD.n803 0.098
R4269 VDD.n87 VDD.n86 0.098
R4270 VDD.n1885 VDD.n1884 0.098
R4271 VDD.n1909 VDD.n1908 0.098
R4272 VDD.n495 VDD.n490 0.098
R4273 VDD.n884 VDD.n877 0.098
R4274 VDD.n752 VDD.n751 0.098
R4275 VDD.n728 VDD.n727 0.098
R4276 VDD.n703 VDD.n702 0.098
R4277 VDD.n168 VDD.n167 0.098
R4278 VDD.n1785 VDD.n1784 0.098
R4279 VDD.n1809 VDD.n1808 0.098
R4280 VDD.n1857 VDD.n1856 0.098
R4281 VDD.n1833 VDD.n1832 0.098
R4282 VDD.n676 VDD.n675 0.098
R4283 VDD.n193 VDD.n192 0.098
R4284 VDD.n1635 VDD.n1634 0.098
R4285 VDD.n1659 VDD.n1658 0.098
R4286 VDD.n1756 VDD.n1755 0.098
R4287 VDD.n1732 VDD.n1731 0.098
R4288 VDD.n1707 VDD.n1706 0.098
R4289 VDD.n1683 VDD.n1682 0.098
R4290 VDD.n651 VDD.n650 0.098
R4291 VDD.n221 VDD.n220 0.098
R4292 VDD.n1608 VDD.n1607 0.098
R4293 VDD.n1583 VDD.n1582 0.098
R4294 VDD.n1557 VDD.n1556 0.098
R4295 VDD.n1532 VDD.n1531 0.098
R4296 VDD.n271 VDD.n270 0.098
R4297 VDD.n246 VDD.n245 0.098
R4298 VDD.n624 VDD.n623 0.098
R4299 VDD.n600 VDD.n599 0.098
R4300 VDD.n575 VDD.n574 0.098
R4301 VDD.n296 VDD.n295 0.098
R4302 VDD.n1431 VDD.n1430 0.098
R4303 VDD.n1455 VDD.n1454 0.098
R4304 VDD.n1503 VDD.n1502 0.098
R4305 VDD.n1479 VDD.n1478 0.098
R4306 VDD.n440 VDD.n439 0.098
R4307 VDD.n322 VDD.n321 0.098
R4308 VDD.n1277 VDD.n1276 0.098
R4309 VDD.n1302 VDD.n1301 0.098
R4310 VDD.n1310 VDD.n1309 0.098
R4311 VDD.n1403 VDD.n1402 0.098
R4312 VDD.n1378 VDD.n1377 0.098
R4313 VDD.n1352 VDD.n1351 0.098
R4314 VDD.n1327 VDD.n1326 0.098
R4315 VDD.n1101 VDD.n1100 0.098
R4316 VDD.n1125 VDD.n1124 0.098
R4317 VDD.n1248 VDD.n1247 0.098
R4318 VDD.n1224 VDD.n1223 0.098
R4319 VDD.n1199 VDD.n1198 0.098
R4320 VDD.n1175 VDD.n1174 0.098
R4321 VDD.n1149 VDD.n1148 0.098
R4322 VDD.n57 VDD.n56 0.098
R4323 VDD.n1073 VDD.n1072 0.098
R4324 VDD.n1049 VDD.n1048 0.098
R4325 VDD.n1024 VDD.n1023 0.098
R4326 VDD.n1000 VDD.n999 0.098
R4327 VDD.n974 VDD.n973 0.098
R4328 VDD.n31 VDD.n30 0.098
R4329 VDD.n1981 VDD.n1980 0.098
R4330 VDD.n1957 VDD.n1956 0.098
R4331 VDD.n1917 VDD.n1916 0.097039
R4332 VDD.n1793 VDD.n1792 0.097039
R4333 VDD.n330 VDD.n329 0.09675
R4334 VDD VDD.n1999 0.0955
R4335 VDD VDD.n2015 0.0955
R4336 VDD.n352 VDD 0.0955
R4337 VDD VDD.n412 0.0955
R4338 VDD.n380 VDD.n377 0.09425
R4339 VDD.n448 VDD.n447 0.093
R4340 VDD.n1360 VDD.n1359 0.093
R4341 VDD.n1057 VDD.n1056 0.092039
R4342 VDD.n773 VDD.n772 0.090789
R4343 VDD.n846 VDD.n845 0.090789
R4344 VDD.n822 VDD.n821 0.090789
R4345 VDD.n797 VDD.n796 0.090789
R4346 VDD.n80 VDD.n79 0.090789
R4347 VDD.n1878 VDD.n1877 0.090789
R4348 VDD.n1902 VDD.n1901 0.090789
R4349 VDD.n745 VDD.n744 0.090789
R4350 VDD.n721 VDD.n720 0.090789
R4351 VDD.n696 VDD.n695 0.090789
R4352 VDD.n161 VDD.n160 0.090789
R4353 VDD.n1778 VDD.n1777 0.090789
R4354 VDD.n1802 VDD.n1801 0.090789
R4355 VDD.n1850 VDD.n1849 0.090789
R4356 VDD.n1826 VDD.n1825 0.090789
R4357 VDD.n671 VDD.n669 0.090789
R4358 VDD.n188 VDD.n186 0.090789
R4359 VDD.n1630 VDD.n1628 0.090789
R4360 VDD.n1654 VDD.n1652 0.090789
R4361 VDD.n1751 VDD.n1749 0.090789
R4362 VDD.n1727 VDD.n1725 0.090789
R4363 VDD.n1702 VDD.n1700 0.090789
R4364 VDD.n1678 VDD.n1676 0.090789
R4365 VDD.n643 VDD.n642 0.090789
R4366 VDD.n213 VDD.n212 0.090789
R4367 VDD.n1600 VDD.n1599 0.090789
R4368 VDD.n1575 VDD.n1574 0.090789
R4369 VDD.n1549 VDD.n1548 0.090789
R4370 VDD.n1524 VDD.n1523 0.090789
R4371 VDD.n263 VDD.n262 0.090789
R4372 VDD.n238 VDD.n237 0.090789
R4373 VDD.n617 VDD.n616 0.090789
R4374 VDD.n593 VDD.n592 0.090789
R4375 VDD.n568 VDD.n567 0.090789
R4376 VDD.n289 VDD.n288 0.090789
R4377 VDD.n1424 VDD.n1423 0.090789
R4378 VDD.n1448 VDD.n1447 0.090789
R4379 VDD.n1496 VDD.n1495 0.090789
R4380 VDD.n1472 VDD.n1471 0.090789
R4381 VDD.n432 VDD.n431 0.090789
R4382 VDD.n314 VDD.n313 0.090789
R4383 VDD.n1269 VDD.n1268 0.090789
R4384 VDD.n1294 VDD.n1293 0.090789
R4385 VDD.n1395 VDD.n1394 0.090789
R4386 VDD.n1370 VDD.n1369 0.090789
R4387 VDD.n1344 VDD.n1343 0.090789
R4388 VDD.n1319 VDD.n1318 0.090789
R4389 VDD.n1093 VDD.n1092 0.090789
R4390 VDD.n1118 VDD.n1117 0.090789
R4391 VDD.n1241 VDD.n1240 0.090789
R4392 VDD.n1217 VDD.n1216 0.090789
R4393 VDD.n1192 VDD.n1191 0.090789
R4394 VDD.n1167 VDD.n1166 0.090789
R4395 VDD.n1142 VDD.n1141 0.090789
R4396 VDD.n49 VDD.n48 0.090789
R4397 VDD.n1066 VDD.n1065 0.090789
R4398 VDD.n1042 VDD.n1041 0.090789
R4399 VDD.n1017 VDD.n1016 0.090789
R4400 VDD.n993 VDD.n992 0.090789
R4401 VDD.n967 VDD.n966 0.090789
R4402 VDD.n24 VDD.n23 0.090789
R4403 VDD.n1974 VDD.n1973 0.090789
R4404 VDD.n1989 VDD.n1988 0.090789
R4405 VDD.n1950 VDD.n1949 0.090789
R4406 VDD.n1487 VDD.n1486 0.089539
R4407 VDD.n1207 VDD.n1206 0.089539
R4408 VDD.n1008 VDD.n1007 0.089539
R4409 VDD.n982 VDD.n981 0.089539
R4410 VDD.n1411 VDD.n1410 0.088
R4411 VDD.n787 VDD.n767 0.087039
R4412 VDD.n860 VDD.n840 0.087039
R4413 VDD.n836 VDD.n816 0.087039
R4414 VDD.n811 VDD.n791 0.087039
R4415 VDD.n94 VDD.n74 0.087039
R4416 VDD.n1892 VDD.n1872 0.087039
R4417 VDD.n1916 VDD.n1896 0.087039
R4418 VDD.n759 VDD.n739 0.087039
R4419 VDD.n735 VDD.n715 0.087039
R4420 VDD.n710 VDD.n690 0.087039
R4421 VDD.n175 VDD.n155 0.087039
R4422 VDD.n1792 VDD.n1772 0.087039
R4423 VDD.n1816 VDD.n1796 0.087039
R4424 VDD.n1864 VDD.n1844 0.087039
R4425 VDD.n1840 VDD.n1820 0.087039
R4426 VDD.n683 VDD.n664 0.087039
R4427 VDD.n200 VDD.n181 0.087039
R4428 VDD.n1642 VDD.n1623 0.087039
R4429 VDD.n1666 VDD.n1647 0.087039
R4430 VDD.n1763 VDD.n1744 0.087039
R4431 VDD.n1739 VDD.n1720 0.087039
R4432 VDD.n1714 VDD.n1695 0.087039
R4433 VDD.n1690 VDD.n1671 0.087039
R4434 VDD.n631 VDD.n611 0.087039
R4435 VDD.n607 VDD.n587 0.087039
R4436 VDD.n582 VDD.n562 0.087039
R4437 VDD.n303 VDD.n283 0.087039
R4438 VDD.n1438 VDD.n1418 0.087039
R4439 VDD.n1462 VDD.n1442 0.087039
R4440 VDD.n1510 VDD.n1490 0.087039
R4441 VDD.n1486 VDD.n1466 0.087039
R4442 VDD.n1132 VDD.n1112 0.087039
R4443 VDD.n1255 VDD.n1235 0.087039
R4444 VDD.n1231 VDD.n1211 0.087039
R4445 VDD.n1206 VDD.n1186 0.087039
R4446 VDD.n1156 VDD.n1136 0.087039
R4447 VDD.n1080 VDD.n1060 0.087039
R4448 VDD.n1056 VDD.n1036 0.087039
R4449 VDD.n1031 VDD.n1011 0.087039
R4450 VDD.n1007 VDD.n987 0.087039
R4451 VDD.n981 VDD.n961 0.087039
R4452 VDD.n38 VDD.n18 0.087039
R4453 VDD.n1988 VDD.n1968 0.087039
R4454 VDD.n1964 VDD.n1944 0.087039
R4455 VDD.n2006 VDD.n1994 0.08675
R4456 VDD.n354 VDD.n348 0.08675
R4457 VDD.n410 VDD.n399 0.08675
R4458 VDD.n772 VDD.n771 0.085789
R4459 VDD.n845 VDD.n844 0.085789
R4460 VDD.n821 VDD.n820 0.085789
R4461 VDD.n796 VDD.n795 0.085789
R4462 VDD.n79 VDD.n78 0.085789
R4463 VDD.n1877 VDD.n1876 0.085789
R4464 VDD.n1901 VDD.n1900 0.085789
R4465 VDD.n744 VDD.n743 0.085789
R4466 VDD.n720 VDD.n719 0.085789
R4467 VDD.n695 VDD.n694 0.085789
R4468 VDD.n160 VDD.n159 0.085789
R4469 VDD.n1777 VDD.n1776 0.085789
R4470 VDD.n1801 VDD.n1800 0.085789
R4471 VDD.n1849 VDD.n1848 0.085789
R4472 VDD.n1825 VDD.n1824 0.085789
R4473 VDD.n669 VDD.n668 0.085789
R4474 VDD.n186 VDD.n185 0.085789
R4475 VDD.n1628 VDD.n1627 0.085789
R4476 VDD.n1652 VDD.n1651 0.085789
R4477 VDD.n1749 VDD.n1748 0.085789
R4478 VDD.n1725 VDD.n1724 0.085789
R4479 VDD.n1700 VDD.n1699 0.085789
R4480 VDD.n1676 VDD.n1675 0.085789
R4481 VDD.n642 VDD.n641 0.085789
R4482 VDD.n212 VDD.n211 0.085789
R4483 VDD.n1599 VDD.n1598 0.085789
R4484 VDD.n1574 VDD.n1573 0.085789
R4485 VDD.n1548 VDD.n1547 0.085789
R4486 VDD.n1523 VDD.n1522 0.085789
R4487 VDD.n262 VDD.n261 0.085789
R4488 VDD.n237 VDD.n236 0.085789
R4489 VDD.n616 VDD.n615 0.085789
R4490 VDD.n592 VDD.n591 0.085789
R4491 VDD.n567 VDD.n566 0.085789
R4492 VDD.n288 VDD.n287 0.085789
R4493 VDD.n1423 VDD.n1422 0.085789
R4494 VDD.n1447 VDD.n1446 0.085789
R4495 VDD.n1495 VDD.n1494 0.085789
R4496 VDD.n1471 VDD.n1470 0.085789
R4497 VDD.n431 VDD.n430 0.085789
R4498 VDD.n313 VDD.n312 0.085789
R4499 VDD.n1268 VDD.n1267 0.085789
R4500 VDD.n1293 VDD.n1292 0.085789
R4501 VDD.n1394 VDD.n1393 0.085789
R4502 VDD.n1369 VDD.n1368 0.085789
R4503 VDD.n1343 VDD.n1342 0.085789
R4504 VDD.n1318 VDD.n1317 0.085789
R4505 VDD.n1092 VDD.n1091 0.085789
R4506 VDD.n1117 VDD.n1116 0.085789
R4507 VDD.n1240 VDD.n1239 0.085789
R4508 VDD.n1216 VDD.n1215 0.085789
R4509 VDD.n1191 VDD.n1190 0.085789
R4510 VDD.n1166 VDD.n1165 0.085789
R4511 VDD.n1141 VDD.n1140 0.085789
R4512 VDD.n48 VDD.n47 0.085789
R4513 VDD.n1065 VDD.n1064 0.085789
R4514 VDD.n1041 VDD.n1040 0.085789
R4515 VDD.n1016 VDD.n1015 0.085789
R4516 VDD.n992 VDD.n991 0.085789
R4517 VDD.n966 VDD.n965 0.085789
R4518 VDD.n23 VDD.n22 0.085789
R4519 VDD.n1973 VDD.n1972 0.085789
R4520 VDD.n1949 VDD.n1948 0.085789
R4521 VDD.n608 VDD.n607 0.084539
R4522 VDD.n1081 VDD.n1080 0.084539
R4523 VDD.n632 VDD.n631 0.080789
R4524 VDD.n503 VDD.n490 0.0805
R4525 VDD.n890 VDD.n877 0.0805
R4526 VDD.n304 VDD.n303 0.079539
R4527 VDD.n3 VDD.n2 0.077039
R4528 VDD.n1965 VDD.n1964 0.077039
R4529 VDD.n1157 VDD.n1156 0.075789
R4530 VDD.n39 VDD.n38 0.075789
R4531 VDD.n583 VDD.n582 0.073289
R4532 VDD.n416 VDD.n394 0.07175
R4533 VDD.n407 VDD.n401 0.07175
R4534 VDD.n368 VDD.n367 0.0705
R4535 VDD.n358 VDD.n357 0.0705
R4536 VDD.n381 VDD.n374 0.0705
R4537 VDD.n1439 VDD.n1438 0.068289
R4538 VDD.n1511 VDD.n1510 0.068289
R4539 VDD.n1232 VDD.n1231 0.068289
R4540 VDD.n893 VDD.n892 0.0667075
R4541 VDD.n1256 VDD.n1255 0.065789
R4542 VDD.n349 VDD.n341 0.06425
R4543 VDD.n360 VDD.n359 0.06425
R4544 VDD.n415 VDD.n397 0.06425
R4545 VDD.n406 VDD.n403 0.06425
R4546 VDD.n2026 VDD.n2025 0.062039
R4547 VDD.n2041 VDD.n2040 0.060789
R4548 VDD.n1463 VDD.n1462 0.060789
R4549 VDD.n1133 VDD.n1132 0.060789
R4550 VDD.n338 VDD.n337 0.060789
R4551 VDD.n2004 VDD 0.0605
R4552 VDD.n2002 VDD 0.0605
R4553 VDD.n2038 VDD 0.0605
R4554 VDD.n2035 VDD 0.0605
R4555 VDD.n2021 VDD 0.0605
R4556 VDD.n2018 VDD 0.0605
R4557 VDD.n494 VDD 0.0605
R4558 VDD.n478 VDD 0.0605
R4559 VDD.n461 VDD 0.0605
R4560 VDD.n887 VDD 0.0605
R4561 VDD.n335 VDD 0.0605
R4562 VDD VDD.n351 0.0605
R4563 VDD.n362 VDD 0.0605
R4564 VDD.n385 VDD 0.0605
R4565 VDD.n378 VDD 0.0605
R4566 VDD.n413 VDD 0.0605
R4567 VDD.n404 VDD 0.0605
R4568 VDD.n2004 VDD.n2003 0.05675
R4569 VDD.n413 VDD.n397 0.05675
R4570 VDD.n404 VDD.n403 0.05675
R4571 VDD.n645 VDD.n636 0.053
R4572 VDD.n215 VDD.n206 0.053
R4573 VDD.n1602 VDD.n1593 0.053
R4574 VDD.n1577 VDD.n1568 0.053
R4575 VDD.n1551 VDD.n1542 0.053
R4576 VDD.n1526 VDD.n1517 0.053
R4577 VDD.n265 VDD.n256 0.053
R4578 VDD.n240 VDD.n231 0.053
R4579 VDD.n1463 VDD.n1441 0.053
R4580 VDD.n434 VDD.n425 0.053
R4581 VDD.n316 VDD.n307 0.053
R4582 VDD.n1271 VDD.n1262 0.053
R4583 VDD.n1296 VDD.n1287 0.053
R4584 VDD.n1397 VDD.n1388 0.053
R4585 VDD.n1372 VDD.n1363 0.053
R4586 VDD.n1346 VDD.n1337 0.053
R4587 VDD.n1321 VDD.n1312 0.053
R4588 VDD.n1095 VDD.n1086 0.053
R4589 VDD.n1133 VDD.n1111 0.053
R4590 VDD.n1169 VDD.n1160 0.053
R4591 VDD.n51 VDD.n42 0.053
R4592 VDD.n383 VDD.n374 0.0505
R4593 VDD.n339 VDD 0.0493889
R4594 VDD VDD.n5 0.0493889
R4595 VDD.n2000 VDD.n1993 0.04925
R4596 VDD.n2041 VDD.n2028 0.04925
R4597 VDD.n356 VDD.n355 0.04925
R4598 VDD.n391 VDD.n390 0.04925
R4599 VDD.n418 VDD.n394 0.04925
R4600 VDD.n409 VDD.n401 0.04925
R4601 VDD.n2026 VDD.n2008 0.048
R4602 VDD.n1256 VDD.n1234 0.048
R4603 VDD.n370 VDD.n369 0.048
R4604 VDD.n779 VDD.n778 0.0455
R4605 VDD.n852 VDD.n851 0.0455
R4606 VDD.n828 VDD.n827 0.0455
R4607 VDD.n803 VDD.n802 0.0455
R4608 VDD.n86 VDD.n85 0.0455
R4609 VDD.n1884 VDD.n1883 0.0455
R4610 VDD.n1908 VDD.n1907 0.0455
R4611 VDD.n751 VDD.n750 0.0455
R4612 VDD.n727 VDD.n726 0.0455
R4613 VDD.n702 VDD.n701 0.0455
R4614 VDD.n167 VDD.n166 0.0455
R4615 VDD.n1784 VDD.n1783 0.0455
R4616 VDD.n1808 VDD.n1807 0.0455
R4617 VDD.n1856 VDD.n1855 0.0455
R4618 VDD.n1832 VDD.n1831 0.0455
R4619 VDD.n675 VDD.n674 0.0455
R4620 VDD.n192 VDD.n191 0.0455
R4621 VDD.n1634 VDD.n1633 0.0455
R4622 VDD.n1658 VDD.n1657 0.0455
R4623 VDD.n1755 VDD.n1754 0.0455
R4624 VDD.n1731 VDD.n1730 0.0455
R4625 VDD.n1706 VDD.n1705 0.0455
R4626 VDD.n1682 VDD.n1681 0.0455
R4627 VDD.n650 VDD.n649 0.0455
R4628 VDD.n220 VDD.n219 0.0455
R4629 VDD.n1607 VDD.n1606 0.0455
R4630 VDD.n1582 VDD.n1581 0.0455
R4631 VDD.n1556 VDD.n1555 0.0455
R4632 VDD.n1531 VDD.n1530 0.0455
R4633 VDD.n270 VDD.n269 0.0455
R4634 VDD.n245 VDD.n244 0.0455
R4635 VDD.n623 VDD.n622 0.0455
R4636 VDD.n599 VDD.n598 0.0455
R4637 VDD.n574 VDD.n573 0.0455
R4638 VDD.n295 VDD.n294 0.0455
R4639 VDD.n1430 VDD.n1429 0.0455
R4640 VDD.n1439 VDD.n1417 0.0455
R4641 VDD.n1454 VDD.n1453 0.0455
R4642 VDD.n1502 VDD.n1501 0.0455
R4643 VDD.n1511 VDD.n1489 0.0455
R4644 VDD.n1478 VDD.n1477 0.0455
R4645 VDD.n439 VDD.n438 0.0455
R4646 VDD.n321 VDD.n320 0.0455
R4647 VDD.n1276 VDD.n1275 0.0455
R4648 VDD.n1301 VDD.n1300 0.0455
R4649 VDD.n1402 VDD.n1401 0.0455
R4650 VDD.n1377 VDD.n1376 0.0455
R4651 VDD.n1351 VDD.n1350 0.0455
R4652 VDD.n1326 VDD.n1325 0.0455
R4653 VDD.n1100 VDD.n1099 0.0455
R4654 VDD.n1124 VDD.n1123 0.0455
R4655 VDD.n1247 VDD.n1246 0.0455
R4656 VDD.n1223 VDD.n1222 0.0455
R4657 VDD.n1232 VDD.n1210 0.0455
R4658 VDD.n1198 VDD.n1197 0.0455
R4659 VDD.n1174 VDD.n1173 0.0455
R4660 VDD.n1148 VDD.n1147 0.0455
R4661 VDD.n56 VDD.n55 0.0455
R4662 VDD.n1072 VDD.n1071 0.0455
R4663 VDD.n1048 VDD.n1047 0.0455
R4664 VDD.n1023 VDD.n1022 0.0455
R4665 VDD.n999 VDD.n998 0.0455
R4666 VDD.n973 VDD.n972 0.0455
R4667 VDD.n30 VDD.n29 0.0455
R4668 VDD.n1980 VDD.n1979 0.0455
R4669 VDD.n1956 VDD.n1955 0.0455
R4670 VDD.n583 VDD.n561 0.0405
R4671 VDD.n488 VDD.n487 0.03925
R4672 VDD.n471 VDD.n470 0.03925
R4673 VDD.n1157 VDD.n1135 0.038
R4674 VDD.n39 VDD.n17 0.038
R4675 VDD.n1965 VDD.n1943 0.03675
R4676 VDD.n1999 VDD.n1998 0.03425
R4677 VDD.n2002 VDD.n1994 0.03425
R4678 VDD.n2035 VDD.n2029 0.03425
R4679 VDD.n2015 VDD.n2014 0.03425
R4680 VDD.n2018 VDD.n2009 0.03425
R4681 VDD.n304 VDD.n282 0.03425
R4682 VDD.n352 VDD.n348 0.03425
R4683 VDD.n412 VDD.n399 0.03425
R4684 VDD.n632 VDD.n610 0.033
R4685 VDD.n1411 VDD.n1388 0.033
R4686 VDD.n2037 VDD.n2036 0.0305
R4687 VDD.n2023 VDD.n2022 0.0305
R4688 VDD.n2020 VDD.n2019 0.0305
R4689 VDD.n350 VDD.n349 0.0305
R4690 VDD.n361 VDD.n360 0.0305
R4691 VDD.n387 VDD.n386 0.0305
R4692 VDD.n608 VDD.n586 0.02925
R4693 VDD.n1081 VDD.n1059 0.02925
R4694 VDD.n448 VDD.n425 0.028
R4695 VDD.n1360 VDD.n1337 0.028
R4696 VDD.n2038 VDD.n2037 0.02675
R4697 VDD.n2021 VDD.n2020 0.02675
R4698 VDD.n658 VDD.n637 0.02675
R4699 VDD.n228 VDD.n207 0.02675
R4700 VDD.n1615 VDD.n1594 0.02675
R4701 VDD.n1590 VDD.n1569 0.02675
R4702 VDD.n1564 VDD.n1543 0.02675
R4703 VDD.n1539 VDD.n1518 0.02675
R4704 VDD.n278 VDD.n257 0.02675
R4705 VDD.n253 VDD.n232 0.02675
R4706 VDD.n447 VDD.n426 0.02675
R4707 VDD.n329 VDD.n308 0.02675
R4708 VDD.n1284 VDD.n1263 0.02675
R4709 VDD.n1309 VDD.n1288 0.02675
R4710 VDD.n1410 VDD.n1389 0.02675
R4711 VDD.n1385 VDD.n1364 0.02675
R4712 VDD.n1359 VDD.n1338 0.02675
R4713 VDD.n1334 VDD.n1313 0.02675
R4714 VDD.n1108 VDD.n1087 0.02675
R4715 VDD.n1182 VDD.n1161 0.02675
R4716 VDD.n64 VDD.n43 0.02675
R4717 VDD.n351 VDD.n350 0.02675
R4718 VDD.n362 VDD.n361 0.02675
R4719 VDD.n386 VDD.n385 0.02675
R4720 VDD.n378 VDD.n377 0.02675
R4721 VDD.n494 VDD.n492 0.0255
R4722 VDD.n480 VDD.n478 0.0255
R4723 VDD.n463 VDD.n461 0.0255
R4724 VDD.n888 VDD.n887 0.0255
R4725 VDD.n1487 VDD.n1465 0.02425
R4726 VDD.n330 VDD.n307 0.02425
R4727 VDD.n1207 VDD.n1185 0.02425
R4728 VDD.n1008 VDD.n986 0.02425
R4729 VDD.n982 VDD.n960 0.02425
R4730 VDD.n487 VDD.n476 0.023
R4731 VDD.n470 VDD.n459 0.023
R4732 VDD.n1310 VDD.n1287 0.023
R4733 VDD.n1989 VDD.n1967 0.023
R4734 VDD.n254 VDD.n231 0.02175
R4735 VDD.n1386 VDD.n1363 0.02175
R4736 VDD.n1335 VDD.n1312 0.02175
R4737 VDD.n1057 VDD.n1035 0.02175
R4738 VDD.n1565 VDD.n1542 0.0205
R4739 VDD.n1644 VDD.n1643 0.01925
R4740 VDD.n1741 VDD.n1740 0.01925
R4741 VDD.n1917 VDD.n1895 0.01675
R4742 VDD.n1793 VDD.n1771 0.01675
R4743 VDD.n1716 VDD.n1715 0.01675
R4744 VDD.n659 VDD.n636 0.01675
R4745 VDD.n736 VDD.n714 0.0155
R4746 VDD.n1817 VDD.n1795 0.0155
R4747 VDD.n1668 VDD.n1667 0.0155
R4748 VDD.n279 VDD.n256 0.0155
R4749 VDD.n1032 VDD.n1010 0.0155
R4750 VDD.n951 VDD 0.0149321
R4751 VDD.n1893 VDD.n1871 0.01425
R4752 VDD.n1865 VDD.n1843 0.01425
R4753 VDD.n202 VDD.n201 0.01425
R4754 VDD.n1616 VDD.n1593 0.01425
R4755 VDD.n1285 VDD.n1262 0.01425
R4756 VDD.n788 VDD.n766 0.01175
R4757 VDD.n1841 VDD.n1819 0.01175
R4758 VDD.n685 VDD.n684 0.01175
R4759 VDD.n812 VDD.n790 0.0105
R4760 VDD.n760 VDD.n738 0.0105
R4761 VDD.n711 VDD.n689 0.0105
R4762 VDD.n336 VDD.n335 0.0105
R4763 VDD.n1765 VDD.n1764 0.00925
R4764 VDD.n524 VDD.n507 0.00849846
R4765 VDD.n534 VDD.n509 0.00849846
R4766 VDD.n948 VDD.n916 0.00849846
R4767 VDD.n927 VDD.n914 0.00849846
R4768 VDD.n534 VDD.n513 0.00849846
R4769 VDD.n948 VDD.n922 0.00849846
R4770 VDD.n524 VDD.n516 0.00849846
R4771 VDD.n928 VDD.n927 0.00849846
R4772 VDD.n146 VDD.n133 0.00849539
R4773 VDD.n135 VDD.n101 0.00849539
R4774 VDD.n2080 VDD.n2061 0.00849539
R4775 VDD.n2072 VDD.n2063 0.00849539
R4776 VDD.n2073 VDD.n2072 0.00849539
R4777 VDD.n141 VDD.n101 0.00849539
R4778 VDD.n2081 VDD.n2080 0.00849539
R4779 VDD.n147 VDD.n146 0.00849539
R4780 VDD.n229 VDD.n206 0.008
R4781 VDD.n1540 VDD.n1517 0.008
R4782 VDD.n1183 VDD.n1160 0.008
R4783 VDD.n932 VDD.n903 0.00752076
R4784 VDD.n942 VDD.n911 0.00752076
R4785 VDD.n2050 VDD.n11 0.00752076
R4786 VDD.n2087 VDD.n2057 0.00752076
R4787 VDD.n540 VDD.n522 0.00752076
R4788 VDD.n555 VDD.n547 0.00752076
R4789 VDD.n115 VDD.n109 0.00752076
R4790 VDD.n129 VDD.n122 0.00752076
R4791 VDD.n2051 VDD.n2050 0.00752076
R4792 VDD.n116 VDD.n115 0.00752076
R4793 VDD.n2087 VDD.n9 0.00752076
R4794 VDD.n129 VDD.n107 0.00752076
R4795 VDD.n541 VDD.n540 0.00752076
R4796 VDD.n932 VDD.n908 0.00752076
R4797 VDD.n555 VDD.n520 0.00752076
R4798 VDD.n942 VDD.n910 0.00752076
R4799 VDD.n837 VDD.n815 0.00675
R4800 VDD.n95 VDD.n73 0.00675
R4801 VDD.n1591 VDD.n1568 0.00675
R4802 VDD.n861 VDD.n839 0.0055
R4803 VDD.n2007 VDD.n1993 0.0055
R4804 VDD.n1109 VDD.n1086 0.0055
R4805 VDD.n419 VDD.n418 0.0055
R4806 VDD.n176 VDD.n154 0.00425
R4807 VDD.n1692 VDD.n1691 0.00425
R4808 VDD.n559 VDD.n530 0.00396371
R4809 VDD.n557 VDD.n556 0.00396371
R4810 VDD.n944 VDD.n929 0.00396371
R4811 VDD.n951 VDD.n936 0.00396371
R4812 VDD.n150 VDD.n112 0.0039623
R4813 VDD.n131 VDD.n104 0.0039623
R4814 VDD.n2093 VDD.n14 0.0039623
R4815 VDD.n2090 VDD.n2089 0.0039623
R4816 VDD.n65 VDD.n42 0.003
R4817 VDD.n556 VDD.n550 0.00273152
R4818 VDD.n532 VDD.n507 0.00273152
R4819 VDD.n525 VDD.n508 0.00273152
R4820 VDD.n533 VDD.n508 0.00273152
R4821 VDD.n526 VDD.n509 0.00273152
R4822 VDD.n527 VDD.n510 0.00273152
R4823 VDD.n535 VDD.n510 0.00273152
R4824 VDD.n528 VDD.n511 0.00273152
R4825 VDD.n536 VDD.n511 0.00273152
R4826 VDD.n918 VDD.n906 0.00273152
R4827 VDD.n919 VDD.n918 0.00273152
R4828 VDD.n949 VDD.n917 0.00273152
R4829 VDD.n921 VDD.n917 0.00273152
R4830 VDD.n923 VDD.n916 0.00273152
R4831 VDD.n947 VDD.n915 0.00273152
R4832 VDD.n925 VDD.n915 0.00273152
R4833 VDD.n946 VDD.n914 0.00273152
R4834 VDD.n945 VDD.n944 0.00273152
R4835 VDD.n536 VDD.n457 0.00273152
R4836 VDD.n535 VDD.n512 0.00273152
R4837 VDD.n533 VDD.n514 0.00273152
R4838 VDD.n532 VDD.n515 0.00273152
R4839 VDD.n550 VDD.n516 0.00273152
R4840 VDD.n953 VDD.n906 0.00273152
R4841 VDD.n949 VDD.n920 0.00273152
R4842 VDD.n947 VDD.n924 0.00273152
R4843 VDD.n946 VDD.n926 0.00273152
R4844 VDD.n945 VDD.n928 0.00273152
R4845 VDD.n528 VDD.n512 0.00273152
R4846 VDD.n527 VDD.n513 0.00273152
R4847 VDD.n526 VDD.n514 0.00273152
R4848 VDD.n525 VDD.n515 0.00273152
R4849 VDD.n920 VDD.n919 0.00273152
R4850 VDD.n922 VDD.n921 0.00273152
R4851 VDD.n924 VDD.n923 0.00273152
R4852 VDD.n926 VDD.n925 0.00273152
R4853 VDD.n557 VDD.n517 0.00273152
R4854 VDD.n935 VDD.n929 0.00273152
R4855 VDD.n530 VDD.n517 0.00273152
R4856 VDD.n936 VDD.n935 0.00273152
R4857 VDD.n148 VDD.n104 0.00273081
R4858 VDD.n2091 VDD.n2090 0.00273081
R4859 VDD.n2091 VDD.n14 0.00273081
R4860 VDD.n148 VDD.n112 0.00273081
R4861 VDD.n131 VDD.n98 0.00273081
R4862 VDD.n133 VDD.n99 0.00273081
R4863 VDD.n144 VDD.n134 0.00273081
R4864 VDD.n134 VDD.n100 0.00273081
R4865 VDD.n142 VDD.n135 0.00273081
R4866 VDD.n140 VDD.n136 0.00273081
R4867 VDD.n136 VDD.n102 0.00273081
R4868 VDD.n138 VDD.n137 0.00273081
R4869 VDD.n137 VDD.n103 0.00273081
R4870 VDD.n2089 VDD.n2082 0.00273081
R4871 VDD.n2078 VDD.n2061 0.00273081
R4872 VDD.n2077 VDD.n2062 0.00273081
R4873 VDD.n2075 VDD.n2062 0.00273081
R4874 VDD.n2074 VDD.n2063 0.00273081
R4875 VDD.n2071 VDD.n2064 0.00273081
R4876 VDD.n2069 VDD.n2064 0.00273081
R4877 VDD.n2068 VDD.n2065 0.00273081
R4878 VDD.n2066 VDD.n2065 0.00273081
R4879 VDD.n2067 VDD.n2066 0.00273081
R4880 VDD.n2070 VDD.n2069 0.00273081
R4881 VDD.n2076 VDD.n2075 0.00273081
R4882 VDD.n2079 VDD.n2078 0.00273081
R4883 VDD.n2082 VDD.n2081 0.00273081
R4884 VDD.n103 VDD.n72 0.00273081
R4885 VDD.n139 VDD.n102 0.00273081
R4886 VDD.n143 VDD.n100 0.00273081
R4887 VDD.n145 VDD.n99 0.00273081
R4888 VDD.n147 VDD.n98 0.00273081
R4889 VDD.n2070 VDD.n2068 0.00273081
R4890 VDD.n2073 VDD.n2071 0.00273081
R4891 VDD.n2076 VDD.n2074 0.00273081
R4892 VDD.n2079 VDD.n2077 0.00273081
R4893 VDD.n139 VDD.n138 0.00273081
R4894 VDD.n141 VDD.n140 0.00273081
R4895 VDD.n143 VDD.n142 0.00273081
R4896 VDD.n145 VDD.n144 0.00273081
R4897 VDD.n937 VDD.n907 0.00250563
R4898 VDD.n939 VDD.n905 0.00250563
R4899 VDD.n933 VDD.n904 0.00250563
R4900 VDD.n940 VDD.n908 0.00250563
R4901 VDD.n941 VDD.n909 0.00250563
R4902 VDD.n931 VDD.n902 0.00250563
R4903 VDD.n938 VDD.n901 0.00250563
R4904 VDD.n934 VDD.n910 0.00250563
R4905 VDD.n930 VDD.n900 0.00250563
R4906 VDD.n952 VDD.n912 0.00250563
R4907 VDD.n913 VDD.n899 0.00250563
R4908 VDD.n943 VDD.n423 0.00250563
R4909 VDD.n2046 VDD.n13 0.00250563
R4910 VDD.n2083 VDD.n2049 0.00250563
R4911 VDD.n2048 VDD.n12 0.00250563
R4912 VDD.n2084 VDD.n2051 0.00250563
R4913 VDD.n2085 VDD.n2053 0.00250563
R4914 VDD.n2052 VDD.n10 0.00250563
R4915 VDD.n2086 VDD.n2055 0.00250563
R4916 VDD.n2054 VDD.n9 0.00250563
R4917 VDD.n2056 VDD.n8 0.00250563
R4918 VDD.n2088 VDD.n2059 0.00250563
R4919 VDD.n2058 VDD.n7 0.00250563
R4920 VDD.n2092 VDD.n2060 0.00250563
R4921 VDD.n531 VDD.n529 0.00250563
R4922 VDD.n551 VDD.n539 0.00250563
R4923 VDD.n538 VDD.n523 0.00250563
R4924 VDD.n552 VDD.n541 0.00250563
R4925 VDD.n553 VDD.n543 0.00250563
R4926 VDD.n542 VDD.n521 0.00250563
R4927 VDD.n554 VDD.n545 0.00250563
R4928 VDD.n544 VDD.n520 0.00250563
R4929 VDD.n546 VDD.n519 0.00250563
R4930 VDD.n558 VDD.n548 0.00250563
R4931 VDD.n549 VDD.n518 0.00250563
R4932 VDD.n560 VDD.n506 0.00250563
R4933 VDD.n111 VDD.n97 0.00250563
R4934 VDD.n125 VDD.n114 0.00250563
R4935 VDD.n113 VDD.n110 0.00250563
R4936 VDD.n126 VDD.n116 0.00250563
R4937 VDD.n127 VDD.n118 0.00250563
R4938 VDD.n117 VDD.n108 0.00250563
R4939 VDD.n128 VDD.n120 0.00250563
R4940 VDD.n119 VDD.n107 0.00250563
R4941 VDD.n121 VDD.n106 0.00250563
R4942 VDD.n130 VDD.n124 0.00250563
R4943 VDD.n123 VDD.n105 0.00250563
R4944 VDD.n149 VDD.n132 0.00250563
R4945 VDD.n2047 VDD.n2046 0.00250563
R4946 VDD.n151 VDD.n97 0.00250563
R4947 VDD.n2083 VDD.n13 0.00250563
R4948 VDD.n125 VDD.n111 0.00250563
R4949 VDD.n2049 VDD.n2048 0.00250563
R4950 VDD.n114 VDD.n113 0.00250563
R4951 VDD.n2084 VDD.n12 0.00250563
R4952 VDD.n126 VDD.n110 0.00250563
R4953 VDD.n2085 VDD.n11 0.00250563
R4954 VDD.n127 VDD.n109 0.00250563
R4955 VDD.n2053 VDD.n2052 0.00250563
R4956 VDD.n118 VDD.n117 0.00250563
R4957 VDD.n2086 VDD.n10 0.00250563
R4958 VDD.n128 VDD.n108 0.00250563
R4959 VDD.n2055 VDD.n2054 0.00250563
R4960 VDD.n120 VDD.n119 0.00250563
R4961 VDD.n2057 VDD.n2056 0.00250563
R4962 VDD.n122 VDD.n121 0.00250563
R4963 VDD.n2088 VDD.n8 0.00250563
R4964 VDD.n130 VDD.n106 0.00250563
R4965 VDD.n2059 VDD.n2058 0.00250563
R4966 VDD.n124 VDD.n123 0.00250563
R4967 VDD.n2060 VDD.n7 0.00250563
R4968 VDD.n132 VDD.n105 0.00250563
R4969 VDD.n537 VDD.n531 0.00250563
R4970 VDD.n950 VDD.n937 0.00250563
R4971 VDD.n551 VDD.n529 0.00250563
R4972 VDD.n539 VDD.n538 0.00250563
R4973 VDD.n933 VDD.n905 0.00250563
R4974 VDD.n939 VDD.n907 0.00250563
R4975 VDD.n552 VDD.n523 0.00250563
R4976 VDD.n940 VDD.n904 0.00250563
R4977 VDD.n553 VDD.n522 0.00250563
R4978 VDD.n941 VDD.n903 0.00250563
R4979 VDD.n543 VDD.n542 0.00250563
R4980 VDD.n931 VDD.n909 0.00250563
R4981 VDD.n554 VDD.n521 0.00250563
R4982 VDD.n938 VDD.n902 0.00250563
R4983 VDD.n545 VDD.n544 0.00250563
R4984 VDD.n934 VDD.n901 0.00250563
R4985 VDD.n547 VDD.n546 0.00250563
R4986 VDD.n930 VDD.n911 0.00250563
R4987 VDD.n548 VDD.n519 0.00250563
R4988 VDD.n912 VDD.n900 0.00250563
R4989 VDD.n558 VDD.n549 0.00250563
R4990 VDD.n952 VDD.n913 0.00250563
R4991 VDD.n518 VDD.n506 0.00250563
R4992 VDD.n943 VDD.n899 0.00250563
R4993 VDD.n2033 VDD.n2028 0.00175
R4994 VDD.n2012 VDD.n2011 0.00175
R4995 VDD.n2016 VDD.n2008 0.00175
R4996 VDD.n370 VDD.n340 0.00175
R4997 VDD.n369 VDD.n368 0.00175
R4998 VDD.n357 VDD.n356 0.00175
R4999 VDD.n390 VDD.n389 0.00175
R5000 VDD.n364 VDD.n347 0.00166667
R5001 VDD.n382 VDD.n376 0.00166667
R5002 VDD.n408 VDD.n402 0.00166667
R5003 VDD.n364 VDD.n363 0.00133332
R5004 VDD.n379 VDD.n376 0.00133332
R5005 VDD.n405 VDD.n402 0.00133332
R5006 VDD.n366 VDD.n343 0.001
R5007 VDD.n366 VDD.n365 0.001
R5008 VDD.n345 VDD.n344 0.001
R5009 VDD.n353 VDD.n346 0.001
R5010 VDD.n365 VDD.n344 0.001
R5011 VDD.n353 VDD.n345 0.001
R5012 VDD.n347 VDD.n346 0.001
R5013 VDD.n382 VDD.n375 0.001
R5014 VDD.n375 VDD.n373 0.001
R5015 VDD.n417 VDD.n395 0.001
R5016 VDD.n417 VDD.n396 0.001
R5017 VDD.n414 VDD.n398 0.001
R5018 VDD.n411 VDD.n400 0.001
R5019 VDD.n414 VDD.n396 0.001
R5020 VDD.n411 VDD.n398 0.001
R5021 VDD.n408 VDD.n400 0.001
R5022 VSS.n6197 VSS.n145 1.75605e+06
R5023 VSS.n2282 VSS.n2281 1.44511e+06
R5024 VSS.n3519 VSS.n3511 1.44511e+06
R5025 VSS.n4192 VSS.n1193 1.44511e+06
R5026 VSS.n5404 VSS.n5403 1.44511e+06
R5027 VSS.n5386 VSS.n1176 1.44511e+06
R5028 VSS.n5374 VSS.n5373 1.44511e+06
R5029 VSS.n145 VSS.t2040 897166
R5030 VSS.n2282 VSS.t2236 260638
R5031 VSS.n3511 VSS.t2208 260638
R5032 VSS.t2180 VSS.n1193 260638
R5033 VSS.n5404 VSS.t2152 260638
R5034 VSS.t2124 VSS.n1176 260638
R5035 VSS.n5373 VSS.t2096 260638
R5036 VSS.n6174 VSS.n174 240065
R5037 VSS.n5996 VSS.n5995 240065
R5038 VSS.n4612 VSS.n4611 240065
R5039 VSS.n4540 VSS.n4539 240065
R5040 VSS.n4499 VSS.n4498 240065
R5041 VSS.n4496 VSS.n4495 240065
R5042 VSS.n213 VSS.n176 240065
R5043 VSS.n2065 VSS.n1982 56623
R5044 VSS.t1796 VSS.n174 50839.6
R5045 VSS.n4611 VSS.t2979 50839.6
R5046 VSS.n4539 VSS.t2856 50839.6
R5047 VSS.n4499 VSS.t3385 50839.6
R5048 VSS.n4495 VSS.t1278 50839.6
R5049 VSS.n213 VSS.t1536 50839.6
R5050 VSS.n5996 VSS.t2068 50839.6
R5051 VSS.n143 VSS.n61 36575.3
R5052 VSS.t2029 VSS.t2521 32813.7
R5053 VSS.n144 VSS.n96 32228.8
R5054 VSS.n299 VSS.n90 32228.8
R5055 VSS.n6171 VSS.n84 32228.8
R5056 VSS.n4491 VSS.n78 32228.8
R5057 VSS.n4510 VSS.n72 32228.8
R5058 VSS.n4535 VSS.n66 32228.8
R5059 VSS.n4607 VSS.n64 31050
R5060 VSS.n2065 VSS.n2064 29756.3
R5061 VSS.n6231 VSS.n64 29250
R5062 VSS.n3574 VSS.n1982 20604.7
R5063 VSS.n6198 VSS.n6197 17719.2
R5064 VSS.n6196 VSS.n6195 17044.3
R5065 VSS.n158 VSS.n146 17044.3
R5066 VSS.n6197 VSS.n6196 14495.7
R5067 VSS.n6175 VSS.n140 9834.22
R5068 VSS.n145 VSS.n143 7655.25
R5069 VSS.t381 VSS.n63 7130.77
R5070 VSS.n2283 VSS.n2282 6688.41
R5071 VSS.n3511 VSS.n2220 6688.41
R5072 VSS.n3043 VSS.n1193 6688.41
R5073 VSS.n5405 VSS.n5404 6688.41
R5074 VSS.n4822 VSS.n1176 6688.41
R5075 VSS.n5373 VSS.n4761 6688.41
R5076 VSS.n143 VSS.t2588 6441.18
R5077 VSS.n6232 VSS.n6231 6215.38
R5078 VSS.n6176 VSS.n6175 5254.29
R5079 VSS.n4280 VSS.n4279 4957.58
R5080 VSS.n3956 VSS.n3955 4957.58
R5081 VSS.n3889 VSS.n3888 4957.58
R5082 VSS.n3682 VSS.n3681 4957.58
R5083 VSS.n3822 VSS.n3821 4957.58
R5084 VSS.n3774 VSS.n3773 4957.58
R5085 VSS.n3726 VSS.n3725 4957.58
R5086 VSS.n2350 VSS.n2349 4957.58
R5087 VSS.n2581 VSS.n2580 4957.58
R5088 VSS.n5971 VSS.n5970 4957.58
R5089 VSS.n5901 VSS.n5900 4957.58
R5090 VSS.n654 VSS.n653 4957.58
R5091 VSS.n5692 VSS.n5691 4957.58
R5092 VSS.n5786 VSS.n5785 4957.58
R5093 VSS.n483 VSS.n482 4957.58
R5094 VSS.n557 VSS.n556 4957.58
R5095 VSS.n5228 VSS.n5227 4957.58
R5096 VSS.n5180 VSS.n5179 4957.58
R5097 VSS.n5113 VSS.n5112 4957.58
R5098 VSS.n4955 VSS.n4954 4957.58
R5099 VSS.n5046 VSS.n5045 4957.58
R5100 VSS.n5302 VSS.n5301 4957.58
R5101 VSS.n5554 VSS.n5553 4957.58
R5102 VSS.n879 VSS.n878 4957.58
R5103 VSS.n5506 VSS.n5505 4957.58
R5104 VSS.n1104 VSS.n1103 4957.58
R5105 VSS.n1036 VSS.n1035 4957.58
R5106 VSS.n969 VSS.n968 4957.58
R5107 VSS.n1743 VSS.n1742 4957.58
R5108 VSS.n1435 VSS.n1434 4957.58
R5109 VSS.n1528 VSS.n1527 4957.58
R5110 VSS.n1676 VSS.n1675 4957.58
R5111 VSS.n1601 VSS.n1600 4957.58
R5112 VSS.n4101 VSS.n4100 4957.58
R5113 VSS.n4177 VSS.n4176 4957.58
R5114 VSS.n2950 VSS.n2949 4957.58
R5115 VSS.n3303 VSS.n3302 4957.58
R5116 VSS.n3104 VSS.n3103 4957.58
R5117 VSS.n3175 VSS.n3174 4957.58
R5118 VSS.n3239 VSS.n3238 4957.58
R5119 VSS.n3284 VSS.n3283 4957.58
R5120 VSS.n1473 VSS.n1472 4957.58
R5121 VSS.n917 VSS.n916 4957.58
R5122 VSS.n4993 VSS.n4992 4957.58
R5123 VSS.n2509 VSS.n2508 4957.58
R5124 VSS.n3395 VSS.n3394 4957.58
R5125 VSS.n2435 VSS.n2434 4957.58
R5126 VSS.n3455 VSS.n3454 4957.58
R5127 VSS.n2204 VSS.n2203 4957.58
R5128 VSS.n3593 VSS.n3592 4522.42
R5129 VSS.n6231 VSS.n63 4246.15
R5130 VSS.n173 VSS.n172 3975.7
R5131 VSS.n289 VSS.n174 3898.59
R5132 VSS.n4611 VSS.n4542 3898.59
R5133 VSS.n4539 VSS.n4291 3898.59
R5134 VSS.n4500 VSS.n4499 3898.59
R5135 VSS.n4495 VSS.n4418 3898.59
R5136 VSS.n214 VSS.n213 3898.59
R5137 VSS.n5997 VSS.n5996 3898.59
R5138 VSS.n144 VSS.t890 3382.35
R5139 VSS.n4241 VSS.t234 2987.47
R5140 VSS.n6175 VSS.n173 2762.2
R5141 VSS.t2025 VSS.t2031 2676.47
R5142 VSS.t2023 VSS.t2041 2470.59
R5143 VSS.t3684 VSS.t2038 2372.55
R5144 VSS.t2034 VSS.t3945 2372.55
R5145 VSS.t2041 VSS.t3684 2156.86
R5146 VSS.t3947 VSS.t2035 2137.25
R5147 VSS.n4614 VSS.n4242 2095.39
R5148 VSS.n2038 VSS.t3584 2080.85
R5149 VSS.t2039 VSS.t2049 2058.82
R5150 VSS.t2048 VSS.t2051 2000
R5151 VSS.t2043 VSS.t2044 2000
R5152 VSS.t234 VSS.t112 2000
R5153 VSS.n2037 VSS.t4324 1991.49
R5154 VSS.n2065 VSS.t3692 1991.49
R5155 VSS.n2065 VSS.t3620 1991.49
R5156 VSS.n6230 VSS.n6229 1991.3
R5157 VSS.n6232 VSS.t112 1946.15
R5158 VSS.n6231 VSS.n100 1861.54
R5159 VSS.n6231 VSS.n94 1861.54
R5160 VSS.n6231 VSS.n88 1861.54
R5161 VSS.n6231 VSS.n82 1861.54
R5162 VSS.n6231 VSS.n76 1861.54
R5163 VSS.n6231 VSS.n70 1861.54
R5164 VSS.t2040 VSS.t2037 1509.8
R5165 VSS.n6231 VSS.n61 1492.02
R5166 VSS.t2053 VSS.n144 1480.39
R5167 VSS.n6175 VSS.n6174 1458.69
R5168 VSS.n3593 VSS.n1921 1346.35
R5169 VSS.n177 VSS.n173 1294.29
R5170 VSS.n64 VSS.t381 1253.85
R5171 VSS.n3465 VSS.n1982 1227.25
R5172 VSS.t2035 VSS.t3946 1137.25
R5173 VSS.t2024 VSS.t2025 1137.25
R5174 VSS.n4729 VSS.t2600 1114.58
R5175 VSS.t1776 VSS.t2024 1068.63
R5176 VSS.n4729 VSS.t2531 1062.91
R5177 VSS.t2038 VSS.t2039 1049.02
R5178 VSS.t3944 VSS.t2033 1019.61
R5179 VSS.n4242 VSS.n4241 1015.11
R5180 VSS.n4614 VSS.n4613 1005.13
R5181 VSS.n3512 VSS.n1185 1001.06
R5182 VSS.n1190 VSS.n1165 1001.06
R5183 VSS.n5391 VSS.n5390 1001.06
R5184 VSS.n5379 VSS.n5378 1001.06
R5185 VSS.n4729 VSS.t3049 1000
R5186 VSS.t2051 VSS.t2053 1000
R5187 VSS.t2046 VSS.t2048 1000
R5188 VSS.t2044 VSS.t2046 1000
R5189 VSS.t2049 VSS.t3949 1000
R5190 VSS.t3945 VSS.t3944 1000
R5191 VSS.t2521 VSS.t1776 1000
R5192 VSS.t2027 VSS.t2029 1000
R5193 VSS.t2588 VSS.t2027 1000
R5194 VSS.n6239 VSS.n6 997.088
R5195 VSS.n4729 VSS.t3343 955.357
R5196 VSS.n4729 VSS.t3341 955.357
R5197 VSS.n4280 VSS.t3181 945.456
R5198 VSS.n3956 VSS.t2659 945.456
R5199 VSS.n3889 VSS.t1450 945.456
R5200 VSS.n3682 VSS.t1964 945.456
R5201 VSS.n3822 VSS.t1705 945.456
R5202 VSS.n3774 VSS.t1151 945.456
R5203 VSS.n3726 VSS.t3250 945.456
R5204 VSS.n2350 VSS.t1187 945.456
R5205 VSS.n2581 VSS.t1731 945.456
R5206 VSS.n5971 VSS.t2317 945.456
R5207 VSS.n5901 VSS.t2744 945.456
R5208 VSS.n654 VSS.t8 945.456
R5209 VSS.n5692 VSS.t1319 945.456
R5210 VSS.n5786 VSS.t1568 945.456
R5211 VSS.n483 VSS.t1829 945.456
R5212 VSS.n557 VSS.t4298 945.456
R5213 VSS.n5228 VSS.t2863 945.456
R5214 VSS.n5180 VSS.t21 945.456
R5215 VSS.n5113 VSS.t1596 945.456
R5216 VSS.n4955 VSS.t1856 945.456
R5217 VSS.n5046 VSS.t1344 945.456
R5218 VSS.n5302 VSS.t2712 945.456
R5219 VSS.n5554 VSS.t3403 945.456
R5220 VSS.n879 VSS.t49 945.456
R5221 VSS.n5506 VSS.t1623 945.456
R5222 VSS.n1104 VSS.t1882 945.456
R5223 VSS.n1036 VSS.t1368 945.456
R5224 VSS.n969 VSS.t2697 945.456
R5225 VSS.n1743 VSS.t3223 945.456
R5226 VSS.n1435 VSS.t77 945.456
R5227 VSS.n1528 VSS.t1649 945.456
R5228 VSS.n1676 VSS.t1910 945.456
R5229 VSS.n1601 VSS.t1396 945.456
R5230 VSS.n4101 VSS.t2948 945.456
R5231 VSS.n4177 VSS.t2717 945.456
R5232 VSS.n2950 VSS.t1107 945.456
R5233 VSS.n3303 VSS.t1677 945.456
R5234 VSS.n3104 VSS.t1937 945.456
R5235 VSS.n3175 VSS.t1422 945.456
R5236 VSS.n3239 VSS.t2614 945.456
R5237 VSS.n3284 VSS.t2476 945.456
R5238 VSS.n1473 VSS.t4090 945.456
R5239 VSS.n917 VSS.t4228 945.456
R5240 VSS.n4993 VSS.t2920 945.456
R5241 VSS.n2509 VSS.t1995 945.456
R5242 VSS.n3395 VSS.t1480 945.456
R5243 VSS.n2435 VSS.t2456 945.456
R5244 VSS.n3455 VSS.t2734 945.456
R5245 VSS.n2204 VSS.t2487 945.456
R5246 VSS.n3524 VSS.n3523 935.976
R5247 VSS.t2033 VSS.n61 901.962
R5248 VSS.n4730 VSS.n4242 890.223
R5249 VSS.t2040 VSS.t2023 884.394
R5250 VSS.t3946 VSS.t2034 823.529
R5251 VSS.n6202 VSS.t2016 786.492
R5252 VSS.n142 VSS.t2020 737.968
R5253 VSS.t2014 VSS.n6200 721.926
R5254 VSS.t4245 VSS.n6199 673.798
R5255 VSS.t2021 VSS.n140 641.712
R5256 VSS.n4731 VSS.n4730 634.553
R5257 VSS.t2018 VSS.n139 633.691
R5258 VSS.t2316 VSS.n6198 625.668
R5259 VSS.t2037 VSS.t3947 617.648
R5260 VSS.t3949 VSS.t2043 607.843
R5261 VSS.n6202 VSS.t2586 602
R5262 VSS.n6231 VSS.n96 571.332
R5263 VSS.n6231 VSS.n90 571.332
R5264 VSS.n6231 VSS.n84 571.332
R5265 VSS.n6231 VSS.n78 571.332
R5266 VSS.n6231 VSS.n72 571.332
R5267 VSS.n6231 VSS.n66 571.332
R5268 VSS.n6231 VSS.t890 558.823
R5269 VSS.n2050 VSS.t3712 501.538
R5270 VSS.n2067 VSS.t3736 480
R5271 VSS.n2067 VSS.t3008 480
R5272 VSS.n2028 VSS.t3561 480
R5273 VSS.n6231 VSS.n6230 474.76
R5274 VSS.n4730 VSS.n4729 472.918
R5275 VSS.n4729 VSS.n4614 461.969
R5276 VSS.t2575 VSS.n2068 447.591
R5277 VSS.n4613 VSS.n4612 438.702
R5278 VSS.n4541 VSS.n4540 436.046
R5279 VSS.n4498 VSS.n4290 436.046
R5280 VSS.n4497 VSS.n4496 436.046
R5281 VSS.n4417 VSS.n176 436.046
R5282 VSS.t1742 VSS.n154 427.408
R5283 VSS.n2070 VSS.t2577 413.637
R5284 VSS.n151 VSS.t1747 411.43
R5285 VSS.n4729 VSS.n4225 411.43
R5286 VSS.n3574 VSS.n3573 411.43
R5287 VSS.n2027 VSS.t4277 403.988
R5288 VSS.n6188 VSS.t1976 394.286
R5289 VSS.t3469 VSS.n4221 394.286
R5290 VSS.t2579 VSS.n1985 394.274
R5291 VSS.n2149 VSS.n1982 389.557
R5292 VSS.n6180 VSS.t2011 385.714
R5293 VSS.n153 VSS.t1746 385.714
R5294 VSS.n160 VSS.t1740 385.714
R5295 VSS.t4165 VSS.n4214 385.714
R5296 VSS.n2037 VSS.n1982 382.979
R5297 VSS.n3594 VSS.n3593 380.036
R5298 VSS.n2055 VSS.t4279 379.168
R5299 VSS.n2064 VSS.n2015 378.947
R5300 VSS.t1744 VSS.n150 360
R5301 VSS.t2583 VSS.n157 360
R5302 VSS.t1978 VSS.n6181 358.836
R5303 VSS.n4230 VSS.t3470 358.836
R5304 VSS.t4275 VSS.n2021 355.724
R5305 VSS.n154 VSS.t2582 350.264
R5306 VSS.t2005 VSS.n6176 342.858
R5307 VSS.n4731 VSS.t3087 342.858
R5308 VSS.t1497 VSS.n147 338.572
R5309 VSS.t2315 VSS.n6184 338.572
R5310 VSS.n4226 VSS.t104 338.572
R5311 VSS.n4231 VSS.t3004 338.572
R5312 VSS.n158 VSS.t2312 334.286
R5313 VSS.n6181 VSS.t2313 328.836
R5314 VSS.t3574 VSS.n4230 328.836
R5315 VSS.n2014 VSS.t3109 320.271
R5316 VSS.n2064 VSS.n2063 315.106
R5317 VSS.n6196 VSS.n146 313.877
R5318 VSS.n6195 VSS.t4242 312.858
R5319 VSS.t4112 VSS.n4225 312.858
R5320 VSS.t1 VSS.n1983 312.858
R5321 VSS.n4612 VSS.n4541 307.517
R5322 VSS.n4540 VSS.n4290 307.517
R5323 VSS.n4498 VSS.n4497 307.517
R5324 VSS.n4496 VSS.n4417 307.517
R5325 VSS.n2039 VSS.t3215 296.25
R5326 VSS.n2038 VSS.n1982 293.618
R5327 VSS.t2682 VSS.n2018 288.159
R5328 VSS.n3573 VSS.t3 287.144
R5329 VSS.n299 VSS.n100 270.471
R5330 VSS.n6171 VSS.n94 270.471
R5331 VSS.n4491 VSS.n88 270.471
R5332 VSS.n4510 VSS.n82 270.471
R5333 VSS.n4535 VSS.n76 270.471
R5334 VSS.n4607 VSS.n70 270.471
R5335 VSS.t2684 VSS.n2015 264.474
R5336 VSS.t3734 VSS.t3034 255.405
R5337 VSS.t2938 VSS.n2008 251.351
R5338 VSS.n2066 VSS.t3186 242.662
R5339 VSS.t3745 VSS.t2402 236.25
R5340 VSS.n2043 VSS.t2975 232.5
R5341 VSS.n6174 VSS.n176 228.114
R5342 VSS.n2048 VSS.t2520 218.118
R5343 VSS.n3468 VSS.n3467 214.101
R5344 VSS.n3006 VSS.n2241 214.101
R5345 VSS.n3042 VSS.n1128 214.101
R5346 VSS.n4843 VSS.n1164 214.101
R5347 VSS.n4876 VSS.n4875 214.101
R5348 VSS.n4782 VSS.n388 214.101
R5349 VSS.n6174 VSS.n177 209.001
R5350 VSS.n177 VSS.n146 187.089
R5351 VSS.t2586 VSS.n139 184.493
R5352 VSS.n2063 VSS.n1963 184.107
R5353 VSS.n2008 VSS.t3186 162.162
R5354 VSS.n2067 VSS.n2066 161.582
R5355 VSS.n2009 VSS.t2938 153.474
R5356 VSS.t3727 VSS.n2014 150
R5357 VSS.n2043 VSS.t2520 150
R5358 VSS.t2574 VSS.n2067 145.456
R5359 VSS.n141 VSS.t2021 144.625
R5360 VSS.n6199 VSS.t2316 144.386
R5361 VSS.n3592 VSS.n3591 143.982
R5362 VSS.n2049 VSS.n2048 143.118
R5363 VSS.n2039 VSS.t3699 138.75
R5364 VSS.t3736 VSS.t3007 138.463
R5365 VSS.t3008 VSS.t5 138.463
R5366 VSS.t3712 VSS.t2974 138.463
R5367 VSS.t3561 VSS.t2400 138.463
R5368 VSS.t1802 VSS.n296 137.505
R5369 VSS.t1542 VSS.n221 137.505
R5370 VSS.t1282 VSS.n4459 137.505
R5371 VSS.t2429 VSS.n4507 137.505
R5372 VSS.t4016 VSS.n4332 137.505
R5373 VSS.t2383 VSS.n4583 137.505
R5374 VSS.n142 VSS.t2018 136.364
R5375 VSS.t2975 VSS.n2035 135.618
R5376 VSS.t1797 VSS.n266 133.584
R5377 VSS.t1537 VSS.n190 133.584
R5378 VSS.t1279 VSS.n4432 133.584
R5379 VSS.t3386 VSS.n4393 133.584
R5380 VSS.t2857 VSS.n4305 133.584
R5381 VSS.t2980 VSS.n4556 133.584
R5382 VSS.t3181 VSS.t3185 133.333
R5383 VSS.t2659 VSS.t2663 133.333
R5384 VSS.t1450 VSS.t1454 133.333
R5385 VSS.t1964 VSS.t1968 133.333
R5386 VSS.t1705 VSS.t1709 133.333
R5387 VSS.t1151 VSS.t1155 133.333
R5388 VSS.t3250 VSS.t3254 133.333
R5389 VSS.t1187 VSS.t1191 133.333
R5390 VSS.t1731 VSS.t1735 133.333
R5391 VSS.t2317 VSS.t2318 133.333
R5392 VSS.t2744 VSS.t2747 133.333
R5393 VSS.t8 VSS.t12 133.333
R5394 VSS.t1319 VSS.t1323 133.333
R5395 VSS.t1568 VSS.t1572 133.333
R5396 VSS.t1829 VSS.t1833 133.333
R5397 VSS.t4298 VSS.t4302 133.333
R5398 VSS.t2863 VSS.t2867 133.333
R5399 VSS.t21 VSS.t25 133.333
R5400 VSS.t1596 VSS.t1600 133.333
R5401 VSS.t1856 VSS.t1860 133.333
R5402 VSS.t1344 VSS.t1348 133.333
R5403 VSS.t2712 VSS.t2716 133.333
R5404 VSS.t3403 VSS.t3407 133.333
R5405 VSS.t49 VSS.t53 133.333
R5406 VSS.t1623 VSS.t1627 133.333
R5407 VSS.t1882 VSS.t1886 133.333
R5408 VSS.t1368 VSS.t1372 133.333
R5409 VSS.t2697 VSS.t2701 133.333
R5410 VSS.t3223 VSS.t3227 133.333
R5411 VSS.t77 VSS.t81 133.333
R5412 VSS.t1649 VSS.t1653 133.333
R5413 VSS.t1910 VSS.t1914 133.333
R5414 VSS.t1396 VSS.t1400 133.333
R5415 VSS.t2948 VSS.t2952 133.333
R5416 VSS.t2717 VSS.t2721 133.333
R5417 VSS.t1107 VSS.t1111 133.333
R5418 VSS.t1677 VSS.t1681 133.333
R5419 VSS.t1937 VSS.t1941 133.333
R5420 VSS.t1422 VSS.t1426 133.333
R5421 VSS.t2614 VSS.t2618 133.333
R5422 VSS.t2476 VSS.t2480 133.333
R5423 VSS.t4090 VSS.t4094 133.333
R5424 VSS.t4228 VSS.t4232 133.333
R5425 VSS.t2920 VSS.t2924 133.333
R5426 VSS.t1995 VSS.t1999 133.333
R5427 VSS.t1480 VSS.t1484 133.333
R5428 VSS.t2456 VSS.t2457 133.333
R5429 VSS.n2049 VSS.t4274 133.333
R5430 VSS.t2734 VSS.t2735 133.333
R5431 VSS.t2487 VSS.t2491 133.333
R5432 VSS.t4207 VSS.n4287 132.627
R5433 VSS.n3950 VSS.t2657 132.627
R5434 VSS.n3883 VSS.t1448 132.627
R5435 VSS.n3676 VSS.t1962 132.627
R5436 VSS.n3816 VSS.t1703 132.627
R5437 VSS.n3768 VSS.t1147 132.627
R5438 VSS.n3720 VSS.t3262 132.627
R5439 VSS.n2344 VSS.t1183 132.627
R5440 VSS.n2575 VSS.t1729 132.627
R5441 VSS.t2422 VSS.n528 132.627
R5442 VSS.t3248 VSS.n5942 132.627
R5443 VSS.t4014 VSS.n5872 132.627
R5444 VSS.t2446 VSS.n625 132.627
R5445 VSS.t1317 VSS.n5663 132.627
R5446 VSS.t1566 VSS.n5757 132.627
R5447 VSS.t1827 VSS.n454 132.627
R5448 VSS.n5222 VSS.t3352 132.627
R5449 VSS.n5174 VSS.t3401 132.627
R5450 VSS.n5107 VSS.t1594 132.627
R5451 VSS.n4949 VSS.t1854 132.627
R5452 VSS.n5040 VSS.t1342 132.627
R5453 VSS.n5296 VSS.t2769 132.627
R5454 VSS.n5548 VSS.t4172 132.627
R5455 VSS.n873 VSS.t45 132.627
R5456 VSS.n5500 VSS.t1621 132.627
R5457 VSS.n1098 VSS.t1880 132.627
R5458 VSS.n1030 VSS.t1366 132.627
R5459 VSS.n963 VSS.t3456 132.627
R5460 VSS.n1737 VSS.t2294 132.627
R5461 VSS.n1429 VSS.t73 132.627
R5462 VSS.n1522 VSS.t1647 132.627
R5463 VSS.n1670 VSS.t1908 132.627
R5464 VSS.n1595 VSS.t1394 132.627
R5465 VSS.n4095 VSS.t2944 132.627
R5466 VSS.t3278 VSS.n4184 132.627
R5467 VSS.t1103 VSS.n2957 132.627
R5468 VSS.t1675 VSS.n3310 132.627
R5469 VSS.t1935 VSS.n3111 132.627
R5470 VSS.t1420 VSS.n3182 132.627
R5471 VSS.t4203 VSS.n3246 132.627
R5472 VSS.t2554 VSS.n3291 132.627
R5473 VSS.t2957 VSS.n1480 132.627
R5474 VSS.t3117 VSS.n924 132.627
R5475 VSS.t2611 VSS.n5000 132.627
R5476 VSS.n2503 VSS.t1993 132.627
R5477 VSS.n3389 VSS.t1478 132.627
R5478 VSS.n2429 VSS.t2255 132.627
R5479 VSS.t3236 VSS.n3462 132.627
R5480 VSS.t2626 VSS.n2211 132.627
R5481 VSS.t3038 VSS.n4242 125.993
R5482 VSS.n6174 VSS.n175 125.436
R5483 VSS.n6174 VSS.n6173 125.436
R5484 VSS.n4443 VSS.n4417 125.436
R5485 VSS.n4497 VSS.n4407 125.436
R5486 VSS.n4316 VSS.n4290 125.436
R5487 VSS.n4567 VSS.n4541 125.436
R5488 VSS.t1806 VSS.n256 124.439
R5489 VSS.t1546 VSS.n180 124.439
R5490 VSS.t1286 VSS.n4422 124.439
R5491 VSS.t2433 VSS.n4383 124.439
R5492 VSS.t4020 VSS.n4295 124.439
R5493 VSS.t2387 VSS.n4546 124.439
R5494 VSS.n6231 VSS.n62 124.353
R5495 VSS.n4613 VSS.n4289 124.353
R5496 VSS.n3524 VSS.n2213 124.353
R5497 VSS.n3988 VSS.n3731 124.353
R5498 VSS.n3988 VSS.n3779 124.353
R5499 VSS.n3988 VSS.n3846 124.353
R5500 VSS.n3989 VSS.n3988 124.353
R5501 VSS.n3988 VSS.n3913 124.353
R5502 VSS.n3988 VSS.n3987 124.353
R5503 VSS.n5995 VSS.n436 124.353
R5504 VSS.n5995 VSS.n437 124.353
R5505 VSS.n5995 VSS.n438 124.353
R5506 VSS.n5995 VSS.n439 124.353
R5507 VSS.n5995 VSS.n440 124.353
R5508 VSS.n5995 VSS.n441 124.353
R5509 VSS.n5995 VSS.n5994 124.353
R5510 VSS.n5992 VSS.n486 124.353
R5511 VSS.n5992 VSS.n487 124.353
R5512 VSS.n5992 VSS.n488 124.353
R5513 VSS.n5993 VSS.n5992 124.353
R5514 VSS.n5992 VSS.n489 124.353
R5515 VSS.n5992 VSS.n490 124.353
R5516 VSS.n5992 VSS.n491 124.353
R5517 VSS.n5327 VSS.n5002 124.353
R5518 VSS.n5327 VSS.n5003 124.353
R5519 VSS.n5327 VSS.n5070 124.353
R5520 VSS.n5328 VSS.n5327 124.353
R5521 VSS.n5327 VSS.n5137 124.353
R5522 VSS.n5327 VSS.n5185 124.353
R5523 VSS.n5327 VSS.n5326 124.353
R5524 VSS.n5586 VSS.n926 124.353
R5525 VSS.n5586 VSS.n993 124.353
R5526 VSS.n5586 VSS.n1061 124.353
R5527 VSS.n5586 VSS.n5463 124.353
R5528 VSS.n5586 VSS.n5511 124.353
R5529 VSS.n5587 VSS.n5586 124.353
R5530 VSS.n5586 VSS.n5585 124.353
R5531 VSS.n4125 VSS.n1482 124.353
R5532 VSS.n4125 VSS.n1483 124.353
R5533 VSS.n4125 VSS.n1484 124.353
R5534 VSS.n4125 VSS.n1485 124.353
R5535 VSS.n4125 VSS.n1700 124.353
R5536 VSS.n4126 VSS.n4125 124.353
R5537 VSS.n4125 VSS.n4124 124.353
R5538 VSS.n3294 VSS.n1288 124.353
R5539 VSS.n3294 VSS.n2959 124.353
R5540 VSS.n3295 VSS.n3294 124.353
R5541 VSS.n3294 VSS.n3113 124.353
R5542 VSS.n3294 VSS.n3184 124.353
R5543 VSS.n3294 VSS.n3248 124.353
R5544 VSS.n3294 VSS.n3293 124.353
R5545 VSS.n4187 VSS.n1256 124.353
R5546 VSS.n4187 VSS.n1257 124.353
R5547 VSS.n4187 VSS.n1258 124.353
R5548 VSS.n4187 VSS.n1259 124.353
R5549 VSS.n4187 VSS.n1260 124.353
R5550 VSS.n4187 VSS.n1261 124.353
R5551 VSS.n4187 VSS.n4186 124.353
R5552 VSS.n1445 VSS.n773 124.353
R5553 VSS.n4080 VSS.n773 124.353
R5554 VSS.n1580 VSS.n773 124.353
R5555 VSS.n1655 VSS.n773 124.353
R5556 VSS.n1507 VSS.n773 124.353
R5557 VSS.n1414 VSS.n773 124.353
R5558 VSS.n1722 VSS.n773 124.353
R5559 VSS.n889 VSS.n700 124.353
R5560 VSS.n948 VSS.n700 124.353
R5561 VSS.n1015 VSS.n700 124.353
R5562 VSS.n1083 VSS.n700 124.353
R5563 VSS.n5485 VSS.n700 124.353
R5564 VSS.n858 VSS.n700 124.353
R5565 VSS.n5533 VSS.n700 124.353
R5566 VSS.n4965 VSS.n578 124.353
R5567 VSS.n5281 VSS.n578 124.353
R5568 VSS.n5025 VSS.n578 124.353
R5569 VSS.n4934 VSS.n578 124.353
R5570 VSS.n5092 VSS.n578 124.353
R5571 VSS.n5159 VSS.n578 124.353
R5572 VSS.n5207 VSS.n578 124.353
R5573 VSS.n3465 VSS.n2304 124.353
R5574 VSS.n3465 VSS.n2305 124.353
R5575 VSS.n3465 VSS.n2306 124.353
R5576 VSS.n3465 VSS.n2307 124.353
R5577 VSS.n3465 VSS.n3418 124.353
R5578 VSS.n3465 VSS.n3464 124.353
R5579 VSS.n3427 VSS.n1803 124.353
R5580 VSS.n2329 VSS.n1803 124.353
R5581 VSS.n2560 VSS.n1803 124.353
R5582 VSS.n2488 VSS.n1803 124.353
R5583 VSS.n3374 VSS.n1803 124.353
R5584 VSS.n2414 VSS.n1803 124.353
R5585 VSS.n2176 VSS.n1323 124.353
R5586 VSS.n3935 VSS.n1323 124.353
R5587 VSS.n3868 VSS.n1323 124.353
R5588 VSS.n3661 VSS.n1323 124.353
R5589 VSS.n3801 VSS.n1323 124.353
R5590 VSS.n3753 VSS.n1323 124.353
R5591 VSS.n3705 VSS.n1323 124.353
R5592 VSS.n1983 VSS.t3 124.287
R5593 VSS.t1758 VSS.n275 124.129
R5594 VSS.t1496 VSS.n199 124.129
R5595 VSS.t1232 VSS.n4438 124.129
R5596 VSS.t2690 VSS.n4402 124.129
R5597 VSS.t2851 VSS.n4311 124.129
R5598 VSS.t3355 VSS.n4562 124.129
R5599 VSS.n4258 VSS.t3189 123.058
R5600 VSS.t3211 VSS.n536 123.058
R5601 VSS.t4208 VSS.n5950 123.058
R5602 VSS.t4003 VSS.n5880 123.058
R5603 VSS.t2466 VSS.n633 123.058
R5604 VSS.t1304 VSS.n5671 123.058
R5605 VSS.t1555 VSS.n5765 123.058
R5606 VSS.t1814 VSS.n462 123.058
R5607 VSS.n3262 VSS.t2783 123.058
R5608 VSS.n3198 VSS.t4192 123.058
R5609 VSS.n3127 VSS.t1409 123.058
R5610 VSS.n2973 VSS.t1922 123.058
R5611 VSS.n2883 VSS.t1665 123.058
R5612 VSS.n2909 VSS.t94 123.058
R5613 VSS.n1275 VSS.t3204 123.058
R5614 VSS.n1451 VSS.t3360 123.058
R5615 VSS.n4085 VSS.t2772 123.058
R5616 VSS.n1585 VSS.t1381 123.058
R5617 VSS.n1660 VSS.t1898 123.058
R5618 VSS.n1512 VSS.t1636 123.058
R5619 VSS.n1419 VSS.t64 123.058
R5620 VSS.n1727 VSS.t4314 123.058
R5621 VSS.n895 VSS.t3331 123.058
R5622 VSS.n953 VSS.t2728 123.058
R5623 VSS.n1020 VSS.t1355 123.058
R5624 VSS.n1088 VSS.t1869 123.058
R5625 VSS.n5490 VSS.t1608 123.058
R5626 VSS.n863 VSS.t36 123.058
R5627 VSS.n5538 VSS.t3078 123.058
R5628 VSS.n4971 VSS.t3111 123.058
R5629 VSS.n5286 VSS.t2760 123.058
R5630 VSS.n5030 VSS.t1327 123.058
R5631 VSS.n4939 VSS.t1841 123.058
R5632 VSS.n5097 VSS.t1584 123.058
R5633 VSS.n5164 VSS.t3388 123.058
R5634 VSS.n5212 VSS.t2591 123.058
R5635 VSS.n3433 VSS.t4320 123.058
R5636 VSS.n2334 VSS.t1173 123.058
R5637 VSS.n2565 VSS.t1719 123.058
R5638 VSS.n2493 VSS.t1980 123.058
R5639 VSS.n3379 VSS.t1465 123.058
R5640 VSS.n2419 VSS.t2450 123.058
R5641 VSS.n2182 VSS.t2628 123.058
R5642 VSS.n3940 VSS.t4191 123.058
R5643 VSS.n3873 VSS.t1437 123.058
R5644 VSS.n3666 VSS.t1951 123.058
R5645 VSS.n3806 VSS.t1690 123.058
R5646 VSS.n3758 VSS.t1139 123.058
R5647 VSS.n3710 VSS.t4137 123.058
R5648 VSS.n3499 VSS.n3498 122.691
R5649 VSS.n3065 VSS.n3064 122.691
R5650 VSS.n5427 VSS.n5426 122.691
R5651 VSS.n4874 VSS.n4873 122.691
R5652 VSS.n5361 VSS.n5360 122.691
R5653 VSS.n6010 VSS.n6009 122.691
R5654 VSS.t1795 VSS.n264 121.516
R5655 VSS.t1535 VSS.n188 121.516
R5656 VSS.t1277 VSS.n4430 121.516
R5657 VSS.t3384 VSS.n4391 121.516
R5658 VSS.t2855 VSS.n4303 121.516
R5659 VSS.t2978 VSS.n4554 121.516
R5660 VSS.n4285 VSS.t4205 120.57
R5661 VSS.t2655 VSS.n3952 120.57
R5662 VSS.t1446 VSS.n3885 120.57
R5663 VSS.t1960 VSS.n3678 120.57
R5664 VSS.t1701 VSS.n3818 120.57
R5665 VSS.t1145 VSS.n3770 120.57
R5666 VSS.t3260 VSS.n3722 120.57
R5667 VSS.t1181 VSS.n2346 120.57
R5668 VSS.t1727 VSS.n2577 120.57
R5669 VSS.t2420 VSS.n526 120.57
R5670 VSS.t3246 VSS.n5940 120.57
R5671 VSS.t4012 VSS.n5870 120.57
R5672 VSS.t2444 VSS.n623 120.57
R5673 VSS.t1315 VSS.n5661 120.57
R5674 VSS.t1564 VSS.n5755 120.57
R5675 VSS.t1825 VSS.n452 120.57
R5676 VSS.t3350 VSS.n5224 120.57
R5677 VSS.t3399 VSS.n5176 120.57
R5678 VSS.t1592 VSS.n5109 120.57
R5679 VSS.t1852 VSS.n4951 120.57
R5680 VSS.t1340 VSS.n5042 120.57
R5681 VSS.t2767 VSS.n5298 120.57
R5682 VSS.t4170 VSS.n5550 120.57
R5683 VSS.t43 VSS.n875 120.57
R5684 VSS.t1619 VSS.n5502 120.57
R5685 VSS.t1878 VSS.n1100 120.57
R5686 VSS.t1364 VSS.n1032 120.57
R5687 VSS.t3454 VSS.n965 120.57
R5688 VSS.t2292 VSS.n1739 120.57
R5689 VSS.t71 VSS.n1431 120.57
R5690 VSS.t1645 VSS.n1524 120.57
R5691 VSS.t1906 VSS.n1672 120.57
R5692 VSS.t1392 VSS.n1597 120.57
R5693 VSS.t2942 VSS.n4097 120.57
R5694 VSS.n4182 VSS.t3276 120.57
R5695 VSS.n2955 VSS.t1101 120.57
R5696 VSS.n3308 VSS.t1673 120.57
R5697 VSS.n3109 VSS.t1933 120.57
R5698 VSS.n3180 VSS.t1418 120.57
R5699 VSS.n3244 VSS.t4201 120.57
R5700 VSS.n3289 VSS.t2552 120.57
R5701 VSS.n1478 VSS.t2955 120.57
R5702 VSS.n922 VSS.t3115 120.57
R5703 VSS.n4998 VSS.t2609 120.57
R5704 VSS.t1991 VSS.n2505 120.57
R5705 VSS.t1476 VSS.n3391 120.57
R5706 VSS.t2253 VSS.n2431 120.57
R5707 VSS.n3460 VSS.t3234 120.57
R5708 VSS.n2209 VSS.t2624 120.57
R5709 VSS.n265 VSS.t1794 120.519
R5710 VSS.n189 VSS.t1534 120.519
R5711 VSS.n4431 VSS.t1276 120.519
R5712 VSS.n4392 VSS.t3383 120.519
R5713 VSS.n4304 VSS.t2854 120.519
R5714 VSS.n4555 VSS.t2473 120.519
R5715 VSS.t1751 VSS.n277 120.21
R5716 VSS.t1489 VSS.n201 120.21
R5717 VSS.t1240 VSS.n4440 120.21
R5718 VSS.t2686 VSS.n4404 120.21
R5719 VSS.t2847 VSS.n4313 120.21
R5720 VSS.t3334 VSS.n4564 120.21
R5721 VSS.n4286 VSS.t4204 119.662
R5722 VSS.t2652 VSS.n3951 119.662
R5723 VSS.t1445 VSS.n3884 119.662
R5724 VSS.t1957 VSS.n3677 119.662
R5725 VSS.t1698 VSS.n3817 119.662
R5726 VSS.t1144 VSS.n3769 119.662
R5727 VSS.t3259 VSS.n3721 119.662
R5728 VSS.t1176 VSS.n2345 119.662
R5729 VSS.t1724 VSS.n2576 119.662
R5730 VSS.n527 VSS.t2419 119.662
R5731 VSS.n5941 VSS.t3243 119.662
R5732 VSS.n5871 VSS.t4010 119.662
R5733 VSS.n624 VSS.t2443 119.662
R5734 VSS.n5662 VSS.t1314 119.662
R5735 VSS.n5756 VSS.t1563 119.662
R5736 VSS.n453 VSS.t1822 119.662
R5737 VSS.t3349 VSS.n5223 119.662
R5738 VSS.t3396 VSS.n5175 119.662
R5739 VSS.t1589 VSS.n5108 119.662
R5740 VSS.t1849 VSS.n4950 119.662
R5741 VSS.t1301 VSS.n5041 119.662
R5742 VSS.t2766 VSS.n5297 119.662
R5743 VSS.t4169 VSS.n5549 119.662
R5744 VSS.t42 VSS.n874 119.662
R5745 VSS.t1616 VSS.n5501 119.662
R5746 VSS.t1877 VSS.n1099 119.662
R5747 VSS.t1361 VSS.n1031 119.662
R5748 VSS.t3453 VSS.n964 119.662
R5749 VSS.t2291 VSS.n1738 119.662
R5750 VSS.t70 VSS.n1430 119.662
R5751 VSS.t1644 VSS.n1523 119.662
R5752 VSS.t1903 VSS.n1671 119.662
R5753 VSS.t1389 VSS.n1596 119.662
R5754 VSS.t2941 VSS.n4096 119.662
R5755 VSS.n4183 VSS.t3275 119.662
R5756 VSS.n2956 VSS.t97 119.662
R5757 VSS.n3309 VSS.t1670 119.662
R5758 VSS.n3110 VSS.t1930 119.662
R5759 VSS.n3181 VSS.t1417 119.662
R5760 VSS.n3245 VSS.t4199 119.662
R5761 VSS.n3290 VSS.t2551 119.662
R5762 VSS.n1479 VSS.t2954 119.662
R5763 VSS.n923 VSS.t3114 119.662
R5764 VSS.n4999 VSS.t2608 119.662
R5765 VSS.t1988 VSS.n2504 119.662
R5766 VSS.t1473 VSS.n3390 119.662
R5767 VSS.t2252 VSS.n2430 119.662
R5768 VSS.n3461 VSS.t3231 119.662
R5769 VSS.n2210 VSS.t2623 119.662
R5770 VSS.n285 VSS.t1752 119.502
R5771 VSS.n209 VSS.t1490 119.502
R5772 VSS.n4449 VSS.t1242 119.502
R5773 VSS.n4413 VSS.t2688 119.502
R5774 VSS.n4322 VSS.t2849 119.502
R5775 VSS.n4573 VSS.t3336 119.502
R5776 VSS.n4254 VSS.t2563 119.171
R5777 VSS.t3268 VSS.n538 119.171
R5778 VSS.t2967 VSS.n5952 119.171
R5779 VSS.t4000 VSS.n5882 119.171
R5780 VSS.t2438 VSS.n635 119.171
R5781 VSS.t1293 VSS.n5673 119.171
R5782 VSS.t1551 VSS.n5767 119.171
R5783 VSS.t1811 VSS.n464 119.171
R5784 VSS.n3258 VSS.t4077 119.171
R5785 VSS.n3194 VSS.t3319 119.171
R5786 VSS.n3123 VSS.t1405 119.171
R5787 VSS.n2969 VSS.t1919 119.171
R5788 VSS.n2879 VSS.t1660 119.171
R5789 VSS.n2905 VSS.t86 119.171
R5790 VSS.n1271 VSS.t3197 119.171
R5791 VSS.n1447 VSS.t2546 119.171
R5792 VSS.t2706 VSS.n4082 119.171
R5793 VSS.t1377 VSS.n1582 119.171
R5794 VSS.t1893 VSS.n1657 119.171
R5795 VSS.t1632 VSS.n1509 119.171
R5796 VSS.t58 VSS.n1416 119.171
R5797 VSS.t3412 VSS.n1724 119.171
R5798 VSS.n891 VSS.t2844 119.171
R5799 VSS.t3174 VSS.n950 119.171
R5800 VSS.t1349 VSS.n1017 119.171
R5801 VSS.t1865 VSS.n1085 119.171
R5802 VSS.t1605 VSS.n5487 119.171
R5803 VSS.t30 VSS.n860 119.171
R5804 VSS.t2872 VSS.n5535 119.171
R5805 VSS.n4967 VSS.t4295 119.171
R5806 VSS.t2754 VSS.n5283 119.171
R5807 VSS.t1297 VSS.n5027 119.171
R5808 VSS.t1838 VSS.n4936 119.171
R5809 VSS.t1579 VSS.n5094 119.171
R5810 VSS.t17 VSS.n5161 119.171
R5811 VSS.t2327 VSS.n5209 119.171
R5812 VSS.n3429 VSS.t4292 119.171
R5813 VSS.t1160 VSS.n2331 119.171
R5814 VSS.t1714 VSS.n2562 119.171
R5815 VSS.t1973 VSS.n2490 119.171
R5816 VSS.t1461 VSS.n3376 119.171
R5817 VSS.t2649 VSS.n2416 119.171
R5818 VSS.n2178 VSS.t3190 119.171
R5819 VSS.t4185 VSS.n3937 119.171
R5820 VSS.t1433 VSS.n3870 119.171
R5821 VSS.t1946 VSS.n3663 119.171
R5822 VSS.t1686 VSS.n3803 119.171
R5823 VSS.t1124 VSS.n3755 119.171
R5824 VSS.t4120 VSS.n3707 119.171
R5825 VSS.n298 VSS.t1804 118.903
R5826 VSS.n223 VSS.t1544 118.903
R5827 VSS.n4461 VSS.t1284 118.903
R5828 VSS.n4509 VSS.t2431 118.903
R5829 VSS.n4334 VSS.t4018 118.903
R5830 VSS.n4585 VSS.t2385 118.903
R5831 VSS.t2564 VSS.n4249 118.585
R5832 VSS.n5960 VSS.t2969 118.585
R5833 VSS.n5890 VSS.t4001 118.585
R5834 VSS.n643 VSS.t2440 118.585
R5835 VSS.n5681 VSS.t1295 118.585
R5836 VSS.n5775 VSS.t1552 118.585
R5837 VSS.n472 VSS.t1812 118.585
R5838 VSS.n546 VSS.t3269 118.585
R5839 VSS.t4078 VSS.n3253 118.585
R5840 VSS.t3321 VSS.n3189 118.585
R5841 VSS.t1407 VSS.n3118 118.585
R5842 VSS.t1920 VSS.n2964 118.585
R5843 VSS.t1661 VSS.n2874 118.585
R5844 VSS.t88 VSS.n2900 118.585
R5845 VSS.t3199 VSS.n1266 118.585
R5846 VSS.t2547 VSS.n1441 118.585
R5847 VSS.n4084 VSS.t2708 118.585
R5848 VSS.n1584 VSS.t1379 118.585
R5849 VSS.n1659 VSS.t1894 118.585
R5850 VSS.n1511 VSS.t1633 118.585
R5851 VSS.n1418 VSS.t60 118.585
R5852 VSS.n1726 VSS.t3414 118.585
R5853 VSS.t2845 VSS.n885 118.585
R5854 VSS.n952 VSS.t3176 118.585
R5855 VSS.n1019 VSS.t1351 118.585
R5856 VSS.n1087 VSS.t1866 118.585
R5857 VSS.n5489 VSS.t1606 118.585
R5858 VSS.n862 VSS.t32 118.585
R5859 VSS.n5537 VSS.t2874 118.585
R5860 VSS.t4296 VSS.n4961 118.585
R5861 VSS.n5285 VSS.t2756 118.585
R5862 VSS.n5029 VSS.t1299 118.585
R5863 VSS.n4938 VSS.t1839 118.585
R5864 VSS.n5096 VSS.t1580 118.585
R5865 VSS.n5163 VSS.t19 118.585
R5866 VSS.n5211 VSS.t2329 118.585
R5867 VSS.t4293 VSS.n3423 118.585
R5868 VSS.n2333 VSS.t1162 118.585
R5869 VSS.n2564 VSS.t1715 118.585
R5870 VSS.n2492 VSS.t1974 118.585
R5871 VSS.n3378 VSS.t1463 118.585
R5872 VSS.n2418 VSS.t2650 118.585
R5873 VSS.t3191 VSS.n2172 118.585
R5874 VSS.n3939 VSS.t4186 118.585
R5875 VSS.n3872 VSS.t1435 118.585
R5876 VSS.n3665 VSS.t1947 118.585
R5877 VSS.n3805 VSS.t1687 118.585
R5878 VSS.n3757 VSS.t1126 118.585
R5879 VSS.n3709 VSS.t4121 118.585
R5880 VSS.n286 VSS.t1756 116.29
R5881 VSS.n210 VSS.t1494 116.29
R5882 VSS.n4450 VSS.t1234 116.29
R5883 VSS.n4414 VSS.t2692 116.29
R5884 VSS.n4323 VSS.t2853 116.29
R5885 VSS.n4574 VSS.t3357 116.29
R5886 VSS.t3187 VSS.n4248 115.285
R5887 VSS.n547 VSS.t3213 115.285
R5888 VSS.n5961 VSS.t4210 115.285
R5889 VSS.n5891 VSS.t4005 115.285
R5890 VSS.n644 VSS.t2468 115.285
R5891 VSS.n5682 VSS.t1306 115.285
R5892 VSS.n5776 VSS.t1557 115.285
R5893 VSS.n473 VSS.t1816 115.285
R5894 VSS.t2785 VSS.n3252 115.285
R5895 VSS.t4194 VSS.n3188 115.285
R5896 VSS.t1411 VSS.n3117 115.285
R5897 VSS.t1924 VSS.n2963 115.285
R5898 VSS.t1663 VSS.n2873 115.285
R5899 VSS.t96 VSS.n2899 115.285
R5900 VSS.t3206 VSS.n1265 115.285
R5901 VSS.t3358 VSS.n1440 115.285
R5902 VSS.n4086 VSS.t2774 115.285
R5903 VSS.n1586 VSS.t1383 115.285
R5904 VSS.n1661 VSS.t1896 115.285
R5905 VSS.n1513 VSS.t1638 115.285
R5906 VSS.n1420 VSS.t62 115.285
R5907 VSS.n1728 VSS.t4312 115.285
R5908 VSS.t3333 VSS.n884 115.285
R5909 VSS.n954 VSS.t2730 115.285
R5910 VSS.n1021 VSS.t1353 115.285
R5911 VSS.n1089 VSS.t1871 115.285
R5912 VSS.n5491 VSS.t1610 115.285
R5913 VSS.n864 VSS.t34 115.285
R5914 VSS.n5539 VSS.t3080 115.285
R5915 VSS.t3113 VSS.n4960 115.285
R5916 VSS.n5287 VSS.t2758 115.285
R5917 VSS.n5031 VSS.t1329 115.285
R5918 VSS.n4940 VSS.t1843 115.285
R5919 VSS.n5098 VSS.t1582 115.285
R5920 VSS.n5165 VSS.t3390 115.285
R5921 VSS.n5213 VSS.t2589 115.285
R5922 VSS.t4322 VSS.n3422 115.285
R5923 VSS.n2335 VSS.t1175 115.285
R5924 VSS.n2566 VSS.t1717 115.285
R5925 VSS.n2494 VSS.t1982 115.285
R5926 VSS.n3380 VSS.t1467 115.285
R5927 VSS.n2420 VSS.t2448 115.285
R5928 VSS.t2630 VSS.n2171 115.285
R5929 VSS.n3941 VSS.t4189 115.285
R5930 VSS.n3874 VSS.t1439 115.285
R5931 VSS.n3667 VSS.t1949 115.285
R5932 VSS.n3807 VSS.t1692 115.285
R5933 VSS.n3759 VSS.t1137 115.285
R5934 VSS.n3711 VSS.t4135 115.285
R5935 VSS.n2018 VSS.t2684 114.475
R5936 VSS.n1985 VSS.t1 114.275
R5937 VSS.t3034 VSS.n2009 112.933
R5938 VSS.n287 VSS.t1793 111.373
R5939 VSS.n211 VSS.t1533 111.373
R5940 VSS.n4451 VSS.t1275 111.373
R5941 VSS.n4415 VSS.t3382 111.373
R5942 VSS.n4324 VSS.t2834 111.373
R5943 VSS.n4575 VSS.t3439 111.373
R5944 VSS.t3551 VSS.n4247 110.501
R5945 VSS.n548 VSS.t3549 110.501
R5946 VSS.n5962 VSS.t3437 110.501
R5947 VSS.n5892 VSS.t2832 110.501
R5948 VSS.n645 VSS.t3380 110.501
R5949 VSS.n5683 VSS.t1273 110.501
R5950 VSS.n5777 VSS.t1531 110.501
R5951 VSS.n474 VSS.t1791 110.501
R5952 VSS.t3541 VSS.n3251 110.501
R5953 VSS.t2824 VSS.n3187 110.501
R5954 VSS.t1265 VSS.n3116 110.501
R5955 VSS.t1783 VSS.n2962 110.501
R5956 VSS.t1523 VSS.n2872 110.501
R5957 VSS.t3372 VSS.n2898 110.501
R5958 VSS.t3429 VSS.n1264 110.501
R5959 VSS.t3543 VSS.n1439 110.501
R5960 VSS.n4088 VSS.t2826 110.501
R5961 VSS.n1588 VSS.t1267 110.501
R5962 VSS.n1663 VSS.t1785 110.501
R5963 VSS.n1515 VSS.t1525 110.501
R5964 VSS.n1422 VSS.t3374 110.501
R5965 VSS.n1730 VSS.t3431 110.501
R5966 VSS.t3545 VSS.n883 110.501
R5967 VSS.n956 VSS.t2828 110.501
R5968 VSS.n1023 VSS.t1269 110.501
R5969 VSS.n1091 VSS.t1787 110.501
R5970 VSS.n5493 VSS.t1527 110.501
R5971 VSS.n866 VSS.t3376 110.501
R5972 VSS.n5541 VSS.t3433 110.501
R5973 VSS.t3547 VSS.n4959 110.501
R5974 VSS.n5289 VSS.t2830 110.501
R5975 VSS.n5033 VSS.t1271 110.501
R5976 VSS.n4942 VSS.t1789 110.501
R5977 VSS.n5100 VSS.t1529 110.501
R5978 VSS.n5167 VSS.t3378 110.501
R5979 VSS.n5215 VSS.t3435 110.501
R5980 VSS.t3425 VSS.n3421 110.501
R5981 VSS.n2337 VSS.t3368 110.501
R5982 VSS.n2568 VSS.t1519 110.501
R5983 VSS.n2496 VSS.t1779 110.501
R5984 VSS.n3382 VSS.t1261 110.501
R5985 VSS.n2422 VSS.t2820 110.501
R5986 VSS.t3539 VSS.n2170 110.501
R5987 VSS.n3943 VSS.t2822 110.501
R5988 VSS.n3876 VSS.t1263 110.501
R5989 VSS.n3669 VSS.t1781 110.501
R5990 VSS.n3809 VSS.t1521 110.501
R5991 VSS.n3761 VSS.t3370 110.501
R5992 VSS.n3713 VSS.t3427 110.501
R5993 VSS.n300 VSS.n299 109.757
R5994 VSS.n6172 VSS.n6171 109.757
R5995 VSS.n4492 VSS.n4491 109.757
R5996 VSS.n4511 VSS.n4510 109.757
R5997 VSS.n4536 VSS.n4535 109.757
R5998 VSS.n4608 VSS.n4607 109.757
R5999 VSS.t1767 VSS.n287 106.145
R6000 VSS.t1505 VSS.n211 106.145
R6001 VSS.t1249 VSS.n4451 106.145
R6002 VSS.t4183 VSS.n4415 106.145
R6003 VSS.t2812 VSS.n4324 106.145
R6004 VSS.t3416 VSS.n4575 106.145
R6005 VSS.t1799 VSS.n263 105.837
R6006 VSS.t1792 VSS.n274 105.837
R6007 VSS.t1539 VSS.n187 105.837
R6008 VSS.t1532 VSS.n198 105.837
R6009 VSS.t1287 VSS.n4429 105.837
R6010 VSS.t1274 VSS.n4437 105.837
R6011 VSS.t2426 VSS.n4390 105.837
R6012 VSS.t3381 VSS.n4401 105.837
R6013 VSS.t4021 VSS.n4302 105.837
R6014 VSS.t2833 VSS.n4310 105.837
R6015 VSS.t2380 VSS.n4553 105.837
R6016 VSS.t3438 VSS.n4561 105.837
R6017 VSS.n4729 VSS.t102 105.694
R6018 VSS.n4247 VSS.t3531 105.32
R6019 VSS.t3214 VSS.n548 105.32
R6020 VSS.t3338 VSS.n5962 105.32
R6021 VSS.t4006 VSS.n5892 105.32
R6022 VSS.t2469 VSS.n645 105.32
R6023 VSS.t1302 VSS.n5683 105.32
R6024 VSS.t1559 VSS.n5777 105.32
R6025 VSS.t1817 VSS.n474 105.32
R6026 VSS.n3251 VSS.t2786 105.32
R6027 VSS.n3187 VSS.t4195 105.32
R6028 VSS.n3116 VSS.t1412 105.32
R6029 VSS.n2962 VSS.t1925 105.32
R6030 VSS.n2872 VSS.t1666 105.32
R6031 VSS.n2898 VSS.t1096 105.32
R6032 VSS.n1264 VSS.t3201 105.32
R6033 VSS.n1439 VSS.t4080 105.32
R6034 VSS.t3323 VSS.n4088 105.32
R6035 VSS.t1384 VSS.n1588 105.32
R6036 VSS.t1899 VSS.n1663 105.32
R6037 VSS.t1639 VSS.n1515 105.32
R6038 VSS.t66 VSS.n1422 105.32
R6039 VSS.t4315 VSS.n1730 105.32
R6040 VSS.n883 VSS.t3312 105.32
R6041 VSS.t2731 VSS.n956 105.32
R6042 VSS.t1357 VSS.n1023 105.32
R6043 VSS.t1872 VSS.n1091 105.32
R6044 VSS.t1612 VSS.n5493 105.32
R6045 VSS.t38 VSS.n866 105.32
R6046 VSS.t3081 VSS.n5541 105.32
R6047 VSS.n4959 VSS.t4152 105.32
R6048 VSS.t2761 VSS.n5289 105.32
R6049 VSS.t1326 VSS.n5033 105.32
R6050 VSS.t1844 VSS.n4942 105.32
R6051 VSS.t1585 VSS.n5100 105.32
R6052 VSS.t3391 VSS.n5167 105.32
R6053 VSS.t2556 VSS.n5215 105.32
R6054 VSS.n3421 VSS.t4323 105.32
R6055 VSS.t1168 VSS.n2337 105.32
R6056 VSS.t1720 VSS.n2568 105.32
R6057 VSS.t1983 VSS.n2496 105.32
R6058 VSS.t1468 VSS.n3382 105.32
R6059 VSS.t2451 VSS.n2422 105.32
R6060 VSS.n2170 VSS.t2631 105.32
R6061 VSS.t4262 VSS.n3943 105.32
R6062 VSS.t1440 VSS.n3876 105.32
R6063 VSS.t1952 VSS.n3669 105.32
R6064 VSS.t1693 VSS.n3809 105.32
R6065 VSS.t1132 VSS.n3761 105.32
R6066 VSS.t4138 VSS.n3713 105.32
R6067 VSS.t3179 VSS.n4267 105.013
R6068 VSS.n3954 VSS.t2653 105.013
R6069 VSS.n3887 VSS.t1455 105.013
R6070 VSS.n3680 VSS.t1958 105.013
R6071 VSS.n3820 VSS.t1699 105.013
R6072 VSS.n3772 VSS.t1149 105.013
R6073 VSS.n3724 VSS.t3255 105.013
R6074 VSS.n2348 VSS.t1185 105.013
R6075 VSS.n2579 VSS.t1725 105.013
R6076 VSS.t4303 VSS.n523 105.013
R6077 VSS.t3244 VSS.n5939 105.013
R6078 VSS.t4011 VSS.n5869 105.013
R6079 VSS.t6 VSS.n622 105.013
R6080 VSS.t1324 VSS.n5660 105.013
R6081 VSS.t1573 VSS.n5754 105.013
R6082 VSS.t1823 VSS.n451 105.013
R6083 VSS.n5226 VSS.t2424 105.013
R6084 VSS.n5178 VSS.t3397 105.013
R6085 VSS.n5111 VSS.t1590 105.013
R6086 VSS.n4953 VSS.t1850 105.013
R6087 VSS.n5044 VSS.t1338 105.013
R6088 VSS.n5300 VSS.t2710 105.013
R6089 VSS.n5552 VSS.t4227 105.013
R6090 VSS.n877 VSS.t47 105.013
R6091 VSS.n5504 VSS.t1617 105.013
R6092 VSS.n1102 VSS.t1887 105.013
R6093 VSS.n1034 VSS.t1362 105.013
R6094 VSS.n967 VSS.t2695 105.013
R6095 VSS.n1741 VSS.t3228 105.013
R6096 VSS.n1433 VSS.t75 105.013
R6097 VSS.n1526 VSS.t1654 105.013
R6098 VSS.n1674 VSS.t1904 105.013
R6099 VSS.n1599 VSS.t1390 105.013
R6100 VSS.n4099 VSS.t2946 105.013
R6101 VSS.t2722 VSS.n1284 105.013
R6102 VSS.t1105 VSS.n2918 105.013
R6103 VSS.t1671 VSS.n2892 105.013
R6104 VSS.t1931 VSS.n2982 105.013
R6105 VSS.t1427 VSS.n3136 105.013
R6106 VSS.t4200 VSS.n3207 105.013
R6107 VSS.t2474 VSS.n3271 105.013
R6108 VSS.t4095 VSS.n1460 105.013
R6109 VSS.t2982 VSS.n904 105.013
R6110 VSS.t2918 VSS.n4980 105.013
R6111 VSS.n2507 VSS.t1989 105.013
R6112 VSS.n3393 VSS.t1474 105.013
R6113 VSS.n2433 VSS.t2454 105.013
R6114 VSS.t3232 VSS.n3442 105.013
R6115 VSS.t2485 VSS.n2191 105.013
R6116 VSS.n4259 VSS.t3550 104.922
R6117 VSS.t3548 VSS.n535 104.922
R6118 VSS.t3436 VSS.n5949 104.922
R6119 VSS.t2831 VSS.n5879 104.922
R6120 VSS.t3379 VSS.n632 104.922
R6121 VSS.t1272 VSS.n5670 104.922
R6122 VSS.t1530 VSS.n5764 104.922
R6123 VSS.t1790 VSS.n461 104.922
R6124 VSS.n3263 VSS.t3540 104.922
R6125 VSS.n3199 VSS.t2823 104.922
R6126 VSS.n3128 VSS.t1264 104.922
R6127 VSS.n2974 VSS.t1782 104.922
R6128 VSS.n2884 VSS.t1522 104.922
R6129 VSS.n2910 VSS.t3371 104.922
R6130 VSS.n1276 VSS.t3428 104.922
R6131 VSS.n1452 VSS.t3542 104.922
R6132 VSS.n4087 VSS.t2825 104.922
R6133 VSS.n1587 VSS.t1266 104.922
R6134 VSS.n1662 VSS.t1784 104.922
R6135 VSS.n1514 VSS.t1524 104.922
R6136 VSS.n1421 VSS.t3373 104.922
R6137 VSS.n1729 VSS.t3430 104.922
R6138 VSS.n896 VSS.t3544 104.922
R6139 VSS.n955 VSS.t2827 104.922
R6140 VSS.n1022 VSS.t1268 104.922
R6141 VSS.n1090 VSS.t1786 104.922
R6142 VSS.n5492 VSS.t1526 104.922
R6143 VSS.n865 VSS.t3375 104.922
R6144 VSS.n5540 VSS.t3432 104.922
R6145 VSS.n4972 VSS.t3546 104.922
R6146 VSS.n5288 VSS.t2829 104.922
R6147 VSS.n5032 VSS.t1270 104.922
R6148 VSS.n4941 VSS.t1788 104.922
R6149 VSS.n5099 VSS.t1528 104.922
R6150 VSS.n5166 VSS.t3377 104.922
R6151 VSS.n5214 VSS.t3434 104.922
R6152 VSS.n3434 VSS.t3424 104.922
R6153 VSS.n2336 VSS.t3367 104.922
R6154 VSS.n2567 VSS.t1518 104.922
R6155 VSS.n2495 VSS.t1778 104.922
R6156 VSS.n3381 VSS.t1260 104.922
R6157 VSS.n2421 VSS.t2819 104.922
R6158 VSS.n2183 VSS.t3538 104.922
R6159 VSS.n3942 VSS.t2821 104.922
R6160 VSS.n3875 VSS.t1262 104.922
R6161 VSS.n3668 VSS.t1780 104.922
R6162 VSS.n3808 VSS.t1520 104.922
R6163 VSS.n3760 VSS.t3369 104.922
R6164 VSS.n3712 VSS.t3426 104.922
R6165 VSS.t1765 VSS.n271 103.224
R6166 VSS.n280 VSS.t1516 103.224
R6167 VSS.t1501 VSS.n195 103.224
R6168 VSS.n204 VSS.t1258 103.224
R6169 VSS.t1244 VSS.n4434 103.224
R6170 VSS.n4444 VSS.t3366 103.224
R6171 VSS.t4181 VSS.n4398 103.224
R6172 VSS.n4408 VSS.t2818 103.224
R6173 VSS.t2603 VSS.n4307 103.224
R6174 VSS.n4317 VSS.t3423 103.224
R6175 VSS.t2510 VSS.n4558 103.224
R6176 VSS.n4568 VSS.t3537 103.224
R6177 VSS.n4262 VSS.t3529 102.332
R6178 VSS.t237 VSS.n4252 102.332
R6179 VSS.t3107 VSS.n532 102.332
R6180 VSS.n541 VSS.t252 102.332
R6181 VSS.t3339 VSS.n5946 102.332
R6182 VSS.n5955 VSS.t3536 102.332
R6183 VSS.t4007 VSS.n5876 102.332
R6184 VSS.n5885 VSS.t3421 102.332
R6185 VSS.t2470 VSS.n629 102.332
R6186 VSS.n638 VSS.t2817 102.332
R6187 VSS.t1311 VSS.n5667 102.332
R6188 VSS.n5676 VSS.t3365 102.332
R6189 VSS.t1560 VSS.n5761 102.332
R6190 VSS.n5770 VSS.t1256 102.332
R6191 VSS.t1819 VSS.n458 102.332
R6192 VSS.n467 VSS.t1514 102.332
R6193 VSS.n3266 VSS.t2916 102.332
R6194 VSS.t314 VSS.n3256 102.332
R6195 VSS.n3202 VSS.t4196 102.332
R6196 VSS.t3417 VSS.n3192 102.332
R6197 VSS.n3131 VSS.t1414 102.332
R6198 VSS.t3361 VSS.n3121 102.332
R6199 VSS.n2977 VSS.t1927 102.332
R6200 VSS.t1503 VSS.n2967 102.332
R6201 VSS.n2887 VSS.t1667 102.332
R6202 VSS.t1250 VSS.n2877 102.332
R6203 VSS.n2913 VSS.t1098 102.332
R6204 VSS.t2813 VSS.n2903 102.332
R6205 VSS.n1279 VSS.t3202 102.332
R6206 VSS.t3346 VSS.n1269 102.332
R6207 VSS.n1455 VSS.t4081 102.332
R6208 VSS.t272 VSS.n1444 102.332
R6209 VSS.t3324 VSS.n4090 102.332
R6210 VSS.t3418 VSS.n4081 102.332
R6211 VSS.t1386 VSS.n1590 102.332
R6212 VSS.t3362 VSS.n1581 102.332
R6213 VSS.t1900 VSS.n1665 102.332
R6214 VSS.t1508 VSS.n1656 102.332
R6215 VSS.t1641 VSS.n1517 102.332
R6216 VSS.t1252 VSS.n1508 102.332
R6217 VSS.t67 VSS.n1424 102.332
R6218 VSS.t2814 VSS.n1415 102.332
R6219 VSS.t4316 VSS.n1732 102.332
R6220 VSS.t3534 VSS.n1723 102.332
R6221 VSS.n899 VSS.t3313 102.332
R6222 VSS.t265 VSS.n888 102.332
R6223 VSS.t2732 VSS.n958 102.332
R6224 VSS.t3419 VSS.n949 102.332
R6225 VSS.t1358 VSS.n1025 102.332
R6226 VSS.t3363 VSS.n1016 102.332
R6227 VSS.t1874 VSS.n1093 102.332
R6228 VSS.t1510 VSS.n1084 102.332
R6229 VSS.t1613 VSS.n5495 102.332
R6230 VSS.t1254 VSS.n5486 102.332
R6231 VSS.t39 VSS.n868 102.332
R6232 VSS.t2815 VSS.n859 102.332
R6233 VSS.t3083 VSS.n5543 102.332
R6234 VSS.t3535 VSS.n5534 102.332
R6235 VSS.n4975 VSS.t4153 102.332
R6236 VSS.t260 VSS.n4964 102.332
R6237 VSS.t2763 VSS.n5291 102.332
R6238 VSS.t3420 VSS.n5282 102.332
R6239 VSS.t1335 VSS.n5035 102.332
R6240 VSS.t3364 VSS.n5026 102.332
R6241 VSS.t1845 VSS.n4944 102.332
R6242 VSS.t1512 VSS.n4935 102.332
R6243 VSS.t1586 VSS.n5102 102.332
R6244 VSS.t1237 VSS.n5093 102.332
R6245 VSS.t3393 VSS.n5169 102.332
R6246 VSS.t2816 VSS.n5160 102.332
R6247 VSS.t2557 VSS.n5217 102.332
R6248 VSS.t4154 VSS.n5208 102.332
R6249 VSS.n3437 VSS.t4317 102.332
R6250 VSS.t3239 VSS.n3426 102.332
R6251 VSS.t1178 VSS.n2339 102.332
R6252 VSS.t2605 VSS.n2330 102.332
R6253 VSS.t1721 VSS.n2570 102.332
R6254 VSS.t1246 VSS.n2561 102.332
R6255 VSS.t1985 VSS.n2498 102.332
R6256 VSS.t1506 VSS.n2489 102.332
R6257 VSS.t1470 VSS.n3384 102.332
R6258 VSS.t2331 VSS.n3375 102.332
R6259 VSS.t2452 VSS.n2424 102.332
R6260 VSS.t2512 VSS.n2415 102.332
R6261 VSS.n2186 VSS.t2632 102.332
R6262 VSS.t327 VSS.n2175 102.332
R6263 VSS.t4263 VSS.n3945 102.332
R6264 VSS.t2514 VSS.n3936 102.332
R6265 VSS.t1442 VSS.n3878 102.332
R6266 VSS.t4182 VSS.n3869 102.332
R6267 VSS.t1954 VSS.n3671 102.332
R6268 VSS.t1492 VSS.n3662 102.332
R6269 VSS.t1695 VSS.n3811 102.332
R6270 VSS.t1235 VSS.n3802 102.332
R6271 VSS.t1141 VSS.n3763 102.332
R6272 VSS.t2606 VSS.n3754 102.332
R6273 VSS.t4139 VSS.n3715 102.332
R6274 VSS.t3532 VSS.n3706 102.332
R6275 VSS.n2021 VSS.t2682 98.9255
R6276 VSS.n6184 VSS.t4242 98.5719
R6277 VSS.n4226 VSS.t4112 98.5719
R6278 VSS.t2402 VSS.n2035 98.1177
R6279 VSS.t2031 VSS.n61 98.0397
R6280 VSS.n3584 VSS.t4067 97.9549
R6281 VSS.t3676 VSS.n265 96.9994
R6282 VSS.t3668 VSS.n189 96.9994
R6283 VSS.t3660 VSS.n4431 96.9994
R6284 VSS.t3657 VSS.n4392 96.9994
R6285 VSS.t3630 VSS.n4304 96.9994
R6286 VSS.t3626 VSS.n4555 96.9994
R6287 VSS.t3634 VSS.n4286 96.3266
R6288 VSS.n3951 VSS.t3654 96.3266
R6289 VSS.n3884 VSS.t3666 96.3266
R6290 VSS.n3677 VSS.t3682 96.3266
R6291 VSS.n3817 VSS.t3674 96.3266
R6292 VSS.n3769 VSS.t3659 96.3266
R6293 VSS.n3721 VSS.t3636 96.3266
R6294 VSS.n2345 VSS.t3623 96.3266
R6295 VSS.n2576 VSS.t3675 96.3266
R6296 VSS.t3639 VSS.n527 96.3266
R6297 VSS.t3642 VSS.n5941 96.3266
R6298 VSS.t3648 VSS.n5871 96.3266
R6299 VSS.t3655 VSS.n624 96.3266
R6300 VSS.t3661 VSS.n5662 96.3266
R6301 VSS.t3669 VSS.n5756 96.3266
R6302 VSS.t3677 VSS.n453 96.3266
R6303 VSS.n5223 VSS.t3643 96.3266
R6304 VSS.n5175 VSS.t3656 96.3266
R6305 VSS.n5108 VSS.t3670 96.3266
R6306 VSS.n4950 VSS.t3678 96.3266
R6307 VSS.n5041 VSS.t3662 96.3266
R6308 VSS.n5297 VSS.t3629 96.3266
R6309 VSS.n5549 VSS.t3644 96.3266
R6310 VSS.n874 VSS.t3621 96.3266
R6311 VSS.n5501 VSS.t3671 96.3266
R6312 VSS.n1099 VSS.t3679 96.3266
R6313 VSS.n1031 VSS.t3663 96.3266
R6314 VSS.n964 VSS.t3651 96.3266
R6315 VSS.n1738 VSS.t3625 96.3266
R6316 VSS.n1430 VSS.t3658 96.3266
R6317 VSS.n1523 VSS.t3672 96.3266
R6318 VSS.n1671 VSS.t3680 96.3266
R6319 VSS.n1596 VSS.t3664 96.3266
R6320 VSS.n4096 VSS.t3650 96.3266
R6321 VSS.t3646 VSS.n4183 96.3266
R6322 VSS.t3622 VSS.n2956 96.3266
R6323 VSS.t3673 VSS.n3309 96.3266
R6324 VSS.t3681 VSS.n3110 96.3266
R6325 VSS.t3665 VSS.n3181 96.3266
R6326 VSS.t3652 VSS.n3245 96.3266
R6327 VSS.t3631 VSS.n3290 96.3266
R6328 VSS.t3640 VSS.n1479 96.3266
R6329 VSS.t3641 VSS.n923 96.3266
R6330 VSS.t3628 VSS.n4999 96.3266
R6331 VSS.n2504 VSS.t3683 96.3266
R6332 VSS.n3390 VSS.t3667 96.3266
R6333 VSS.n2430 VSS.t3624 96.3266
R6334 VSS.t3647 VSS.n3461 96.3266
R6335 VSS.t3627 VSS.n2210 96.3266
R6336 VSS.n6200 VSS.t4245 96.2572
R6337 VSS.t1807 VSS.n254 95.3838
R6338 VSS.n290 VSS.n289 95.3838
R6339 VSS.t3219 VSS.n175 95.3838
R6340 VSS.t1547 VSS.n178 95.3838
R6341 VSS.n215 VSS.n214 95.3838
R6342 VSS.n6173 VSS.t3221 95.3838
R6343 VSS.t1289 VSS.n4420 95.3838
R6344 VSS.n4453 VSS.n4418 95.3838
R6345 VSS.t3209 VSS.n4443 95.3838
R6346 VSS.t2434 VSS.n4381 95.3838
R6347 VSS.n4501 VSS.n4500 95.3838
R6348 VSS.t3217 VSS.n4407 95.3838
R6349 VSS.t4022 VSS.n4293 95.3838
R6350 VSS.n4326 VSS.n4291 95.3838
R6351 VSS.t2534 VSS.n4316 95.3838
R6352 VSS.t2388 VSS.n4544 95.3838
R6353 VSS.n4577 VSS.n4542 95.3838
R6354 VSS.t2527 VSS.n4567 95.3838
R6355 VSS.t3264 VSS.n4274 94.5601
R6356 VSS.n4289 VSS.t2536 94.5601
R6357 VSS.t2672 VSS.n2198 94.5601
R6358 VSS.t4288 VSS.n3684 94.5601
R6359 VSS.t1156 VSS.n3732 94.5601
R6360 VSS.t1710 VSS.n3780 94.5601
R6361 VSS.t1969 VSS.n3640 94.5601
R6362 VSS.t1457 VSS.n3847 94.5601
R6363 VSS.t2645 VSS.n3914 94.5601
R6364 VSS.t3002 VSS.n436 94.5601
R6365 VSS.t3000 VSS.n437 94.5601
R6366 VSS.t2998 VSS.n438 94.5601
R6367 VSS.t2996 VSS.n439 94.5601
R6368 VSS.t3059 VSS.n440 94.5601
R6369 VSS.t2805 VSS.n441 94.5601
R6370 VSS.n5994 VSS.t2992 94.5601
R6371 VSS.t4304 VSS.n516 94.5601
R6372 VSS.t2750 VSS.n5860 94.5601
R6373 VSS.t1307 VSS.n5651 94.5601
R6374 VSS.t1834 VSS.n442 94.5601
R6375 VSS.t1575 VSS.n5745 94.5601
R6376 VSS.t13 VSS.n613 94.5601
R6377 VSS.t2323 VSS.n5930 94.5601
R6378 VSS.t2925 VSS.n4987 94.5601
R6379 VSS.t3170 VSS.n5260 94.5601
R6380 VSS.t1330 VSS.n5004 94.5601
R6381 VSS.t1861 VSS.n4913 94.5601
R6382 VSS.t1601 VSS.n5071 94.5601
R6383 VSS.t26 VSS.n5138 94.5601
R6384 VSS.t2868 VSS.n5186 94.5601
R6385 VSS.t2984 VSS.n911 94.5601
R6386 VSS.t2702 VSS.n927 94.5601
R6387 VSS.t1373 VSS.n994 94.5601
R6388 VSS.t1889 VSS.n1062 94.5601
R6389 VSS.t1628 VSS.n5464 94.5601
R6390 VSS.t54 VSS.n837 94.5601
R6391 VSS.t3408 VSS.n5512 94.5601
R6392 VSS.t4096 VSS.n1467 94.5601
R6393 VSS.t3315 VSS.n4059 94.5601
R6394 VSS.t1401 VSS.n1559 94.5601
R6395 VSS.t1915 VSS.n1634 94.5601
R6396 VSS.t1656 VSS.n1486 94.5601
R6397 VSS.t82 VSS.n1393 94.5601
R6398 VSS.t3193 VSS.n1701 94.5601
R6399 VSS.t2724 VSS.n4171 94.5601
R6400 VSS.t1120 VSS.n2944 94.5601
R6401 VSS.t1682 VSS.n3297 94.5601
R6402 VSS.t1942 VSS.n3098 94.5601
R6403 VSS.t1429 VSS.n3169 94.5601
R6404 VSS.t2619 VSS.n3233 94.5601
R6405 VSS.t2481 VSS.n3278 94.5601
R6406 VSS.t2990 VSS.n1256 94.5601
R6407 VSS.t2994 VSS.n1257 94.5601
R6408 VSS.t3036 VSS.n1258 94.5601
R6409 VSS.t2678 VSS.n1259 94.5601
R6410 VSS.t2680 VSS.n1260 94.5601
R6411 VSS.t2676 VSS.n1261 94.5601
R6412 VSS.n4186 VSS.t2988 94.5601
R6413 VSS.n1445 VSS.t3091 94.5601
R6414 VSS.t3515 VSS.n4080 94.5601
R6415 VSS.t2529 VSS.n1580 94.5601
R6416 VSS.t2523 VSS.n1655 94.5601
R6417 VSS.t2525 VSS.n1507 94.5601
R6418 VSS.t2538 VSS.n1414 94.5601
R6419 VSS.t3519 VSS.n1722 94.5601
R6420 VSS.n889 VSS.t2310 94.5601
R6421 VSS.t2306 VSS.n948 94.5601
R6422 VSS.t2300 VSS.n1015 94.5601
R6423 VSS.t3476 VSS.n1083 94.5601
R6424 VSS.t2302 VSS.n5485 94.5601
R6425 VSS.t2304 VSS.n858 94.5601
R6426 VSS.t2308 VSS.n5533 94.5601
R6427 VSS.n4965 VSS.t3089 94.5601
R6428 VSS.t3093 VSS.n5281 94.5601
R6429 VSS.t3517 VSS.n5025 94.5601
R6430 VSS.t2542 VSS.n4934 94.5601
R6431 VSS.t2544 VSS.n5092 94.5601
R6432 VSS.t2540 VSS.n5159 94.5601
R6433 VSS.t3095 VSS.n5207 94.5601
R6434 VSS.t2462 VSS.n2393 94.5601
R6435 VSS.t1485 VSS.n3353 94.5601
R6436 VSS.t2000 VSS.n2467 94.5601
R6437 VSS.t1736 VSS.n2539 94.5601
R6438 VSS.t1192 VSS.n2308 94.5601
R6439 VSS.t2740 VSS.n3449 94.5601
R6440 VSS.n3427 VSS.t493 94.5601
R6441 VSS.t660 VSS.n2329 94.5601
R6442 VSS.t868 VSS.n2560 94.5601
R6443 VSS.t990 VSS.n2488 94.5601
R6444 VSS.t760 VSS.n3374 94.5601
R6445 VSS.t574 VSS.n2414 94.5601
R6446 VSS.n2176 VSS.t2972 94.5601
R6447 VSS.t2518 VSS.n3935 94.5601
R6448 VSS.t2809 VSS.n3868 94.5601
R6449 VSS.t2931 VSS.n3661 94.5601
R6450 VSS.t2933 VSS.n3801 94.5601
R6451 VSS.t2929 VSS.n3753 94.5601
R6452 VSS.t2516 VSS.n3705 94.5601
R6453 VSS.n2049 VSS.n2028 92.3082
R6454 VSS.t4066 VSS.n1946 88.5135
R6455 VSS.n291 VSS.t1759 88.1437
R6456 VSS.n216 VSS.t1500 88.1437
R6457 VSS.n4454 VSS.t1248 88.1437
R6458 VSS.n4502 VSS.t2693 88.1437
R6459 VSS.n4327 VSS.t2811 88.1437
R6460 VSS.n4578 VSS.t3354 88.1437
R6461 VSS.n300 VSS.t1809 87.5441
R6462 VSS.n6172 VSS.t1549 87.5441
R6463 VSS.n4492 VSS.t1291 87.5441
R6464 VSS.n4511 VSS.t2436 87.5441
R6465 VSS.n4536 VSS.t4024 87.5441
R6466 VSS.n4608 VSS.t2390 87.5441
R6467 VSS.n4288 VSS.t3207 87.4963
R6468 VSS.n5965 VSS.t3241 87.4963
R6469 VSS.n5895 VSS.t4008 87.4963
R6470 VSS.n648 VSS.t4184 87.4963
R6471 VSS.n5686 VSS.t1303 87.4963
R6472 VSS.n5780 VSS.t1558 87.4963
R6473 VSS.n477 VSS.t1818 87.4963
R6474 VSS.n551 VSS.t3105 87.4963
R6475 VSS.n3292 VSS.t2549 87.4963
R6476 VSS.n3247 VSS.t4197 87.4963
R6477 VSS.n3183 VSS.t1413 87.4963
R6478 VSS.n3112 VSS.t1926 87.4963
R6479 VSS.n3311 VSS.t1635 87.4963
R6480 VSS.n2958 VSS.t1097 87.4963
R6481 VSS.n4185 VSS.t3273 87.4963
R6482 VSS.n1481 VSS.t2935 87.4963
R6483 VSS.n925 VSS.t3271 87.4963
R6484 VSS.n5001 VSS.t2613 87.4963
R6485 VSS.n3463 VSS.t4318 87.4963
R6486 VSS.n2212 VSS.t2500 87.4963
R6487 VSS.n4094 VSS.t2771 87.4954
R6488 VSS.n1594 VSS.t1385 87.4954
R6489 VSS.n1669 VSS.t1868 87.4954
R6490 VSS.n1521 VSS.t1640 87.4954
R6491 VSS.n1428 VSS.t65 87.4954
R6492 VSS.n1736 VSS.t2289 87.4954
R6493 VSS.n962 VSS.t3178 87.4954
R6494 VSS.n1029 VSS.t1356 87.4954
R6495 VSS.n1097 VSS.t1873 87.4954
R6496 VSS.n5499 VSS.t1611 87.4954
R6497 VSS.n872 VSS.t37 87.4954
R6498 VSS.n5547 VSS.t3082 87.4954
R6499 VSS.n5295 VSS.t2762 87.4954
R6500 VSS.n5039 VSS.t1334 87.4954
R6501 VSS.n4948 VSS.t1847 87.4954
R6502 VSS.n5106 VSS.t1554 87.4954
R6503 VSS.n5173 VSS.t3392 87.4954
R6504 VSS.n5221 VSS.t3347 87.4954
R6505 VSS.n2343 VSS.t1177 87.4954
R6506 VSS.n2574 VSS.t1689 87.4954
R6507 VSS.n2502 VSS.t1984 87.4954
R6508 VSS.n3388 VSS.t1469 87.4954
R6509 VSS.n2428 VSS.t4188 87.4954
R6510 VSS.n3949 VSS.t4264 87.4954
R6511 VSS.n3882 VSS.t1441 87.4954
R6512 VSS.n3675 VSS.t1953 87.4954
R6513 VSS.n3815 VSS.t1694 87.4954
R6514 VSS.n3767 VSS.t1140 87.4954
R6515 VSS.n3719 VSS.t3257 87.4954
R6516 VSS.t3266 VSS.n62 86.7881
R6517 VSS.n2213 VSS.t2674 86.7881
R6518 VSS.n3731 VSS.t4290 86.7881
R6519 VSS.n3779 VSS.t1158 86.7881
R6520 VSS.n3846 VSS.t1712 86.7881
R6521 VSS.n3989 VSS.t1971 86.7881
R6522 VSS.n3913 VSS.t1459 86.7881
R6523 VSS.n3987 VSS.t2647 86.7881
R6524 VSS.t4306 VSS.n486 86.7881
R6525 VSS.t2752 VSS.n487 86.7881
R6526 VSS.t1309 VSS.n488 86.7881
R6527 VSS.n5993 VSS.t1836 86.7881
R6528 VSS.t1577 VSS.n489 86.7881
R6529 VSS.t15 VSS.n490 86.7881
R6530 VSS.t2325 VSS.n491 86.7881
R6531 VSS.n5002 VSS.t2927 86.7881
R6532 VSS.t3172 VSS.n5003 86.7881
R6533 VSS.n5070 VSS.t1332 86.7881
R6534 VSS.n5328 VSS.t1863 86.7881
R6535 VSS.n5137 VSS.t1603 86.7881
R6536 VSS.n5185 VSS.t28 86.7881
R6537 VSS.n5326 VSS.t2870 86.7881
R6538 VSS.n926 VSS.t2986 86.7881
R6539 VSS.n993 VSS.t2704 86.7881
R6540 VSS.n1061 VSS.t1375 86.7881
R6541 VSS.n5463 VSS.t1891 86.7881
R6542 VSS.n5511 VSS.t1630 86.7881
R6543 VSS.n5587 VSS.t56 86.7881
R6544 VSS.n5585 VSS.t3410 86.7881
R6545 VSS.n1482 VSS.t4098 86.7881
R6546 VSS.t3317 VSS.n1483 86.7881
R6547 VSS.t1403 VSS.n1484 86.7881
R6548 VSS.t1917 VSS.n1485 86.7881
R6549 VSS.n1700 VSS.t1658 86.7881
R6550 VSS.n4126 VSS.t84 86.7881
R6551 VSS.n4124 VSS.t3195 86.7881
R6552 VSS.t2726 VSS.n1288 86.7881
R6553 VSS.n2959 VSS.t1122 86.7881
R6554 VSS.t1684 VSS.n3295 86.7881
R6555 VSS.n3113 VSS.t1944 86.7881
R6556 VSS.n3184 VSS.t1431 86.7881
R6557 VSS.n3248 VSS.t2621 86.7881
R6558 VSS.n3293 VSS.t2483 86.7881
R6559 VSS.t2464 VSS.n2304 86.7881
R6560 VSS.t1487 VSS.n2305 86.7881
R6561 VSS.t2002 VSS.n2306 86.7881
R6562 VSS.t1738 VSS.n2307 86.7881
R6563 VSS.n3418 VSS.t1194 86.7881
R6564 VSS.n3464 VSS.t2742 86.7881
R6565 VSS.t3109 VSS.n2013 85.2084
R6566 VSS.n6183 VSS.t1978 84.2748
R6567 VSS.t3470 VSS.n4227 84.2748
R6568 VSS.n1924 VSS.n1923 82.6126
R6569 VSS.n4030 VSS.n1803 82.4467
R6570 VSS.t3913 VSS.t1762 82.3176
R6571 VSS.t3881 VSS.t1499 82.3176
R6572 VSS.t1239 VSS.t3849 82.3176
R6573 VSS.t3822 VSS.t2694 82.3176
R6574 VSS.t2835 VSS.t3797 82.3176
R6575 VSS.t2472 VSS.t3701 82.3176
R6576 VSS.t3208 VSS.t3749 81.6067
R6577 VSS.t3753 VSS.t3106 81.6067
R6578 VSS.t3770 VSS.t3242 81.6067
R6579 VSS.t3717 VSS.t4009 81.6067
R6580 VSS.t3693 VSS.t2442 81.6067
R6581 VSS.t3852 VSS.t1313 81.6067
R6582 VSS.t3884 VSS.t1562 81.6067
R6583 VSS.t3917 VSS.t1821 81.6067
R6584 VSS.t2550 VSS.t3765 81.6067
R6585 VSS.t4198 VSS.t3709 81.6067
R6586 VSS.t1416 VSS.t3869 81.6067
R6587 VSS.t1929 VSS.t3933 81.6067
R6588 VSS.t1669 VSS.t3901 81.6067
R6589 VSS.t1100 VSS.t3838 81.6067
R6590 VSS.t3274 VSS.t3788 81.6067
R6591 VSS.t2953 VSS.t3762 81.6067
R6592 VSS.t3326 VSS.t3809 81.6067
R6593 VSS.t1388 VSS.t3865 81.6067
R6594 VSS.t1902 VSS.t3929 81.6067
R6595 VSS.t1643 VSS.t3896 81.6067
R6596 VSS.t69 VSS.t3834 81.6067
R6597 VSS.t2290 VSS.t3786 81.6067
R6598 VSS.t3272 VSS.t3758 81.6067
R6599 VSS.t3452 VSS.t3807 81.6067
R6600 VSS.t1360 VSS.t3861 81.6067
R6601 VSS.t1876 VSS.t3924 81.6067
R6602 VSS.t1615 VSS.t3893 81.6067
R6603 VSS.t41 VSS.t3830 81.6067
R6604 VSS.t4168 VSS.t3784 81.6067
R6605 VSS.t2607 VSS.t3722 81.6067
R6606 VSS.t2765 VSS.t3804 81.6067
R6607 VSS.t1337 VSS.t3857 81.6067
R6608 VSS.t1848 VSS.t3921 81.6067
R6609 VSS.t1588 VSS.t3889 81.6067
R6610 VSS.t3395 VSS.t3826 81.6067
R6611 VSS.t3348 VSS.t3775 81.6067
R6612 VSS.t4319 VSS.t3715 81.6067
R6613 VSS.t1180 VSS.t3845 81.6067
R6614 VSS.t1723 VSS.t3909 81.6067
R6615 VSS.t1987 VSS.t3941 81.6067
R6616 VSS.t1472 VSS.t3877 81.6067
R6617 VSS.t2251 VSS.t3819 81.6067
R6618 VSS.t2501 VSS.t3767 81.6067
R6619 VSS.t4265 VSS.t3812 81.6067
R6620 VSS.t1444 VSS.t3873 81.6067
R6621 VSS.t1956 VSS.t3937 81.6067
R6622 VSS.t1697 VSS.t3905 81.6067
R6623 VSS.t1143 VSS.t3842 81.6067
R6624 VSS.t3258 VSS.t3794 81.6067
R6625 VSS.t2598 VSS.n1943 81.4324
R6626 VSS.t1801 VSS.t3915 81.011
R6627 VSS.t1541 VSS.t3883 81.011
R6628 VSS.t1281 VSS.t3851 81.011
R6629 VSS.t2428 VSS.t3821 81.011
R6630 VSS.t4015 VSS.t3791 81.011
R6631 VSS.t2382 VSS.t3769 81.011
R6632 VSS.n4266 VSS.t4206 79.6243
R6633 VSS.n3718 VSS.t3261 79.6243
R6634 VSS.n3766 VSS.t1146 79.6243
R6635 VSS.n3814 VSS.t1702 79.6243
R6636 VSS.n3674 VSS.t1961 79.6243
R6637 VSS.n3881 VSS.t1447 79.6243
R6638 VSS.n3948 VSS.t2656 79.6243
R6639 VSS.n2427 VSS.t2254 79.6243
R6640 VSS.n3387 VSS.t1477 79.6243
R6641 VSS.n2501 VSS.t1992 79.6243
R6642 VSS.n2573 VSS.t1728 79.6243
R6643 VSS.n2342 VSS.t1182 79.6243
R6644 VSS.t2421 VSS.n529 79.6243
R6645 VSS.t3247 VSS.n5943 79.6243
R6646 VSS.t4013 VSS.n5873 79.6243
R6647 VSS.t2445 VSS.n626 79.6243
R6648 VSS.t1316 VSS.n5664 79.6243
R6649 VSS.t1565 VSS.n5758 79.6243
R6650 VSS.t1826 VSS.n455 79.6243
R6651 VSS.n5220 VSS.t3351 79.6243
R6652 VSS.n5172 VSS.t3400 79.6243
R6653 VSS.n5105 VSS.t1593 79.6243
R6654 VSS.n4947 VSS.t1853 79.6243
R6655 VSS.n5038 VSS.t1341 79.6243
R6656 VSS.n5294 VSS.t2768 79.6243
R6657 VSS.n5546 VSS.t4171 79.6243
R6658 VSS.n871 VSS.t44 79.6243
R6659 VSS.n5498 VSS.t1620 79.6243
R6660 VSS.n1096 VSS.t1879 79.6243
R6661 VSS.n1028 VSS.t1365 79.6243
R6662 VSS.n961 VSS.t3455 79.6243
R6663 VSS.n1735 VSS.t2293 79.6243
R6664 VSS.n1427 VSS.t72 79.6243
R6665 VSS.n1520 VSS.t1646 79.6243
R6666 VSS.n1668 VSS.t1907 79.6243
R6667 VSS.n1593 VSS.t1393 79.6243
R6668 VSS.n4093 VSS.t2943 79.6243
R6669 VSS.n1283 VSS.t3277 79.6243
R6670 VSS.n2917 VSS.t1102 79.6243
R6671 VSS.n2891 VSS.t1674 79.6243
R6672 VSS.n2981 VSS.t1934 79.6243
R6673 VSS.n3135 VSS.t1419 79.6243
R6674 VSS.n3206 VSS.t4202 79.6243
R6675 VSS.n3270 VSS.t2553 79.6243
R6676 VSS.n1459 VSS.t2956 79.6243
R6677 VSS.n903 VSS.t3116 79.6243
R6678 VSS.n4979 VSS.t2610 79.6243
R6679 VSS.n3441 VSS.t3235 79.6243
R6680 VSS.n2190 VSS.t2625 79.6243
R6681 VSS.t1796 VSS.n267 79.6243
R6682 VSS.t2979 VSS.n4543 79.6243
R6683 VSS.t2856 VSS.n4292 79.6243
R6684 VSS.t3385 VSS.n4394 79.6243
R6685 VSS.t1278 VSS.n4419 79.6243
R6686 VSS.t1536 VSS.n191 79.6243
R6687 VSS.t2585 VSS.n147 77.1434
R6688 VSS.t2582 VSS.n150 77.1434
R6689 VSS.t2312 VSS.n157 77.1434
R6690 VSS.n4231 VSS.t106 77.1434
R6691 VSS.n288 VSS.t3912 77.0911
R6692 VSS.n212 VSS.t3880 77.0911
R6693 VSS.n4452 VSS.t3848 77.0911
R6694 VSS.n4416 VSS.t3824 77.0911
R6695 VSS.n4325 VSS.t3793 77.0911
R6696 VSS.n4576 VSS.t3726 77.0911
R6697 VSS.t3733 VSS.n4246 76.4254
R6698 VSS.n549 VSS.t3752 76.4254
R6699 VSS.n5963 VSS.t3700 76.4254
R6700 VSS.n5893 VSS.t3799 76.4254
R6701 VSS.n646 VSS.t3703 76.4254
R6702 VSS.n5684 VSS.t3854 76.4254
R6703 VSS.n5778 VSS.t3886 76.4254
R6704 VSS.n475 VSS.t3916 76.4254
R6705 VSS.t3764 VSS.n3250 76.4254
R6706 VSS.t3707 VSS.n3186 76.4254
R6707 VSS.t3868 VSS.n3115 76.4254
R6708 VSS.t3932 VSS.n2961 76.4254
R6709 VSS.t3900 VSS.n2871 76.4254
R6710 VSS.t3837 VSS.n2897 76.4254
R6711 VSS.t3774 VSS.n1263 76.4254
R6712 VSS.t3760 VSS.n1438 76.4254
R6713 VSS.t3803 VSS.n4089 76.4254
R6714 VSS.t3864 VSS.n1589 76.4254
R6715 VSS.t3928 VSS.n1664 76.4254
R6716 VSS.t3898 VSS.n1516 76.4254
R6717 VSS.t3833 VSS.n1423 76.4254
R6718 VSS.t3779 VSS.n1731 76.4254
R6719 VSS.t3757 VSS.n882 76.4254
R6720 VSS.t3806 VSS.n957 76.4254
R6721 VSS.t3860 VSS.n1024 76.4254
R6722 VSS.t3926 VSS.n1092 76.4254
R6723 VSS.t3892 VSS.n5494 76.4254
R6724 VSS.t3829 VSS.n867 76.4254
R6725 VSS.t3783 VSS.n5542 76.4254
R6726 VSS.t3724 VSS.n4958 76.4254
R6727 VSS.t3714 VSS.n5290 76.4254
R6728 VSS.t3856 VSS.n5034 76.4254
R6729 VSS.t3920 VSS.n4943 76.4254
R6730 VSS.t3888 VSS.n5101 76.4254
R6731 VSS.t3696 VSS.n5168 76.4254
R6732 VSS.t3772 VSS.n5216 76.4254
R6733 VSS.t3738 VSS.n3420 76.4254
R6734 VSS.t3697 VSS.n2338 76.4254
R6735 VSS.t3908 VSS.n2569 76.4254
R6736 VSS.t3940 VSS.n2497 76.4254
R6737 VSS.t3876 VSS.n3383 76.4254
R6738 VSS.t3698 VSS.n2423 76.4254
R6739 VSS.t3706 VSS.n2169 76.4254
R6740 VSS.t3814 VSS.n3944 76.4254
R6741 VSS.t3872 VSS.n3877 76.4254
R6742 VSS.t3936 VSS.n3670 76.4254
R6743 VSS.t3904 VSS.n3810 76.4254
R6744 VSS.t3841 VSS.n3762 76.4254
R6745 VSS.t3740 VSS.n3714 76.4254
R6746 VSS.n2068 VSS.t2574 74.8631
R6747 VSS.t3006 VSS.t3035 73.8467
R6748 VSS.t2939 VSS.t0 73.8467
R6749 VSS.t2976 VSS.t2971 73.8467
R6750 VSS.t3458 VSS.t2401 73.8467
R6751 VSS.n6229 VSS.n61 73.3116
R6752 VSS.n6188 VSS.t2315 72.8576
R6753 VSS.t104 VSS.n4221 72.8576
R6754 VSS.n3575 VSS.n3574 72.4239
R6755 VSS.t3215 VSS.n2036 72.0549
R6756 VSS.n99 VSS.n98 71.8646
R6757 VSS.n93 VSS.n92 71.8646
R6758 VSS.n87 VSS.n86 71.8646
R6759 VSS.n81 VSS.n80 71.8646
R6760 VSS.n75 VSS.n74 71.8646
R6761 VSS.n69 VSS.n68 71.8646
R6762 VSS.n4189 VSS.n4187 70.9525
R6763 VSS.n5621 VSS.n773 70.9525
R6764 VSS.n5831 VSS.n700 70.9525
R6765 VSS.n5989 VSS.n578 70.9525
R6766 VSS.n4165 VSS.n1323 70.9525
R6767 VSS.n2050 VSS.n2049 70.7697
R6768 VSS.t2012 VSS.t2005 68.5719
R6769 VSS.t3087 VSS.t4166 68.5719
R6770 VSS.t2596 VSS.n1942 67.2704
R6771 VSS.n2065 VSS.t3727 64.8654
R6772 VSS.n6201 VSS.t2014 64.4105
R6773 VSS.t2599 VSS.t4076 63.7298
R6774 VSS.t4274 VSS.n2027 62.3211
R6775 VSS.t3185 VSS.t3182 60.6066
R6776 VSS.t2663 VSS.t2660 60.6066
R6777 VSS.t1454 VSS.t1451 60.6066
R6778 VSS.t1968 VSS.t1965 60.6066
R6779 VSS.t1709 VSS.t1706 60.6066
R6780 VSS.t1155 VSS.t1152 60.6066
R6781 VSS.t3254 VSS.t3251 60.6066
R6782 VSS.t1191 VSS.t1188 60.6066
R6783 VSS.t1735 VSS.t1732 60.6066
R6784 VSS.t2318 VSS.t2320 60.6066
R6785 VSS.t2747 VSS.t2745 60.6066
R6786 VSS.t12 VSS.t9 60.6066
R6787 VSS.t1323 VSS.t1320 60.6066
R6788 VSS.t1572 VSS.t1569 60.6066
R6789 VSS.t1833 VSS.t1830 60.6066
R6790 VSS.t4302 VSS.t4299 60.6066
R6791 VSS.t2867 VSS.t2864 60.6066
R6792 VSS.t25 VSS.t22 60.6066
R6793 VSS.t1600 VSS.t1597 60.6066
R6794 VSS.t1860 VSS.t1857 60.6066
R6795 VSS.t1348 VSS.t1345 60.6066
R6796 VSS.t2716 VSS.t2713 60.6066
R6797 VSS.t3407 VSS.t3404 60.6066
R6798 VSS.t53 VSS.t50 60.6066
R6799 VSS.t1627 VSS.t1624 60.6066
R6800 VSS.t1886 VSS.t1883 60.6066
R6801 VSS.t1372 VSS.t1369 60.6066
R6802 VSS.t2701 VSS.t2698 60.6066
R6803 VSS.t3227 VSS.t3224 60.6066
R6804 VSS.t81 VSS.t78 60.6066
R6805 VSS.t1653 VSS.t1650 60.6066
R6806 VSS.t1914 VSS.t1911 60.6066
R6807 VSS.t1400 VSS.t1397 60.6066
R6808 VSS.t2952 VSS.t2949 60.6066
R6809 VSS.t2721 VSS.t2718 60.6066
R6810 VSS.t1111 VSS.t1108 60.6066
R6811 VSS.t1681 VSS.t1678 60.6066
R6812 VSS.t1941 VSS.t1938 60.6066
R6813 VSS.t1426 VSS.t1423 60.6066
R6814 VSS.t2618 VSS.t2615 60.6066
R6815 VSS.t2480 VSS.t2477 60.6066
R6816 VSS.t4094 VSS.t4091 60.6066
R6817 VSS.t4232 VSS.t4229 60.6066
R6818 VSS.t2924 VSS.t2921 60.6066
R6819 VSS.t1999 VSS.t1996 60.6066
R6820 VSS.t1484 VSS.t1481 60.6066
R6821 VSS.t2457 VSS.t2459 60.6066
R6822 VSS.t2735 VSS.t2737 60.6066
R6823 VSS.t2491 VSS.t2488 60.6066
R6824 VSS.t2593 VSS.n1930 60.1893
R6825 VSS.t3699 VSS.n1982 60.0005
R6826 VSS.n3585 VSS.t180 57.829
R6827 VSS.n268 VSS.t1796 57.8008
R6828 VSS.t1536 VSS.n192 57.8008
R6829 VSS.t1278 VSS.n4494 57.8008
R6830 VSS.t3385 VSS.n4395 57.8008
R6831 VSS.t2856 VSS.n4538 57.8008
R6832 VSS.t2979 VSS.n4610 57.8008
R6833 VSS.t4206 VSS.n4265 57.1669
R6834 VSS.t3261 VSS.n3717 57.1669
R6835 VSS.t1146 VSS.n3765 57.1669
R6836 VSS.t1702 VSS.n3813 57.1669
R6837 VSS.t1961 VSS.n3673 57.1669
R6838 VSS.t1447 VSS.n3880 57.1669
R6839 VSS.t2656 VSS.n3947 57.1669
R6840 VSS.t2254 VSS.n2426 57.1669
R6841 VSS.t1477 VSS.n3386 57.1669
R6842 VSS.t1992 VSS.n2500 57.1669
R6843 VSS.t1728 VSS.n2572 57.1669
R6844 VSS.t1182 VSS.n2341 57.1669
R6845 VSS.n530 VSS.t2421 57.1669
R6846 VSS.n5944 VSS.t3247 57.1669
R6847 VSS.n5874 VSS.t4013 57.1669
R6848 VSS.n627 VSS.t2445 57.1669
R6849 VSS.n5665 VSS.t1316 57.1669
R6850 VSS.n5759 VSS.t1565 57.1669
R6851 VSS.n456 VSS.t1826 57.1669
R6852 VSS.t3351 VSS.n5219 57.1669
R6853 VSS.t3400 VSS.n5171 57.1669
R6854 VSS.t1593 VSS.n5104 57.1669
R6855 VSS.t1853 VSS.n4946 57.1669
R6856 VSS.t1341 VSS.n5037 57.1669
R6857 VSS.t2768 VSS.n5293 57.1669
R6858 VSS.t4171 VSS.n5545 57.1669
R6859 VSS.t44 VSS.n870 57.1669
R6860 VSS.t1620 VSS.n5497 57.1669
R6861 VSS.t1879 VSS.n1095 57.1669
R6862 VSS.t1365 VSS.n1027 57.1669
R6863 VSS.t3455 VSS.n960 57.1669
R6864 VSS.t2293 VSS.n1734 57.1669
R6865 VSS.t72 VSS.n1426 57.1669
R6866 VSS.t1646 VSS.n1519 57.1669
R6867 VSS.t1907 VSS.n1667 57.1669
R6868 VSS.t1393 VSS.n1592 57.1669
R6869 VSS.t2943 VSS.n4092 57.1669
R6870 VSS.t3277 VSS.n1282 57.1669
R6871 VSS.t1102 VSS.n2916 57.1669
R6872 VSS.t1674 VSS.n2890 57.1669
R6873 VSS.t1934 VSS.n2980 57.1669
R6874 VSS.t1419 VSS.n3134 57.1669
R6875 VSS.t4202 VSS.n3205 57.1669
R6876 VSS.t2553 VSS.n3269 57.1669
R6877 VSS.t2956 VSS.n1458 57.1669
R6878 VSS.t3116 VSS.n902 57.1669
R6879 VSS.t2610 VSS.n4978 57.1669
R6880 VSS.t3235 VSS.n3440 57.1669
R6881 VSS.t2625 VSS.n2189 57.1669
R6882 VSS.n266 VSS.t3676 55.1876
R6883 VSS.n190 VSS.t3668 55.1876
R6884 VSS.n4432 VSS.t3660 55.1876
R6885 VSS.n4393 VSS.t3657 55.1876
R6886 VSS.n4305 VSS.t3630 55.1876
R6887 VSS.n4556 VSS.t3626 55.1876
R6888 VSS.n4287 VSS.t3634 54.84
R6889 VSS.t3654 VSS.n3950 54.84
R6890 VSS.t3666 VSS.n3883 54.84
R6891 VSS.t3682 VSS.n3676 54.84
R6892 VSS.t3674 VSS.n3816 54.84
R6893 VSS.t3659 VSS.n3768 54.84
R6894 VSS.t3636 VSS.n3720 54.84
R6895 VSS.t3623 VSS.n2344 54.84
R6896 VSS.t3675 VSS.n2575 54.84
R6897 VSS.n528 VSS.t3639 54.84
R6898 VSS.n5942 VSS.t3642 54.84
R6899 VSS.n5872 VSS.t3648 54.84
R6900 VSS.n625 VSS.t3655 54.84
R6901 VSS.n5663 VSS.t3661 54.84
R6902 VSS.n5757 VSS.t3669 54.84
R6903 VSS.n454 VSS.t3677 54.84
R6904 VSS.t3643 VSS.n5222 54.84
R6905 VSS.t3656 VSS.n5174 54.84
R6906 VSS.t3670 VSS.n5107 54.84
R6907 VSS.t3678 VSS.n4949 54.84
R6908 VSS.t3662 VSS.n5040 54.84
R6909 VSS.t3629 VSS.n5296 54.84
R6910 VSS.t3644 VSS.n5548 54.84
R6911 VSS.t3621 VSS.n873 54.84
R6912 VSS.t3671 VSS.n5500 54.84
R6913 VSS.t3679 VSS.n1098 54.84
R6914 VSS.t3663 VSS.n1030 54.84
R6915 VSS.t3651 VSS.n963 54.84
R6916 VSS.t3625 VSS.n1737 54.84
R6917 VSS.t3658 VSS.n1429 54.84
R6918 VSS.t3672 VSS.n1522 54.84
R6919 VSS.t3680 VSS.n1670 54.84
R6920 VSS.t3664 VSS.n1595 54.84
R6921 VSS.t3650 VSS.n4095 54.84
R6922 VSS.n4184 VSS.t3646 54.84
R6923 VSS.n2957 VSS.t3622 54.84
R6924 VSS.n3310 VSS.t3673 54.84
R6925 VSS.n3111 VSS.t3681 54.84
R6926 VSS.n3182 VSS.t3665 54.84
R6927 VSS.n3246 VSS.t3652 54.84
R6928 VSS.n3291 VSS.t3631 54.84
R6929 VSS.n1480 VSS.t3640 54.84
R6930 VSS.n924 VSS.t3641 54.84
R6931 VSS.n5000 VSS.t3628 54.84
R6932 VSS.t3683 VSS.n2503 54.84
R6933 VSS.t3667 VSS.n3389 54.84
R6934 VSS.t3624 VSS.n2429 54.84
R6935 VSS.n3462 VSS.t3647 54.84
R6936 VSS.n2211 VSS.t3627 54.84
R6937 VSS.n98 VSS.n97 53.5719
R6938 VSS.n92 VSS.n91 53.5719
R6939 VSS.n86 VSS.n85 53.5719
R6940 VSS.n80 VSS.n79 53.5719
R6941 VSS.n74 VSS.n73 53.5719
R6942 VSS.n68 VSS.n67 53.5719
R6943 VSS.t2592 VSS.n1938 53.1083
R6944 VSS.n2013 VSS.t3734 52.777
R6945 VSS.n4279 VSS.n4275 52.211
R6946 VSS.n2203 VSS.n2199 52.211
R6947 VSS.n3725 VSS.n3686 52.211
R6948 VSS.n3773 VSS.n3734 52.211
R6949 VSS.n3821 VSS.n3782 52.211
R6950 VSS.n3681 VSS.n3642 52.211
R6951 VSS.n3888 VSS.n3849 52.211
R6952 VSS.n3955 VSS.n3916 52.211
R6953 VSS.n556 VSS.n518 52.211
R6954 VSS.n5900 VSS.n5862 52.211
R6955 VSS.n5691 VSS.n5653 52.211
R6956 VSS.n482 VSS.n444 52.211
R6957 VSS.n5785 VSS.n5747 52.211
R6958 VSS.n653 VSS.n615 52.211
R6959 VSS.n5970 VSS.n5932 52.211
R6960 VSS.n4992 VSS.n4988 52.211
R6961 VSS.n5301 VSS.n5262 52.211
R6962 VSS.n5045 VSS.n5006 52.211
R6963 VSS.n4954 VSS.n4915 52.211
R6964 VSS.n5112 VSS.n5073 52.211
R6965 VSS.n5179 VSS.n5140 52.211
R6966 VSS.n5227 VSS.n5188 52.211
R6967 VSS.n916 VSS.n912 52.211
R6968 VSS.n968 VSS.n929 52.211
R6969 VSS.n1035 VSS.n996 52.211
R6970 VSS.n1103 VSS.n1064 52.211
R6971 VSS.n5505 VSS.n5466 52.211
R6972 VSS.n878 VSS.n839 52.211
R6973 VSS.n5553 VSS.n5514 52.211
R6974 VSS.n1472 VSS.n1468 52.211
R6975 VSS.n4100 VSS.n4061 52.211
R6976 VSS.n1600 VSS.n1561 52.211
R6977 VSS.n1675 VSS.n1636 52.211
R6978 VSS.n1527 VSS.n1488 52.211
R6979 VSS.n1434 VSS.n1395 52.211
R6980 VSS.n1742 VSS.n1703 52.211
R6981 VSS.n4176 VSS.n4172 52.211
R6982 VSS.n2949 VSS.n2945 52.211
R6983 VSS.n3302 VSS.n3298 52.211
R6984 VSS.n3103 VSS.n3099 52.211
R6985 VSS.n3174 VSS.n3170 52.211
R6986 VSS.n3238 VSS.n3234 52.211
R6987 VSS.n3283 VSS.n3279 52.211
R6988 VSS.n2434 VSS.n2395 52.211
R6989 VSS.n3394 VSS.n3355 52.211
R6990 VSS.n2508 VSS.n2469 52.211
R6991 VSS.n2580 VSS.n2541 52.211
R6992 VSS.n2349 VSS.n2310 52.211
R6993 VSS.n3454 VSS.n3450 52.211
R6994 VSS.t2600 VSS.t3571 52.0838
R6995 VSS.t3049 VSS.t100 52.0838
R6996 VSS.t168 VSS.t141 51.9281
R6997 VSS.n6180 VSS.t2009 51.4291
R6998 VSS.n153 VSS.t1744 51.4291
R6999 VSS.n160 VSS.t2583 51.4291
R7000 VSS.t3467 VSS.n4214 51.4291
R7001 VSS.t3207 VSS.n4266 51.3709
R7002 VSS.t3105 VSS.n529 51.3709
R7003 VSS.t3241 VSS.n5943 51.3709
R7004 VSS.t4008 VSS.n5873 51.3709
R7005 VSS.t4184 VSS.n626 51.3709
R7006 VSS.t1303 VSS.n5664 51.3709
R7007 VSS.t1558 VSS.n5758 51.3709
R7008 VSS.t1818 VSS.n455 51.3709
R7009 VSS.t2549 VSS.n3270 51.3709
R7010 VSS.t4197 VSS.n3206 51.3709
R7011 VSS.t1413 VSS.n3135 51.3709
R7012 VSS.t1926 VSS.n2981 51.3709
R7013 VSS.t1635 VSS.n2891 51.3709
R7014 VSS.t1097 VSS.n2917 51.3709
R7015 VSS.t3273 VSS.n1283 51.3709
R7016 VSS.t2935 VSS.n1459 51.3709
R7017 VSS.t2771 VSS.n4093 51.3709
R7018 VSS.t1385 VSS.n1593 51.3709
R7019 VSS.t1868 VSS.n1668 51.3709
R7020 VSS.t1640 VSS.n1520 51.3709
R7021 VSS.t65 VSS.n1427 51.3709
R7022 VSS.t2289 VSS.n1735 51.3709
R7023 VSS.t3271 VSS.n903 51.3709
R7024 VSS.t3178 VSS.n961 51.3709
R7025 VSS.t1356 VSS.n1028 51.3709
R7026 VSS.t1873 VSS.n1096 51.3709
R7027 VSS.t1611 VSS.n5498 51.3709
R7028 VSS.t37 VSS.n871 51.3709
R7029 VSS.t3082 VSS.n5546 51.3709
R7030 VSS.t2613 VSS.n4979 51.3709
R7031 VSS.t2762 VSS.n5294 51.3709
R7032 VSS.t1334 VSS.n5038 51.3709
R7033 VSS.t1847 VSS.n4947 51.3709
R7034 VSS.t1554 VSS.n5105 51.3709
R7035 VSS.t3392 VSS.n5172 51.3709
R7036 VSS.t3347 VSS.n5220 51.3709
R7037 VSS.t4318 VSS.n3441 51.3709
R7038 VSS.t1177 VSS.n2342 51.3709
R7039 VSS.t1689 VSS.n2573 51.3709
R7040 VSS.t1984 VSS.n2501 51.3709
R7041 VSS.t1469 VSS.n3387 51.3709
R7042 VSS.t4188 VSS.n2427 51.3709
R7043 VSS.t2500 VSS.n2190 51.3709
R7044 VSS.t4264 VSS.n3948 51.3709
R7045 VSS.t1441 VSS.n3881 51.3709
R7046 VSS.t1953 VSS.n3674 51.3709
R7047 VSS.t1694 VSS.n3814 51.3709
R7048 VSS.t1140 VSS.n3766 51.3709
R7049 VSS.t3257 VSS.n3718 51.3709
R7050 VSS.t1759 VSS.n267 51.3709
R7051 VSS.t1500 VSS.n191 51.3709
R7052 VSS.t1248 VSS.n4419 51.3709
R7053 VSS.t2693 VSS.n4394 51.3709
R7054 VSS.t2811 VSS.n4292 51.3709
R7055 VSS.t3354 VSS.n4543 51.3709
R7056 VSS.n5995 VSS.n24 50.1554
R7057 VSS.n2070 VSS.t2579 50.0005
R7058 VSS.t2531 VSS.t107 49.6694
R7059 VSS.t871 VSS.n95 49.6521
R7060 VSS.t801 VSS.n89 49.6521
R7061 VSS.t646 VSS.n83 49.6521
R7062 VSS.t441 VSS.n77 49.6521
R7063 VSS.t426 VSS.n71 49.6521
R7064 VSS.t370 VSS.n65 49.6521
R7065 VSS.t2020 VSS.n141 48.3677
R7066 VSS.t3912 VSS.n271 48.3454
R7067 VSS.t3880 VSS.n195 48.3454
R7068 VSS.t3848 VSS.n4434 48.3454
R7069 VSS.t3824 VSS.n4398 48.3454
R7070 VSS.t3793 VSS.n4307 48.3454
R7071 VSS.t3726 VSS.n4558 48.3454
R7072 VSS.n4262 VSS.t3733 47.928
R7073 VSS.t3752 VSS.n532 47.928
R7074 VSS.t3700 VSS.n5946 47.928
R7075 VSS.t3799 VSS.n5876 47.928
R7076 VSS.t3703 VSS.n629 47.928
R7077 VSS.t3854 VSS.n5667 47.928
R7078 VSS.t3886 VSS.n5761 47.928
R7079 VSS.t3916 VSS.n458 47.928
R7080 VSS.n3266 VSS.t3764 47.928
R7081 VSS.n3202 VSS.t3707 47.928
R7082 VSS.n3131 VSS.t3868 47.928
R7083 VSS.n2977 VSS.t3932 47.928
R7084 VSS.n2887 VSS.t3900 47.928
R7085 VSS.n2913 VSS.t3837 47.928
R7086 VSS.n1279 VSS.t3774 47.928
R7087 VSS.n1455 VSS.t3760 47.928
R7088 VSS.n4090 VSS.t3803 47.928
R7089 VSS.n1590 VSS.t3864 47.928
R7090 VSS.n1665 VSS.t3928 47.928
R7091 VSS.n1517 VSS.t3898 47.928
R7092 VSS.n1424 VSS.t3833 47.928
R7093 VSS.n1732 VSS.t3779 47.928
R7094 VSS.n899 VSS.t3757 47.928
R7095 VSS.n958 VSS.t3806 47.928
R7096 VSS.n1025 VSS.t3860 47.928
R7097 VSS.n1093 VSS.t3926 47.928
R7098 VSS.n5495 VSS.t3892 47.928
R7099 VSS.n868 VSS.t3829 47.928
R7100 VSS.n5543 VSS.t3783 47.928
R7101 VSS.n4975 VSS.t3724 47.928
R7102 VSS.n5291 VSS.t3714 47.928
R7103 VSS.n5035 VSS.t3856 47.928
R7104 VSS.n4944 VSS.t3920 47.928
R7105 VSS.n5102 VSS.t3888 47.928
R7106 VSS.n5169 VSS.t3696 47.928
R7107 VSS.n5217 VSS.t3772 47.928
R7108 VSS.n3437 VSS.t3738 47.928
R7109 VSS.n2339 VSS.t3697 47.928
R7110 VSS.n2570 VSS.t3908 47.928
R7111 VSS.n2498 VSS.t3940 47.928
R7112 VSS.n3384 VSS.t3876 47.928
R7113 VSS.n2424 VSS.t3698 47.928
R7114 VSS.n2186 VSS.t3706 47.928
R7115 VSS.n3945 VSS.t3814 47.928
R7116 VSS.n3878 VSS.t3872 47.928
R7117 VSS.n3671 VSS.t3936 47.928
R7118 VSS.n3811 VSS.t3904 47.928
R7119 VSS.n3763 VSS.t3841 47.928
R7120 VSS.n3715 VSS.t3740 47.928
R7121 VSS.t2592 VSS.n1957 46.0272
R7122 VSS.t168 VSS.n1932 46.0272
R7123 VSS.n2055 VSS.t4275 45.8338
R7124 VSS.t1762 VSS.n268 44.7346
R7125 VSS.t1499 VSS.n192 44.7346
R7126 VSS.n4494 VSS.t1239 44.7346
R7127 VSS.t2694 VSS.n4395 44.7346
R7128 VSS.n4538 VSS.t2835 44.7346
R7129 VSS.n4610 VSS.t2472 44.7346
R7130 VSS.t3343 VSS.t3573 44.6434
R7131 VSS.t3341 VSS.t98 44.6434
R7132 VSS.n4265 VSS.t3208 44.341
R7133 VSS.t3106 VSS.n530 44.341
R7134 VSS.t3242 VSS.n5944 44.341
R7135 VSS.t4009 VSS.n5874 44.341
R7136 VSS.t2442 VSS.n627 44.341
R7137 VSS.t1313 VSS.n5665 44.341
R7138 VSS.t1562 VSS.n5759 44.341
R7139 VSS.t1821 VSS.n456 44.341
R7140 VSS.n3269 VSS.t2550 44.341
R7141 VSS.n3205 VSS.t4198 44.341
R7142 VSS.n3134 VSS.t1416 44.341
R7143 VSS.n2980 VSS.t1929 44.341
R7144 VSS.n2890 VSS.t1669 44.341
R7145 VSS.n2916 VSS.t1100 44.341
R7146 VSS.n1282 VSS.t3274 44.341
R7147 VSS.n1458 VSS.t2953 44.341
R7148 VSS.n4092 VSS.t3326 44.341
R7149 VSS.n1592 VSS.t1388 44.341
R7150 VSS.n1667 VSS.t1902 44.341
R7151 VSS.n1519 VSS.t1643 44.341
R7152 VSS.n1426 VSS.t69 44.341
R7153 VSS.n1734 VSS.t2290 44.341
R7154 VSS.n902 VSS.t3272 44.341
R7155 VSS.n960 VSS.t3452 44.341
R7156 VSS.n1027 VSS.t1360 44.341
R7157 VSS.n1095 VSS.t1876 44.341
R7158 VSS.n5497 VSS.t1615 44.341
R7159 VSS.n870 VSS.t41 44.341
R7160 VSS.n5545 VSS.t4168 44.341
R7161 VSS.n4978 VSS.t2607 44.341
R7162 VSS.n5293 VSS.t2765 44.341
R7163 VSS.n5037 VSS.t1337 44.341
R7164 VSS.n4946 VSS.t1848 44.341
R7165 VSS.n5104 VSS.t1588 44.341
R7166 VSS.n5171 VSS.t3395 44.341
R7167 VSS.n5219 VSS.t3348 44.341
R7168 VSS.n3440 VSS.t4319 44.341
R7169 VSS.n2341 VSS.t1180 44.341
R7170 VSS.n2572 VSS.t1723 44.341
R7171 VSS.n2500 VSS.t1987 44.341
R7172 VSS.n3386 VSS.t1472 44.341
R7173 VSS.n2426 VSS.t2251 44.341
R7174 VSS.n2189 VSS.t2501 44.341
R7175 VSS.n3947 VSS.t4265 44.341
R7176 VSS.n3880 VSS.t1444 44.341
R7177 VSS.n3673 VSS.t1956 44.341
R7178 VSS.n3813 VSS.t1697 44.341
R7179 VSS.n3765 VSS.t1143 44.341
R7180 VSS.n3717 VSS.t3258 44.341
R7181 VSS.n256 VSS.t1807 43.428
R7182 VSS.n289 VSS.n269 43.428
R7183 VSS.n180 VSS.t1547 43.428
R7184 VSS.n214 VSS.n193 43.428
R7185 VSS.n4422 VSS.t1289 43.428
R7186 VSS.n4493 VSS.n4418 43.428
R7187 VSS.n4383 VSS.t2434 43.428
R7188 VSS.n4500 VSS.n4396 43.428
R7189 VSS.n4295 VSS.t4022 43.428
R7190 VSS.n4537 VSS.n4291 43.428
R7191 VSS.n4546 VSS.t2388 43.428
R7192 VSS.n4609 VSS.n4542 43.428
R7193 VSS.n4275 VSS.t3264 43.1437
R7194 VSS.n2199 VSS.t2672 43.1437
R7195 VSS.n3686 VSS.t4288 43.1437
R7196 VSS.n3734 VSS.t1156 43.1437
R7197 VSS.n3782 VSS.t1710 43.1437
R7198 VSS.n3642 VSS.t1969 43.1437
R7199 VSS.n3849 VSS.t1457 43.1437
R7200 VSS.n3916 VSS.t2645 43.1437
R7201 VSS.n518 VSS.t4304 43.1437
R7202 VSS.n5862 VSS.t2750 43.1437
R7203 VSS.n5653 VSS.t1307 43.1437
R7204 VSS.n444 VSS.t1834 43.1437
R7205 VSS.n5747 VSS.t1575 43.1437
R7206 VSS.n615 VSS.t13 43.1437
R7207 VSS.n5932 VSS.t2323 43.1437
R7208 VSS.n4988 VSS.t2925 43.1437
R7209 VSS.n5262 VSS.t3170 43.1437
R7210 VSS.n5006 VSS.t1330 43.1437
R7211 VSS.n4915 VSS.t1861 43.1437
R7212 VSS.n5073 VSS.t1601 43.1437
R7213 VSS.n5140 VSS.t26 43.1437
R7214 VSS.n5188 VSS.t2868 43.1437
R7215 VSS.n912 VSS.t2984 43.1437
R7216 VSS.n929 VSS.t2702 43.1437
R7217 VSS.n996 VSS.t1373 43.1437
R7218 VSS.n1064 VSS.t1889 43.1437
R7219 VSS.n5466 VSS.t1628 43.1437
R7220 VSS.n839 VSS.t54 43.1437
R7221 VSS.n5514 VSS.t3408 43.1437
R7222 VSS.n1468 VSS.t4096 43.1437
R7223 VSS.n4061 VSS.t3315 43.1437
R7224 VSS.n1561 VSS.t1401 43.1437
R7225 VSS.n1636 VSS.t1915 43.1437
R7226 VSS.n1488 VSS.t1656 43.1437
R7227 VSS.n1395 VSS.t82 43.1437
R7228 VSS.n1703 VSS.t3193 43.1437
R7229 VSS.n4172 VSS.t2724 43.1437
R7230 VSS.n2945 VSS.t1120 43.1437
R7231 VSS.n3298 VSS.t1682 43.1437
R7232 VSS.n3099 VSS.t1942 43.1437
R7233 VSS.n3170 VSS.t1429 43.1437
R7234 VSS.n3234 VSS.t2619 43.1437
R7235 VSS.n3279 VSS.t2481 43.1437
R7236 VSS.n2395 VSS.t2462 43.1437
R7237 VSS.n3355 VSS.t1485 43.1437
R7238 VSS.n2469 VSS.t2000 43.1437
R7239 VSS.n2541 VSS.t1736 43.1437
R7240 VSS.n2310 VSS.t1192 43.1437
R7241 VSS.n3450 VSS.t2740 43.1437
R7242 VSS.t2242 VSS.n2299 42.8877
R7243 VSS.t2214 VSS.n2251 42.8877
R7244 VSS.t2186 VSS.n3059 42.8877
R7245 VSS.t2158 VSS.n5421 42.8877
R7246 VSS.t2130 VSS.n4838 42.8877
R7247 VSS.t2102 VSS.n4792 42.8877
R7248 VSS.t2074 VSS.n6004 42.8877
R7249 VSS.n2036 VSS.t3745 42.0559
R7250 VSS.t2237 VSS.n2268 41.8044
R7251 VSS.t2209 VSS.n2234 41.8044
R7252 VSS.t2181 VSS.n3029 41.8044
R7253 VSS.t2153 VSS.n1151 41.8044
R7254 VSS.t2125 VSS.n4809 41.8044
R7255 VSS.t2097 VSS.n4775 41.8044
R7256 VSS.t2069 VSS.n412 41.8044
R7257 VSS.n3477 VSS.t3602 41.5544
R7258 VSS.n3015 VSS.t4101 41.5544
R7259 VSS.n1137 VSS.t3495 41.5544
R7260 VSS.n4852 VSS.t3128 41.5544
R7261 VSS.n4885 VSS.t2635 41.5544
R7262 VSS.n398 VSS.t3064 41.5544
R7263 VSS.t1740 VSS.n156 41.4177
R7264 VSS.n2289 VSS.t2224 40.296
R7265 VSS.n3502 VSS.t2196 40.296
R7266 VSS.n3049 VSS.t2168 40.296
R7267 VSS.n5411 VSS.t2140 40.296
R7268 VSS.n4828 VSS.t2112 40.296
R7269 VSS.n5364 VSS.t2084 40.296
R7270 VSS.n432 VSS.t2056 40.296
R7271 VSS.t2218 VSS.n2224 39.2767
R7272 VSS.t2190 VSS.n3019 39.2767
R7273 VSS.t2162 VSS.n1141 39.2767
R7274 VSS.t2134 VSS.n4799 39.2767
R7275 VSS.t2106 VSS.n4765 39.2767
R7276 VSS.t2078 VSS.n402 39.2767
R7277 VSS.t2246 VSS.n2258 39.2404
R7278 VSS.n4279 VSS.t3751 38.8942
R7279 VSS.n3955 VSS.t3704 38.8942
R7280 VSS.n3888 VSS.t3875 38.8942
R7281 VSS.n3681 VSS.t3939 38.8942
R7282 VSS.n3821 VSS.t3907 38.8942
R7283 VSS.n3773 VSS.t3844 38.8942
R7284 VSS.n3725 VSS.t3796 38.8942
R7285 VSS.n2349 VSS.t3847 38.8942
R7286 VSS.n2580 VSS.t3911 38.8942
R7287 VSS.n556 VSS.t3731 38.8942
R7288 VSS.n5970 VSS.t3773 38.8942
R7289 VSS.n5900 VSS.t3719 38.8942
R7290 VSS.n653 VSS.t3695 38.8942
R7291 VSS.n5691 VSS.t3855 38.8942
R7292 VSS.n5785 VSS.t3887 38.8942
R7293 VSS.n482 VSS.t3919 38.8942
R7294 VSS.n5227 VSS.t3777 38.8942
R7295 VSS.n5179 VSS.t3828 38.8942
R7296 VSS.n5112 VSS.t3891 38.8942
R7297 VSS.n4954 VSS.t3923 38.8942
R7298 VSS.n5045 VSS.t3859 38.8942
R7299 VSS.n5301 VSS.t3801 38.8942
R7300 VSS.n5553 VSS.t3781 38.8942
R7301 VSS.n878 VSS.t3832 38.8942
R7302 VSS.n5505 VSS.t3895 38.8942
R7303 VSS.n1103 VSS.t3927 38.8942
R7304 VSS.n1035 VSS.t3863 38.8942
R7305 VSS.n968 VSS.t3802 38.8942
R7306 VSS.n1742 VSS.t3778 38.8942
R7307 VSS.n1434 VSS.t3836 38.8942
R7308 VSS.n1527 VSS.t3899 38.8942
R7309 VSS.n1675 VSS.t3931 38.8942
R7310 VSS.n1600 VSS.t3867 38.8942
R7311 VSS.n4100 VSS.t3811 38.8942
R7312 VSS.n4176 VSS.t3790 38.8942
R7313 VSS.n2949 VSS.t3840 38.8942
R7314 VSS.n3302 VSS.t3903 38.8942
R7315 VSS.n3103 VSS.t3935 38.8942
R7316 VSS.n3174 VSS.t3871 38.8942
R7317 VSS.n3238 VSS.t3816 38.8942
R7318 VSS.n3283 VSS.t3711 38.8942
R7319 VSS.n1472 VSS.t3729 38.8942
R7320 VSS.n916 VSS.t3756 38.8942
R7321 VSS.n4992 VSS.t3755 38.8942
R7322 VSS.n2508 VSS.t3943 38.8942
R7323 VSS.n3394 VSS.t3879 38.8942
R7324 VSS.n2434 VSS.t3818 38.8942
R7325 VSS.n3454 VSS.t3728 38.8942
R7326 VSS.n2203 VSS.t3705 38.8942
R7327 VSS.t2577 VSS.n2069 38.4994
R7328 VSS.n2267 VSS.t2234 38.1934
R7329 VSS.n2233 VSS.t2206 38.1934
R7330 VSS.n3028 VSS.t2178 38.1934
R7331 VSS.n1150 VSS.t2150 38.1934
R7332 VSS.n4808 VSS.t2122 38.1934
R7333 VSS.n4774 VSS.t2094 38.1934
R7334 VSS.n411 VSS.t2066 38.1934
R7335 VSS.n3988 VSS.n1787 38.1861
R7336 VSS.t1809 VSS.n254 37.8925
R7337 VSS.t1549 VSS.n178 37.8925
R7338 VSS.t1291 VSS.n4420 37.8925
R7339 VSS.t2436 VSS.n4381 37.8925
R7340 VSS.t4024 VSS.n4293 37.8925
R7341 VSS.t2390 VSS.n4544 37.8925
R7342 VSS.n4274 VSS.t3266 37.5653
R7343 VSS.n2198 VSS.t2674 37.5653
R7344 VSS.n3684 VSS.t4290 37.5653
R7345 VSS.n3732 VSS.t1158 37.5653
R7346 VSS.n3780 VSS.t1712 37.5653
R7347 VSS.t1971 VSS.n3640 37.5653
R7348 VSS.n3847 VSS.t1459 37.5653
R7349 VSS.n3914 VSS.t2647 37.5653
R7350 VSS.n516 VSS.t4306 37.5653
R7351 VSS.n5860 VSS.t2752 37.5653
R7352 VSS.n5651 VSS.t1309 37.5653
R7353 VSS.t1836 VSS.n442 37.5653
R7354 VSS.n5745 VSS.t1577 37.5653
R7355 VSS.n613 VSS.t15 37.5653
R7356 VSS.n5930 VSS.t2325 37.5653
R7357 VSS.n4987 VSS.t2927 37.5653
R7358 VSS.n5260 VSS.t3172 37.5653
R7359 VSS.n5004 VSS.t1332 37.5653
R7360 VSS.t1863 VSS.n4913 37.5653
R7361 VSS.n5071 VSS.t1603 37.5653
R7362 VSS.n5138 VSS.t28 37.5653
R7363 VSS.n5186 VSS.t2870 37.5653
R7364 VSS.n911 VSS.t2986 37.5653
R7365 VSS.n927 VSS.t2704 37.5653
R7366 VSS.n994 VSS.t1375 37.5653
R7367 VSS.n1062 VSS.t1891 37.5653
R7368 VSS.n5464 VSS.t1630 37.5653
R7369 VSS.t56 VSS.n837 37.5653
R7370 VSS.n5512 VSS.t3410 37.5653
R7371 VSS.n1467 VSS.t4098 37.5653
R7372 VSS.n4059 VSS.t3317 37.5653
R7373 VSS.n1559 VSS.t1403 37.5653
R7374 VSS.n1634 VSS.t1917 37.5653
R7375 VSS.n1486 VSS.t1658 37.5653
R7376 VSS.t84 VSS.n1393 37.5653
R7377 VSS.n1701 VSS.t3195 37.5653
R7378 VSS.n4171 VSS.t2726 37.5653
R7379 VSS.n2944 VSS.t1122 37.5653
R7380 VSS.n3297 VSS.t1684 37.5653
R7381 VSS.n3098 VSS.t1944 37.5653
R7382 VSS.n3169 VSS.t1431 37.5653
R7383 VSS.n3233 VSS.t2621 37.5653
R7384 VSS.n3278 VSS.t2483 37.5653
R7385 VSS.n2393 VSS.t2464 37.5653
R7386 VSS.n3353 VSS.t1487 37.5653
R7387 VSS.n2467 VSS.t2002 37.5653
R7388 VSS.n2539 VSS.t1738 37.5653
R7389 VSS.n2308 VSS.t1194 37.5653
R7390 VSS.n3449 VSS.t2742 37.5653
R7391 VSS.n3525 VSS.n3524 37.0209
R7392 VSS.t3529 VSS.n4245 36.9781
R7393 VSS.n5964 VSS.t3339 36.9781
R7394 VSS.n5894 VSS.t4007 36.9781
R7395 VSS.n647 VSS.t2470 36.9781
R7396 VSS.n5685 VSS.t1311 36.9781
R7397 VSS.n5779 VSS.t1560 36.9781
R7398 VSS.n476 VSS.t1819 36.9781
R7399 VSS.n550 VSS.t3107 36.9781
R7400 VSS.t2916 VSS.n3249 36.9781
R7401 VSS.t4196 VSS.n3185 36.9781
R7402 VSS.t1414 VSS.n3114 36.9781
R7403 VSS.t1927 VSS.n2960 36.9781
R7404 VSS.t1667 VSS.n2870 36.9781
R7405 VSS.t1098 VSS.n2896 36.9781
R7406 VSS.t3202 VSS.n1262 36.9781
R7407 VSS.t4081 VSS.n1437 36.9781
R7408 VSS.n4091 VSS.t3324 36.9781
R7409 VSS.n1591 VSS.t1386 36.9781
R7410 VSS.n1666 VSS.t1900 36.9781
R7411 VSS.n1518 VSS.t1641 36.9781
R7412 VSS.n1425 VSS.t67 36.9781
R7413 VSS.n1733 VSS.t4316 36.9781
R7414 VSS.t3313 VSS.n881 36.9781
R7415 VSS.n959 VSS.t2732 36.9781
R7416 VSS.n1026 VSS.t1358 36.9781
R7417 VSS.n1094 VSS.t1874 36.9781
R7418 VSS.n5496 VSS.t1613 36.9781
R7419 VSS.n869 VSS.t39 36.9781
R7420 VSS.n5544 VSS.t3083 36.9781
R7421 VSS.t4153 VSS.n4957 36.9781
R7422 VSS.n5292 VSS.t2763 36.9781
R7423 VSS.n5036 VSS.t1335 36.9781
R7424 VSS.n4945 VSS.t1845 36.9781
R7425 VSS.n5103 VSS.t1586 36.9781
R7426 VSS.n5170 VSS.t3393 36.9781
R7427 VSS.n5218 VSS.t2557 36.9781
R7428 VSS.t4317 VSS.n3419 36.9781
R7429 VSS.n2340 VSS.t1178 36.9781
R7430 VSS.n2571 VSS.t1721 36.9781
R7431 VSS.n2499 VSS.t1985 36.9781
R7432 VSS.n3385 VSS.t1470 36.9781
R7433 VSS.n2425 VSS.t2452 36.9781
R7434 VSS.t2632 VSS.n2168 36.9781
R7435 VSS.n3946 VSS.t4263 36.9781
R7436 VSS.n3879 VSS.t1442 36.9781
R7437 VSS.n3672 VSS.t1954 36.9781
R7438 VSS.n3812 VSS.t1695 36.9781
R7439 VSS.n3764 VSS.t1141 36.9781
R7440 VSS.n3716 VSS.t4139 36.9781
R7441 VSS.t4064 VSS.n1929 36.5859
R7442 VSS.n2291 VSS.t3987 35.6657
R7443 VSS.n3506 VSS.t3981 35.6657
R7444 VSS.n3051 VSS.t3975 35.6657
R7445 VSS.n5413 VSS.t3969 35.6657
R7446 VSS.n4830 VSS.t3963 35.6657
R7447 VSS.n5368 VSS.t3957 35.6657
R7448 VSS.n434 VSS.t3951 35.6657
R7449 VSS.n5995 VSS.n426 34.6659
R7450 VSS.n3466 VSS.n3465 34.5826
R7451 VSS.n295 VSS.t1799 34.5713
R7452 VSS.n220 VSS.t1539 34.5713
R7453 VSS.n4458 VSS.t1287 34.5713
R7454 VSS.n4506 VSS.t2426 34.5713
R7455 VSS.n4331 VSS.t4021 34.5713
R7456 VSS.n4582 VSS.t2380 34.5713
R7457 VSS.n4284 VSS.t3179 34.4048
R7458 VSS.t2653 VSS.n3953 34.4048
R7459 VSS.t1455 VSS.n3886 34.4048
R7460 VSS.t1958 VSS.n3679 34.4048
R7461 VSS.t1699 VSS.n3819 34.4048
R7462 VSS.t1149 VSS.n3771 34.4048
R7463 VSS.t3255 VSS.n3723 34.4048
R7464 VSS.t1185 VSS.n2347 34.4048
R7465 VSS.t1725 VSS.n2578 34.4048
R7466 VSS.n555 VSS.t4303 34.4048
R7467 VSS.n5969 VSS.t3244 34.4048
R7468 VSS.n5899 VSS.t4011 34.4048
R7469 VSS.n652 VSS.t6 34.4048
R7470 VSS.n5690 VSS.t1324 34.4048
R7471 VSS.n5784 VSS.t1573 34.4048
R7472 VSS.n481 VSS.t1823 34.4048
R7473 VSS.t2424 VSS.n5225 34.4048
R7474 VSS.t3397 VSS.n5177 34.4048
R7475 VSS.t1590 VSS.n5110 34.4048
R7476 VSS.t1850 VSS.n4952 34.4048
R7477 VSS.t1338 VSS.n5043 34.4048
R7478 VSS.t2710 VSS.n5299 34.4048
R7479 VSS.t4227 VSS.n5551 34.4048
R7480 VSS.t47 VSS.n876 34.4048
R7481 VSS.t1617 VSS.n5503 34.4048
R7482 VSS.t1887 VSS.n1101 34.4048
R7483 VSS.t1362 VSS.n1033 34.4048
R7484 VSS.t2695 VSS.n966 34.4048
R7485 VSS.t3228 VSS.n1740 34.4048
R7486 VSS.t75 VSS.n1432 34.4048
R7487 VSS.t1654 VSS.n1525 34.4048
R7488 VSS.t1904 VSS.n1673 34.4048
R7489 VSS.t1390 VSS.n1598 34.4048
R7490 VSS.t2946 VSS.n4098 34.4048
R7491 VSS.n4181 VSS.t2722 34.4048
R7492 VSS.n2954 VSS.t1105 34.4048
R7493 VSS.n3307 VSS.t1671 34.4048
R7494 VSS.n3108 VSS.t1931 34.4048
R7495 VSS.n3179 VSS.t1427 34.4048
R7496 VSS.n3243 VSS.t4200 34.4048
R7497 VSS.n3288 VSS.t2474 34.4048
R7498 VSS.n1477 VSS.t4095 34.4048
R7499 VSS.n921 VSS.t2982 34.4048
R7500 VSS.n4997 VSS.t2918 34.4048
R7501 VSS.t1989 VSS.n2506 34.4048
R7502 VSS.t1474 VSS.n3392 34.4048
R7503 VSS.t2454 VSS.n2432 34.4048
R7504 VSS.n3459 VSS.t3232 34.4048
R7505 VSS.n2208 VSS.t2485 34.4048
R7506 VSS.t2226 VSS.n2276 34.3048
R7507 VSS.n3503 VSS.t2200 34.3048
R7508 VSS.t2172 VSS.n3037 34.3048
R7509 VSS.t2142 VSS.n1159 34.3048
R7510 VSS.t2116 VSS.n4817 34.3048
R7511 VSS.n5365 VSS.t2088 34.3048
R7512 VSS.t2058 VSS.n421 34.3048
R7513 VSS.t1752 VSS.n281 34.2816
R7514 VSS.t1490 VSS.n205 34.2816
R7515 VSS.t1242 VSS.n4445 34.2816
R7516 VSS.t2688 VSS.n4409 34.2816
R7517 VSS.t2849 VSS.n4318 34.2816
R7518 VSS.t3336 VSS.n4569 34.2816
R7519 VSS.t2229 VSS.n2291 34.2213
R7520 VSS.t2201 VSS.n3506 34.2213
R7521 VSS.t2173 VSS.n3051 34.2213
R7522 VSS.t2145 VSS.n5413 34.2213
R7523 VSS.t2117 VSS.n4830 34.2213
R7524 VSS.t2089 VSS.n5368 34.2213
R7525 VSS.t2061 VSS.n434 34.2213
R7526 VSS.n4251 VSS.t2564 34.0763
R7527 VSS.t3269 VSS.n542 34.0763
R7528 VSS.t2969 VSS.n5956 34.0763
R7529 VSS.t4001 VSS.n5886 34.0763
R7530 VSS.t2440 VSS.n639 34.0763
R7531 VSS.t1295 VSS.n5677 34.0763
R7532 VSS.t1552 VSS.n5771 34.0763
R7533 VSS.t1812 VSS.n468 34.0763
R7534 VSS.n3255 VSS.t4078 34.0763
R7535 VSS.n3191 VSS.t3321 34.0763
R7536 VSS.n3120 VSS.t1407 34.0763
R7537 VSS.n2966 VSS.t1920 34.0763
R7538 VSS.n2876 VSS.t1661 34.0763
R7539 VSS.n2902 VSS.t88 34.0763
R7540 VSS.n1268 VSS.t3199 34.0763
R7541 VSS.n1443 VSS.t2547 34.0763
R7542 VSS.t2708 VSS.n4083 34.0763
R7543 VSS.t1379 VSS.n1583 34.0763
R7544 VSS.t1894 VSS.n1658 34.0763
R7545 VSS.t1633 VSS.n1510 34.0763
R7546 VSS.t60 VSS.n1417 34.0763
R7547 VSS.t3414 VSS.n1725 34.0763
R7548 VSS.n887 VSS.t2845 34.0763
R7549 VSS.t3176 VSS.n951 34.0763
R7550 VSS.t1351 VSS.n1018 34.0763
R7551 VSS.t1866 VSS.n1086 34.0763
R7552 VSS.t1606 VSS.n5488 34.0763
R7553 VSS.t32 VSS.n861 34.0763
R7554 VSS.t2874 VSS.n5536 34.0763
R7555 VSS.n4963 VSS.t4296 34.0763
R7556 VSS.t2756 VSS.n5284 34.0763
R7557 VSS.t1299 VSS.n5028 34.0763
R7558 VSS.t1839 VSS.n4937 34.0763
R7559 VSS.t1580 VSS.n5095 34.0763
R7560 VSS.t19 VSS.n5162 34.0763
R7561 VSS.t2329 VSS.n5210 34.0763
R7562 VSS.n3425 VSS.t4293 34.0763
R7563 VSS.t1162 VSS.n2332 34.0763
R7564 VSS.t1715 VSS.n2563 34.0763
R7565 VSS.t1974 VSS.n2491 34.0763
R7566 VSS.t1463 VSS.n3377 34.0763
R7567 VSS.t2650 VSS.n2417 34.0763
R7568 VSS.n2174 VSS.t3191 34.0763
R7569 VSS.t4186 VSS.n3938 34.0763
R7570 VSS.t1435 VSS.n3871 34.0763
R7571 VSS.t1947 VSS.n3664 34.0763
R7572 VSS.t1687 VSS.n3804 34.0763
R7573 VSS.t1126 VSS.n3756 34.0763
R7574 VSS.t4121 VSS.n3708 34.0763
R7575 VSS.t2235 VSS.n2266 33.5826
R7576 VSS.t2207 VSS.n2232 33.5826
R7577 VSS.t2179 VSS.n3027 33.5826
R7578 VSS.t2151 VSS.n1149 33.5826
R7579 VSS.t2123 VSS.n4807 33.5826
R7580 VSS.t2095 VSS.n4773 33.5826
R7581 VSS.t2067 VSS.n410 33.5826
R7582 VSS.n3474 VSS.t3604 33.4991
R7583 VSS.n3012 VSS.t4103 33.4991
R7584 VSS.n1134 VSS.t3497 33.4991
R7585 VSS.n4849 VSS.t3130 33.4991
R7586 VSS.n4882 VSS.t2637 33.4991
R7587 VSS.n394 VSS.t3066 33.4991
R7588 VSS.t2223 VSS.n2278 33.2215
R7589 VSS.t2195 VSS.n3500 33.2215
R7590 VSS.t2167 VSS.n3039 33.2215
R7591 VSS.t2139 VSS.n1161 33.2215
R7592 VSS.t2111 VSS.n4819 33.2215
R7593 VSS.t2083 VSS.n5362 33.2215
R7594 VSS.t2055 VSS.n423 33.2215
R7595 VSS.n4125 VSS.n1230 32.8625
R7596 VSS.n5586 VSS.n757 32.8625
R7597 VSS.n5327 VSS.n682 32.8625
R7598 VSS.n5992 VSS.n5991 32.8625
R7599 VSS.n3294 VSS.n1305 32.8625
R7600 VSS.n2301 VSS.t2244 32.8604
R7601 VSS.n2253 VSS.t2216 32.8604
R7602 VSS.n3061 VSS.t2188 32.8604
R7603 VSS.n5423 VSS.t2160 32.8604
R7604 VSS.n4840 VSS.t2132 32.8604
R7605 VSS.n4794 VSS.t2104 32.8604
R7606 VSS.n6006 VSS.t2076 32.8604
R7607 VSS.t2004 VSS.n6179 32.8462
R7608 VSS.t1976 VSS.n6183 32.8462
R7609 VSS.n4227 VSS.t3469 32.8462
R7610 VSS.n4232 VSS.t3086 32.8462
R7611 VSS.n100 VSS.n99 32.666
R7612 VSS.n288 VSS.t1767 32.666
R7613 VSS.n94 VSS.n93 32.666
R7614 VSS.n212 VSS.t1505 32.666
R7615 VSS.n88 VSS.n87 32.666
R7616 VSS.n4452 VSS.t1249 32.666
R7617 VSS.n82 VSS.n81 32.666
R7618 VSS.n4416 VSS.t4183 32.666
R7619 VSS.n76 VSS.n75 32.666
R7620 VSS.n4325 VSS.t2812 32.666
R7621 VSS.n70 VSS.n69 32.666
R7622 VSS.n4576 VSS.t3416 32.666
R7623 VSS.t3531 VSS.n4246 32.3839
R7624 VSS.n549 VSS.t3214 32.3839
R7625 VSS.n5963 VSS.t3338 32.3839
R7626 VSS.n5893 VSS.t4006 32.3839
R7627 VSS.n646 VSS.t2469 32.3839
R7628 VSS.n5684 VSS.t1302 32.3839
R7629 VSS.n5778 VSS.t1559 32.3839
R7630 VSS.n475 VSS.t1817 32.3839
R7631 VSS.t2786 VSS.n3250 32.3839
R7632 VSS.t4195 VSS.n3186 32.3839
R7633 VSS.t1412 VSS.n3115 32.3839
R7634 VSS.t1925 VSS.n2961 32.3839
R7635 VSS.t1666 VSS.n2871 32.3839
R7636 VSS.t1096 VSS.n2897 32.3839
R7637 VSS.t3201 VSS.n1263 32.3839
R7638 VSS.t4080 VSS.n1438 32.3839
R7639 VSS.n4089 VSS.t3323 32.3839
R7640 VSS.n1589 VSS.t1384 32.3839
R7641 VSS.n1664 VSS.t1899 32.3839
R7642 VSS.n1516 VSS.t1639 32.3839
R7643 VSS.n1423 VSS.t66 32.3839
R7644 VSS.n1731 VSS.t4315 32.3839
R7645 VSS.t3312 VSS.n882 32.3839
R7646 VSS.n957 VSS.t2731 32.3839
R7647 VSS.n1024 VSS.t1357 32.3839
R7648 VSS.n1092 VSS.t1872 32.3839
R7649 VSS.n5494 VSS.t1612 32.3839
R7650 VSS.n867 VSS.t38 32.3839
R7651 VSS.n5542 VSS.t3081 32.3839
R7652 VSS.t4152 VSS.n4958 32.3839
R7653 VSS.n5290 VSS.t2761 32.3839
R7654 VSS.n5034 VSS.t1326 32.3839
R7655 VSS.n4943 VSS.t1844 32.3839
R7656 VSS.n5101 VSS.t1585 32.3839
R7657 VSS.n5168 VSS.t3391 32.3839
R7658 VSS.n5216 VSS.t2556 32.3839
R7659 VSS.t4323 VSS.n3420 32.3839
R7660 VSS.n2338 VSS.t1168 32.3839
R7661 VSS.n2569 VSS.t1720 32.3839
R7662 VSS.n2497 VSS.t1983 32.3839
R7663 VSS.n3383 VSS.t1468 32.3839
R7664 VSS.n2423 VSS.t2451 32.3839
R7665 VSS.t2631 VSS.n2169 32.3839
R7666 VSS.n3944 VSS.t4262 32.3839
R7667 VSS.n3877 VSS.t1440 32.3839
R7668 VSS.n3670 VSS.t1952 32.3839
R7669 VSS.n3810 VSS.t1693 32.3839
R7670 VSS.n3762 VSS.t1132 32.3839
R7671 VSS.n3714 VSS.t4138 32.3839
R7672 VSS.n2290 VSS.t2228 32.1382
R7673 VSS.n3504 VSS.t2198 32.1382
R7674 VSS.n3050 VSS.t2170 32.1382
R7675 VSS.n5412 VSS.t2144 32.1382
R7676 VSS.n4829 VSS.t2114 32.1382
R7677 VSS.n5366 VSS.t2086 32.1382
R7678 VSS.n433 VSS.t2060 32.1382
R7679 VSS.t2596 VSS.n1956 31.8652
R7680 VSS.n3496 VSS.t1078 31.7771
R7681 VSS.n3078 VSS.t1071 31.7771
R7682 VSS.n5440 VSS.t902 31.7771
R7683 VSS.n4871 VSS.t1061 31.7771
R7684 VSS.n5358 VSS.t1053 31.7771
R7685 VSS.n6021 VSS.t1042 31.7771
R7686 VSS.t3691 VSS.n2267 31.6936
R7687 VSS.t3690 VSS.n2233 31.6936
R7688 VSS.t3689 VSS.n3028 31.6936
R7689 VSS.t3688 VSS.n1150 31.6936
R7690 VSS.t3687 VSS.n4808 31.6936
R7691 VSS.t3686 VSS.n4774 31.6936
R7692 VSS.t3685 VSS.n411 31.6936
R7693 VSS.n2122 VSS.t326 31.6835
R7694 VSS.n1182 VSS.t313 31.6835
R7695 VSS.n4205 VSS.t271 31.6835
R7696 VSS.n1178 VSS.t264 31.6835
R7697 VSS.n4745 VSS.t259 31.6835
R7698 VSS.n0 VSS.t251 31.6835
R7699 VSS.n6248 VSS.t236 31.6835
R7700 VSS.n2294 VSS.t2230 31.6296
R7701 VSS.n2246 VSS.t2202 31.6296
R7702 VSS.n3054 VSS.t2174 31.6296
R7703 VSS.n5416 VSS.t2146 31.6296
R7704 VSS.n4833 VSS.t2120 31.6296
R7705 VSS.n4787 VSS.t2092 31.6296
R7706 VSS.n5999 VSS.t2062 31.6296
R7707 VSS.t3608 VSS.n3470 31.416
R7708 VSS.n3486 VSS.t3601 31.416
R7709 VSS.t4108 VSS.n3008 31.416
R7710 VSS.n3068 VSS.t4100 31.416
R7711 VSS.t3504 VSS.n1130 31.416
R7712 VSS.n5430 VSS.t3494 31.416
R7713 VSS.t3134 VSS.n4845 31.416
R7714 VSS.n4861 VSS.t3127 31.416
R7715 VSS.t2644 VSS.n4878 31.416
R7716 VSS.n5348 VSS.t2634 31.416
R7717 VSS.t3070 VSS.n390 31.416
R7718 VSS.n6011 VSS.t3063 31.416
R7719 VSS.n6239 VSS.n6238 30.6337
R7720 VSS.t3610 VSS.n3489 30.6103
R7721 VSS.t4110 VSS.n3071 30.6103
R7722 VSS.t3500 VSS.n5433 30.6103
R7723 VSS.t3136 VSS.n4864 30.6103
R7724 VSS.t2640 VSS.n5351 30.6103
R7725 VSS.t3072 VSS.n6014 30.6103
R7726 VSS.n296 VSS.t1801 30.3618
R7727 VSS.n221 VSS.t1541 30.3618
R7728 VSS.n4459 VSS.t1281 30.3618
R7729 VSS.n4507 VSS.t2428 30.3618
R7730 VSS.n4332 VSS.t4015 30.3618
R7731 VSS.n4583 VSS.t2382 30.3618
R7732 VSS.n280 VSS.t3219 30.0528
R7733 VSS.n204 VSS.t3221 30.0528
R7734 VSS.n4444 VSS.t3209 30.0528
R7735 VSS.n4408 VSS.t3217 30.0528
R7736 VSS.n4317 VSS.t2534 30.0528
R7737 VSS.n4568 VSS.t2527 30.0528
R7738 VSS.n4252 VSS.t2536 29.7932
R7739 VSS.n541 VSS.t3002 29.7932
R7740 VSS.n5955 VSS.t3000 29.7932
R7741 VSS.n5885 VSS.t2998 29.7932
R7742 VSS.n638 VSS.t2996 29.7932
R7743 VSS.n5676 VSS.t3059 29.7932
R7744 VSS.n5770 VSS.t2805 29.7932
R7745 VSS.n467 VSS.t2992 29.7932
R7746 VSS.n3256 VSS.t2990 29.7932
R7747 VSS.n3192 VSS.t2994 29.7932
R7748 VSS.n3121 VSS.t3036 29.7932
R7749 VSS.n2967 VSS.t2678 29.7932
R7750 VSS.n2877 VSS.t2680 29.7932
R7751 VSS.n2903 VSS.t2676 29.7932
R7752 VSS.n1269 VSS.t2988 29.7932
R7753 VSS.t3091 VSS.n1444 29.7932
R7754 VSS.n4081 VSS.t3515 29.7932
R7755 VSS.n1581 VSS.t2529 29.7932
R7756 VSS.n1656 VSS.t2523 29.7932
R7757 VSS.n1508 VSS.t2525 29.7932
R7758 VSS.n1415 VSS.t2538 29.7932
R7759 VSS.n1723 VSS.t3519 29.7932
R7760 VSS.t2310 VSS.n888 29.7932
R7761 VSS.n949 VSS.t2306 29.7932
R7762 VSS.n1016 VSS.t2300 29.7932
R7763 VSS.n1084 VSS.t3476 29.7932
R7764 VSS.n5486 VSS.t2302 29.7932
R7765 VSS.n859 VSS.t2304 29.7932
R7766 VSS.n5534 VSS.t2308 29.7932
R7767 VSS.t3089 VSS.n4964 29.7932
R7768 VSS.n5282 VSS.t3093 29.7932
R7769 VSS.n5026 VSS.t3517 29.7932
R7770 VSS.n4935 VSS.t2542 29.7932
R7771 VSS.n5093 VSS.t2544 29.7932
R7772 VSS.n5160 VSS.t2540 29.7932
R7773 VSS.n5208 VSS.t3095 29.7932
R7774 VSS.t493 VSS.n3426 29.7932
R7775 VSS.n2330 VSS.t660 29.7932
R7776 VSS.n2561 VSS.t868 29.7932
R7777 VSS.n2489 VSS.t990 29.7932
R7778 VSS.n3375 VSS.t760 29.7932
R7779 VSS.n2415 VSS.t574 29.7932
R7780 VSS.t2972 VSS.n2175 29.7932
R7781 VSS.n3936 VSS.t2518 29.7932
R7782 VSS.n3869 VSS.t2809 29.7932
R7783 VSS.n3662 VSS.t2931 29.7932
R7784 VSS.n3802 VSS.t2933 29.7932
R7785 VSS.n3754 VSS.t2929 29.7932
R7786 VSS.n3706 VSS.t2516 29.7932
R7787 VSS.t133 VSS.t180 29.5048
R7788 VSS.t2239 VSS.n2265 29.2494
R7789 VSS.t3986 VSS.n2275 29.2494
R7790 VSS.t2211 VSS.n2231 29.2494
R7791 VSS.n3505 VSS.t3980 29.2494
R7792 VSS.t2183 VSS.n3026 29.2494
R7793 VSS.t3974 VSS.n3036 29.2494
R7794 VSS.t2155 VSS.n1148 29.2494
R7795 VSS.t3968 VSS.n1158 29.2494
R7796 VSS.t2127 VSS.n4806 29.2494
R7797 VSS.t3962 VSS.n4816 29.2494
R7798 VSS.t2099 VSS.n4772 29.2494
R7799 VSS.n5367 VSS.t3956 29.2494
R7800 VSS.t2071 VSS.n409 29.2494
R7801 VSS.t3950 VSS.n420 29.2494
R7802 VSS.t4279 VSS.n2024 28.9878
R7803 VSS.t2231 VSS.n2272 28.5272
R7804 VSS.t3607 VSS.n3470 28.5272
R7805 VSS.n3486 VSS.t1074 28.5272
R7806 VSS.t2203 VSS.n3508 28.5272
R7807 VSS.t4107 VSS.n3008 28.5272
R7808 VSS.n3068 VSS.t905 28.5272
R7809 VSS.t2175 VSS.n3033 28.5272
R7810 VSS.t3503 VSS.n1130 28.5272
R7811 VSS.n5430 VSS.t898 28.5272
R7812 VSS.t2147 VSS.n1155 28.5272
R7813 VSS.t3133 VSS.n4845 28.5272
R7814 VSS.n4861 VSS.t894 28.5272
R7815 VSS.t2118 VSS.n4813 28.5272
R7816 VSS.t2643 VSS.n4878 28.5272
R7817 VSS.n5348 VSS.t1049 28.5272
R7818 VSS.t2090 VSS.n5370 28.5272
R7819 VSS.t3069 VSS.n390 28.5272
R7820 VSS.n6011 VSS.t1038 28.5272
R7821 VSS.t2063 VSS.n417 28.5272
R7822 VSS.n427 VSS.t1774 28.5272
R7823 VSS.n3496 VSS.t3611 28.1661
R7824 VSS.n3078 VSS.t4106 28.1661
R7825 VSS.n5440 VSS.t3502 28.1661
R7826 VSS.n4871 VSS.t3137 28.1661
R7827 VSS.n5358 VSS.t2642 28.1661
R7828 VSS.n6021 VSS.t3073 28.1661
R7829 VSS.t3605 VSS.n3471 27.7215
R7830 VSS.t4104 VSS.n3009 27.7215
R7831 VSS.t3498 VSS.n1131 27.7215
R7832 VSS.t3131 VSS.n4846 27.7215
R7833 VSS.t2638 VSS.n4879 27.7215
R7834 VSS.t3067 VSS.n391 27.7215
R7835 VSS.t3915 VSS.n263 27.4395
R7836 VSS.t1793 VSS.n274 27.4395
R7837 VSS.t3883 VSS.n187 27.4395
R7838 VSS.t1533 VSS.n198 27.4395
R7839 VSS.t3851 VSS.n4429 27.4395
R7840 VSS.t1275 VSS.n4437 27.4395
R7841 VSS.t3821 VSS.n4390 27.4395
R7842 VSS.t3382 VSS.n4401 27.4395
R7843 VSS.t3791 VSS.n4302 27.4395
R7844 VSS.t2834 VSS.n4310 27.4395
R7845 VSS.t3769 VSS.n4553 27.4395
R7846 VSS.t3439 VSS.n4561 27.4395
R7847 VSS.t3751 VSS.n4267 27.2261
R7848 VSS.t3704 VSS.n3954 27.2261
R7849 VSS.t3875 VSS.n3887 27.2261
R7850 VSS.t3939 VSS.n3680 27.2261
R7851 VSS.t3907 VSS.n3820 27.2261
R7852 VSS.t3844 VSS.n3772 27.2261
R7853 VSS.t3796 VSS.n3724 27.2261
R7854 VSS.t3847 VSS.n2348 27.2261
R7855 VSS.t3911 VSS.n2579 27.2261
R7856 VSS.t3731 VSS.n523 27.2261
R7857 VSS.t3773 VSS.n5939 27.2261
R7858 VSS.t3719 VSS.n5869 27.2261
R7859 VSS.t3695 VSS.n622 27.2261
R7860 VSS.t3855 VSS.n5660 27.2261
R7861 VSS.t3887 VSS.n5754 27.2261
R7862 VSS.t3919 VSS.n451 27.2261
R7863 VSS.t3777 VSS.n5226 27.2261
R7864 VSS.t3828 VSS.n5178 27.2261
R7865 VSS.t3891 VSS.n5111 27.2261
R7866 VSS.t3923 VSS.n4953 27.2261
R7867 VSS.t3859 VSS.n5044 27.2261
R7868 VSS.t3801 VSS.n5300 27.2261
R7869 VSS.t3781 VSS.n5552 27.2261
R7870 VSS.t3832 VSS.n877 27.2261
R7871 VSS.t3895 VSS.n5504 27.2261
R7872 VSS.t3927 VSS.n1102 27.2261
R7873 VSS.t3863 VSS.n1034 27.2261
R7874 VSS.t3802 VSS.n967 27.2261
R7875 VSS.t3778 VSS.n1741 27.2261
R7876 VSS.t3836 VSS.n1433 27.2261
R7877 VSS.t3899 VSS.n1526 27.2261
R7878 VSS.t3931 VSS.n1674 27.2261
R7879 VSS.t3867 VSS.n1599 27.2261
R7880 VSS.t3811 VSS.n4099 27.2261
R7881 VSS.t3790 VSS.n1284 27.2261
R7882 VSS.t3840 VSS.n2918 27.2261
R7883 VSS.t3903 VSS.n2892 27.2261
R7884 VSS.t3935 VSS.n2982 27.2261
R7885 VSS.t3871 VSS.n3136 27.2261
R7886 VSS.t3816 VSS.n3207 27.2261
R7887 VSS.t3711 VSS.n3271 27.2261
R7888 VSS.t3729 VSS.n1460 27.2261
R7889 VSS.t3756 VSS.n904 27.2261
R7890 VSS.t3755 VSS.n4980 27.2261
R7891 VSS.t3943 VSS.n2507 27.2261
R7892 VSS.t3879 VSS.n3393 27.2261
R7893 VSS.t3818 VSS.n2433 27.2261
R7894 VSS.t3728 VSS.n3442 27.2261
R7895 VSS.t3705 VSS.n2191 27.2261
R7896 VSS.n4259 VSS.t3551 27.2026
R7897 VSS.t3549 VSS.n535 27.2026
R7898 VSS.t3437 VSS.n5949 27.2026
R7899 VSS.t2832 VSS.n5879 27.2026
R7900 VSS.t3380 VSS.n632 27.2026
R7901 VSS.t1273 VSS.n5670 27.2026
R7902 VSS.t1531 VSS.n5764 27.2026
R7903 VSS.t1791 VSS.n461 27.2026
R7904 VSS.n3263 VSS.t3541 27.2026
R7905 VSS.n3199 VSS.t2824 27.2026
R7906 VSS.n3128 VSS.t1265 27.2026
R7907 VSS.n2974 VSS.t1783 27.2026
R7908 VSS.n2884 VSS.t1523 27.2026
R7909 VSS.n2910 VSS.t3372 27.2026
R7910 VSS.n1276 VSS.t3429 27.2026
R7911 VSS.n1452 VSS.t3543 27.2026
R7912 VSS.t2826 VSS.n4087 27.2026
R7913 VSS.t1267 VSS.n1587 27.2026
R7914 VSS.t1785 VSS.n1662 27.2026
R7915 VSS.t1525 VSS.n1514 27.2026
R7916 VSS.t3374 VSS.n1421 27.2026
R7917 VSS.t3431 VSS.n1729 27.2026
R7918 VSS.n896 VSS.t3545 27.2026
R7919 VSS.t2828 VSS.n955 27.2026
R7920 VSS.t1269 VSS.n1022 27.2026
R7921 VSS.t1787 VSS.n1090 27.2026
R7922 VSS.t1527 VSS.n5492 27.2026
R7923 VSS.t3376 VSS.n865 27.2026
R7924 VSS.t3433 VSS.n5540 27.2026
R7925 VSS.n4972 VSS.t3547 27.2026
R7926 VSS.t2830 VSS.n5288 27.2026
R7927 VSS.t1271 VSS.n5032 27.2026
R7928 VSS.t1789 VSS.n4941 27.2026
R7929 VSS.t1529 VSS.n5099 27.2026
R7930 VSS.t3378 VSS.n5166 27.2026
R7931 VSS.t3435 VSS.n5214 27.2026
R7932 VSS.n3434 VSS.t3425 27.2026
R7933 VSS.t3368 VSS.n2336 27.2026
R7934 VSS.t1519 VSS.n2567 27.2026
R7935 VSS.t1779 VSS.n2495 27.2026
R7936 VSS.t1261 VSS.n3381 27.2026
R7937 VSS.t2820 VSS.n2421 27.2026
R7938 VSS.n2183 VSS.t3539 27.2026
R7939 VSS.t2822 VSS.n3942 27.2026
R7940 VSS.t1263 VSS.n3875 27.2026
R7941 VSS.t1781 VSS.n3668 27.2026
R7942 VSS.t1521 VSS.n3808 27.2026
R7943 VSS.t3370 VSS.n3760 27.2026
R7944 VSS.t3427 VSS.n3712 27.2026
R7945 VSS.t4073 VSS.n1964 27.1445
R7946 VSS.t3749 VSS.n4245 26.6145
R7947 VSS.n550 VSS.t3753 26.6145
R7948 VSS.n5964 VSS.t3770 26.6145
R7949 VSS.n5894 VSS.t3717 26.6145
R7950 VSS.n647 VSS.t3693 26.6145
R7951 VSS.n5685 VSS.t3852 26.6145
R7952 VSS.n5779 VSS.t3884 26.6145
R7953 VSS.n476 VSS.t3917 26.6145
R7954 VSS.t3765 VSS.n3249 26.6145
R7955 VSS.t3709 VSS.n3185 26.6145
R7956 VSS.t3869 VSS.n3114 26.6145
R7957 VSS.t3933 VSS.n2960 26.6145
R7958 VSS.t3901 VSS.n2870 26.6145
R7959 VSS.t3838 VSS.n2896 26.6145
R7960 VSS.t3788 VSS.n1262 26.6145
R7961 VSS.t3762 VSS.n1437 26.6145
R7962 VSS.t3809 VSS.n4091 26.6145
R7963 VSS.t3865 VSS.n1591 26.6145
R7964 VSS.t3929 VSS.n1666 26.6145
R7965 VSS.t3896 VSS.n1518 26.6145
R7966 VSS.t3834 VSS.n1425 26.6145
R7967 VSS.t3786 VSS.n1733 26.6145
R7968 VSS.t3758 VSS.n881 26.6145
R7969 VSS.t3807 VSS.n959 26.6145
R7970 VSS.t3861 VSS.n1026 26.6145
R7971 VSS.t3924 VSS.n1094 26.6145
R7972 VSS.t3893 VSS.n5496 26.6145
R7973 VSS.t3830 VSS.n869 26.6145
R7974 VSS.t3784 VSS.n5544 26.6145
R7975 VSS.t3722 VSS.n4957 26.6145
R7976 VSS.t3804 VSS.n5292 26.6145
R7977 VSS.t3857 VSS.n5036 26.6145
R7978 VSS.t3921 VSS.n4945 26.6145
R7979 VSS.t3889 VSS.n5103 26.6145
R7980 VSS.t3826 VSS.n5170 26.6145
R7981 VSS.t3775 VSS.n5218 26.6145
R7982 VSS.t3715 VSS.n3419 26.6145
R7983 VSS.t3845 VSS.n2340 26.6145
R7984 VSS.t3909 VSS.n2571 26.6145
R7985 VSS.t3941 VSS.n2499 26.6145
R7986 VSS.t3877 VSS.n3385 26.6145
R7987 VSS.t3819 VSS.n2425 26.6145
R7988 VSS.t3767 VSS.n2168 26.6145
R7989 VSS.t3812 VSS.n3946 26.6145
R7990 VSS.t3873 VSS.n3879 26.6145
R7991 VSS.t3937 VSS.n3672 26.6145
R7992 VSS.t3905 VSS.n3812 26.6145
R7993 VSS.t3842 VSS.n3764 26.6145
R7994 VSS.t3794 VSS.n3716 26.6145
R7995 VSS.n3467 VSS.t1087 26.3606
R7996 VSS.t2219 VSS.n2222 26.3606
R7997 VSS.t2807 VSS.n2241 26.3606
R7998 VSS.t2191 VSS.n3017 26.3606
R7999 VSS.t3061 VSS.n3042 26.3606
R8000 VSS.t2163 VSS.n1139 26.3606
R8001 VSS.t4163 VSS.n1164 26.3606
R8002 VSS.t2135 VSS.n4797 26.3606
R8003 VSS.n4875 VSS.t3474 26.3606
R8004 VSS.t2107 VSS.n4763 26.3606
R8005 VSS.t3513 VSS.n4782 26.3606
R8006 VSS.t2079 VSS.n400 26.3606
R8007 VSS.n5998 VSS.n5997 26.3606
R8008 VSS.t2803 VSS.n426 26.3606
R8009 VSS.t2247 VSS.n2256 26.2973
R8010 VSS.n3551 VSS.t1086 26.2388
R8011 VSS.t2597 VSS.t4075 25.9643
R8012 VSS.t1746 VSS.n151 25.7148
R8013 VSS.n269 VSS.t3913 25.1353
R8014 VSS.n193 VSS.t3881 25.1353
R8015 VSS.t3849 VSS.n4493 25.1353
R8016 VSS.n4396 VSS.t3822 25.1353
R8017 VSS.t3797 VSS.n4537 25.1353
R8018 VSS.t3701 VSS.n4609 25.1353
R8019 VSS.t109 VSS.t165 25.0701
R8020 VSS.n6231 VSS.n95 24.8263
R8021 VSS.n6231 VSS.n89 24.8263
R8022 VSS.n6231 VSS.n83 24.8263
R8023 VSS.n6231 VSS.n77 24.8263
R8024 VSS.n6231 VSS.n71 24.8263
R8025 VSS.n6231 VSS.n65 24.8263
R8026 VSS.t2597 VSS.n1965 24.7841
R8027 VSS.t3007 VSS.t3006 24.6159
R8028 VSS.t5 VSS.t2939 24.6159
R8029 VSS.t2974 VSS.t2976 24.6159
R8030 VSS.t2400 VSS.t3458 24.6159
R8031 VSS.n96 VSS.t1013 24.492
R8032 VSS.n90 VSS.t922 24.492
R8033 VSS.n84 VSS.t783 24.492
R8034 VSS.n78 VSS.t664 24.492
R8035 VSS.n72 VSS.t468 24.492
R8036 VSS.n66 VSS.t525 24.492
R8037 VSS.n3556 VSS.t492 24.4788
R8038 VSS.n3555 VSS.t573 24.4788
R8039 VSS.n3554 VSS.t659 24.4788
R8040 VSS.n3553 VSS.t759 24.4788
R8041 VSS.n3552 VSS.t867 24.4788
R8042 VSS.n3551 VSS.t989 24.4788
R8043 VSS.n3499 VSS.t2221 24.194
R8044 VSS.n3064 VSS.t2193 24.194
R8045 VSS.n5426 VSS.t2165 24.194
R8046 VSS.n4874 VSS.t2137 24.194
R8047 VSS.n5361 VSS.t2109 24.194
R8048 VSS.n6009 VSS.t2081 24.194
R8049 VSS.n3523 VSS.t152 24.1769
R8050 VSS.t227 VSS.n1185 24.1769
R8051 VSS.t212 VSS.n1165 24.1769
R8052 VSS.n5390 VSS.t215 24.1769
R8053 VSS.n5378 VSS.t193 24.1769
R8054 VSS.n3466 VSS.t2249 24.1359
R8055 VSS.n3473 VSS.t3605 24.1106
R8056 VSS.n3011 VSS.t4104 24.1106
R8057 VSS.n1133 VSS.t3498 24.1106
R8058 VSS.n4848 VSS.t3131 24.1106
R8059 VSS.n4881 VSS.t2638 24.1106
R8060 VSS.n393 VSS.t3067 24.1106
R8061 VSS.n1976 VSS.n1921 23.5226
R8062 VSS.n2283 VSS.t1763 23.4719
R8063 VSS.t1760 VSS.n2220 23.4719
R8064 VSS.n3043 VSS.t1768 23.4719
R8065 VSS.n5405 VSS.t1770 23.4719
R8066 VSS.n4822 VSS.t1772 23.4719
R8067 VSS.t1754 VSS.n4761 23.4719
R8068 VSS.t3989 VSS.t2233 22.7497
R8069 VSS.t2205 VSS.t3983 22.7497
R8070 VSS.t3977 VSS.t2177 22.7497
R8071 VSS.t3971 VSS.t2149 22.7497
R8072 VSS.t3965 VSS.t2121 22.7497
R8073 VSS.t2093 VSS.t3959 22.7497
R8074 VSS.t3953 VSS.t2065 22.7497
R8075 VSS.t2241 VSS.t3991 22.3886
R8076 VSS.t2213 VSS.t3985 22.3886
R8077 VSS.t2185 VSS.t3979 22.3886
R8078 VSS.t2157 VSS.t3973 22.3886
R8079 VSS.t2129 VSS.t3967 22.3886
R8080 VSS.t2101 VSS.t3961 22.3886
R8081 VSS.t2073 VSS.t3955 22.3886
R8082 VSS.t2236 VSS.n2269 22.2818
R8083 VSS.t2208 VSS.n2221 22.2818
R8084 VSS.t2180 VSS.n3030 22.2818
R8085 VSS.t2152 VSS.n1152 22.2818
R8086 VSS.t2124 VSS.n4810 22.2818
R8087 VSS.t2096 VSS.n4762 22.2818
R8088 VSS.t2068 VSS.n413 22.2818
R8089 VSS.n97 VSS.t871 22.213
R8090 VSS.n290 VSS.t1765 22.213
R8091 VSS.t1516 VSS.n277 22.213
R8092 VSS.n91 VSS.t801 22.213
R8093 VSS.n215 VSS.t1501 22.213
R8094 VSS.t1258 VSS.n201 22.213
R8095 VSS.n85 VSS.t646 22.213
R8096 VSS.n4453 VSS.t1244 22.213
R8097 VSS.t3366 VSS.n4440 22.213
R8098 VSS.n79 VSS.t441 22.213
R8099 VSS.n4501 VSS.t4181 22.213
R8100 VSS.t2818 VSS.n4404 22.213
R8101 VSS.n73 VSS.t426 22.213
R8102 VSS.n4326 VSS.t2603 22.213
R8103 VSS.t3423 VSS.n4313 22.213
R8104 VSS.n67 VSS.t370 22.213
R8105 VSS.n4577 VSS.t2510 22.213
R8106 VSS.t3537 VSS.n4564 22.213
R8107 VSS.n4254 VSS.t237 22.0212
R8108 VSS.t252 VSS.n538 22.0212
R8109 VSS.t3536 VSS.n5952 22.0212
R8110 VSS.t3421 VSS.n5882 22.0212
R8111 VSS.t2817 VSS.n635 22.0212
R8112 VSS.t3365 VSS.n5673 22.0212
R8113 VSS.t1256 VSS.n5767 22.0212
R8114 VSS.t1514 VSS.n464 22.0212
R8115 VSS.n3258 VSS.t314 22.0212
R8116 VSS.n3194 VSS.t3417 22.0212
R8117 VSS.n3123 VSS.t3361 22.0212
R8118 VSS.n2969 VSS.t1503 22.0212
R8119 VSS.n2879 VSS.t1250 22.0212
R8120 VSS.n2905 VSS.t2813 22.0212
R8121 VSS.n1271 VSS.t3346 22.0212
R8122 VSS.n1447 VSS.t272 22.0212
R8123 VSS.n4082 VSS.t3418 22.0212
R8124 VSS.n1582 VSS.t3362 22.0212
R8125 VSS.n1657 VSS.t1508 22.0212
R8126 VSS.n1509 VSS.t1252 22.0212
R8127 VSS.n1416 VSS.t2814 22.0212
R8128 VSS.n1724 VSS.t3534 22.0212
R8129 VSS.n891 VSS.t265 22.0212
R8130 VSS.n950 VSS.t3419 22.0212
R8131 VSS.n1017 VSS.t3363 22.0212
R8132 VSS.n1085 VSS.t1510 22.0212
R8133 VSS.n5487 VSS.t1254 22.0212
R8134 VSS.n860 VSS.t2815 22.0212
R8135 VSS.n5535 VSS.t3535 22.0212
R8136 VSS.n4967 VSS.t260 22.0212
R8137 VSS.n5283 VSS.t3420 22.0212
R8138 VSS.n5027 VSS.t3364 22.0212
R8139 VSS.n4936 VSS.t1512 22.0212
R8140 VSS.n5094 VSS.t1237 22.0212
R8141 VSS.n5161 VSS.t2816 22.0212
R8142 VSS.n5209 VSS.t4154 22.0212
R8143 VSS.n3429 VSS.t3239 22.0212
R8144 VSS.n2331 VSS.t2605 22.0212
R8145 VSS.n2562 VSS.t1246 22.0212
R8146 VSS.n2490 VSS.t1506 22.0212
R8147 VSS.n3376 VSS.t2331 22.0212
R8148 VSS.n2416 VSS.t2512 22.0212
R8149 VSS.n2178 VSS.t327 22.0212
R8150 VSS.n3937 VSS.t2514 22.0212
R8151 VSS.n3870 VSS.t4182 22.0212
R8152 VSS.n3663 VSS.t1492 22.0212
R8153 VSS.n3803 VSS.t1235 22.0212
R8154 VSS.n3755 VSS.t2606 22.0212
R8155 VSS.n3707 VSS.t3532 22.0212
R8156 VSS.n4242 VSS.n4240 21.7788
R8157 VSS.t2009 VSS.t1497 21.4291
R8158 VSS.t2313 VSS.t2585 21.4291
R8159 VSS.t106 VSS.t3574 21.4291
R8160 VSS.t3004 VSS.t3467 21.4291
R8161 VSS.t2599 VSS.t4062 21.3561
R8162 VSS.n2292 VSS.t3988 21.3053
R8163 VSS.t3982 VSS.n3507 21.3053
R8164 VSS.n3052 VSS.t3976 21.3053
R8165 VSS.n5414 VSS.t3970 21.3053
R8166 VSS.n4831 VSS.t3964 21.3053
R8167 VSS.t3958 VSS.n5369 21.3053
R8168 VSS.n435 VSS.t3952 21.3053
R8169 VSS.n3490 VSS.t3610 21.2658
R8170 VSS.n3072 VSS.t4110 21.2658
R8171 VSS.n5434 VSS.t3500 21.2658
R8172 VSS.n4865 VSS.t3136 21.2658
R8173 VSS.n5352 VSS.t2640 21.2658
R8174 VSS.n6015 VSS.t3072 21.2658
R8175 VSS.n3465 VSS.n1852 21.151
R8176 VSS.t3611 VSS.n3490 20.9047
R8177 VSS.t4106 VSS.n3072 20.9047
R8178 VSS.t3502 VSS.n5434 20.9047
R8179 VSS.t3137 VSS.n4865 20.9047
R8180 VSS.t2642 VSS.n5352 20.9047
R8181 VSS.t3073 VSS.n6015 20.9047
R8182 VSS.t2236 VSS.n2270 20.8607
R8183 VSS.t2208 VSS.n3510 20.8607
R8184 VSS.n3031 VSS.t2180 20.8607
R8185 VSS.t2152 VSS.n1153 20.8607
R8186 VSS.n4811 VSS.t2124 20.8607
R8187 VSS.t2096 VSS.n5372 20.8607
R8188 VSS.t2068 VSS.n414 20.8607
R8189 VSS.t230 VSS.n3512 20.5463
R8190 VSS.n1190 VSS.t224 20.5463
R8191 VSS.n5391 VSS.t221 20.5463
R8192 VSS.t218 VSS.n5379 20.5463
R8193 VSS.t209 VSS.n6 20.5463
R8194 VSS.n2069 VSS.t2575 20.3176
R8195 VSS.n291 VSS.t1797 20.1985
R8196 VSS.n216 VSS.t1537 20.1985
R8197 VSS.n4454 VSS.t1279 20.1985
R8198 VSS.n4502 VSS.t3386 20.1985
R8199 VSS.n4327 VSS.t2857 20.1985
R8200 VSS.n4578 VSS.t2980 20.1985
R8201 VSS.t2657 VSS.n3949 20.1441
R8202 VSS.t1448 VSS.n3882 20.1441
R8203 VSS.t1962 VSS.n3675 20.1441
R8204 VSS.t1703 VSS.n3815 20.1441
R8205 VSS.t1147 VSS.n3767 20.1441
R8206 VSS.t3262 VSS.n3719 20.1441
R8207 VSS.t1183 VSS.n2343 20.1441
R8208 VSS.t1729 VSS.n2574 20.1441
R8209 VSS.t3352 VSS.n5221 20.1441
R8210 VSS.t3401 VSS.n5173 20.1441
R8211 VSS.t1594 VSS.n5106 20.1441
R8212 VSS.t1854 VSS.n4948 20.1441
R8213 VSS.t1342 VSS.n5039 20.1441
R8214 VSS.t2769 VSS.n5295 20.1441
R8215 VSS.t4172 VSS.n5547 20.1441
R8216 VSS.t45 VSS.n872 20.1441
R8217 VSS.t1621 VSS.n5499 20.1441
R8218 VSS.t1880 VSS.n1097 20.1441
R8219 VSS.t1366 VSS.n1029 20.1441
R8220 VSS.t3456 VSS.n962 20.1441
R8221 VSS.t2294 VSS.n1736 20.1441
R8222 VSS.t73 VSS.n1428 20.1441
R8223 VSS.t1647 VSS.n1521 20.1441
R8224 VSS.t1908 VSS.n1669 20.1441
R8225 VSS.t1394 VSS.n1594 20.1441
R8226 VSS.t2944 VSS.n4094 20.1441
R8227 VSS.t1993 VSS.n2502 20.1441
R8228 VSS.t1478 VSS.n3388 20.1441
R8229 VSS.t2255 VSS.n2428 20.1441
R8230 VSS.n4288 VSS.t4207 20.1431
R8231 VSS.n551 VSS.t2422 20.1431
R8232 VSS.n5965 VSS.t3248 20.1431
R8233 VSS.n5895 VSS.t4014 20.1431
R8234 VSS.n648 VSS.t2446 20.1431
R8235 VSS.n5686 VSS.t1317 20.1431
R8236 VSS.n5780 VSS.t1566 20.1431
R8237 VSS.n477 VSS.t1827 20.1431
R8238 VSS.n4185 VSS.t3278 20.1431
R8239 VSS.n2958 VSS.t1103 20.1431
R8240 VSS.n3311 VSS.t1675 20.1431
R8241 VSS.n3112 VSS.t1935 20.1431
R8242 VSS.n3183 VSS.t1420 20.1431
R8243 VSS.n3247 VSS.t4203 20.1431
R8244 VSS.n3292 VSS.t2554 20.1431
R8245 VSS.n1481 VSS.t2957 20.1431
R8246 VSS.n925 VSS.t3117 20.1431
R8247 VSS.n5001 VSS.t2611 20.1431
R8248 VSS.n3463 VSS.t3236 20.1431
R8249 VSS.n2212 VSS.t2626 20.1431
R8250 VSS.n2268 VSS.t3691 20.1385
R8251 VSS.n2234 VSS.t3690 20.1385
R8252 VSS.n3029 VSS.t3689 20.1385
R8253 VSS.n1151 VSS.t3688 20.1385
R8254 VSS.n4809 VSS.t3687 20.1385
R8255 VSS.n4775 VSS.t3686 20.1385
R8256 VSS.n412 VSS.t3685 20.1385
R8257 VSS.n6238 VSS.t196 19.9137
R8258 VSS.t1804 VSS.n297 19.9088
R8259 VSS.t1544 VSS.n222 19.9088
R8260 VSS.t1284 VSS.n4460 19.9088
R8261 VSS.t2431 VSS.n4508 19.9088
R8262 VSS.t4018 VSS.n4333 19.9088
R8263 VSS.t2385 VSS.n4584 19.9088
R8264 VSS.n286 VSS.t1792 19.5998
R8265 VSS.n210 VSS.t1532 19.5998
R8266 VSS.n4450 VSS.t1274 19.5998
R8267 VSS.n4414 VSS.t3381 19.5998
R8268 VSS.n4323 VSS.t2833 19.5998
R8269 VSS.n4574 VSS.t3438 19.5998
R8270 VSS.t3550 VSS.n4248 19.4306
R8271 VSS.n547 VSS.t3548 19.4306
R8272 VSS.n5961 VSS.t3436 19.4306
R8273 VSS.n5891 VSS.t2831 19.4306
R8274 VSS.n644 VSS.t3379 19.4306
R8275 VSS.n5682 VSS.t1272 19.4306
R8276 VSS.n5776 VSS.t1530 19.4306
R8277 VSS.n473 VSS.t1790 19.4306
R8278 VSS.t3540 VSS.n3252 19.4306
R8279 VSS.t2823 VSS.n3188 19.4306
R8280 VSS.t1264 VSS.n3117 19.4306
R8281 VSS.t1782 VSS.n2963 19.4306
R8282 VSS.t1522 VSS.n2873 19.4306
R8283 VSS.t3371 VSS.n2899 19.4306
R8284 VSS.t3428 VSS.n1265 19.4306
R8285 VSS.t3542 VSS.n1440 19.4306
R8286 VSS.t2825 VSS.n4086 19.4306
R8287 VSS.t1266 VSS.n1586 19.4306
R8288 VSS.t1784 VSS.n1661 19.4306
R8289 VSS.t1524 VSS.n1513 19.4306
R8290 VSS.t3373 VSS.n1420 19.4306
R8291 VSS.t3430 VSS.n1728 19.4306
R8292 VSS.t3544 VSS.n884 19.4306
R8293 VSS.t2827 VSS.n954 19.4306
R8294 VSS.t1268 VSS.n1021 19.4306
R8295 VSS.t1786 VSS.n1089 19.4306
R8296 VSS.t1526 VSS.n5491 19.4306
R8297 VSS.t3375 VSS.n864 19.4306
R8298 VSS.t3432 VSS.n5539 19.4306
R8299 VSS.t3546 VSS.n4960 19.4306
R8300 VSS.t2829 VSS.n5287 19.4306
R8301 VSS.t1270 VSS.n5031 19.4306
R8302 VSS.t1788 VSS.n4940 19.4306
R8303 VSS.t1528 VSS.n5098 19.4306
R8304 VSS.t3377 VSS.n5165 19.4306
R8305 VSS.t3434 VSS.n5213 19.4306
R8306 VSS.t3424 VSS.n3422 19.4306
R8307 VSS.t3367 VSS.n2335 19.4306
R8308 VSS.t1518 VSS.n2566 19.4306
R8309 VSS.t1778 VSS.n2494 19.4306
R8310 VSS.t1260 VSS.n3380 19.4306
R8311 VSS.t2819 VSS.n2420 19.4306
R8312 VSS.t3538 VSS.n2171 19.4306
R8313 VSS.t2821 VSS.n3941 19.4306
R8314 VSS.t1262 VSS.n3874 19.4306
R8315 VSS.t1780 VSS.n3667 19.4306
R8316 VSS.t1520 VSS.n3807 19.4306
R8317 VSS.t3369 VSS.n3759 19.4306
R8318 VSS.t3426 VSS.n3711 19.4306
R8319 VSS.n295 VSS.t1795 18.8928
R8320 VSS.n220 VSS.t1535 18.8928
R8321 VSS.n4458 VSS.t1277 18.8928
R8322 VSS.n4506 VSS.t3384 18.8928
R8323 VSS.n4331 VSS.t2855 18.8928
R8324 VSS.n4582 VSS.t2978 18.8928
R8325 VSS.t4076 VSS.t4065 18.8833
R8326 VSS.n2089 VSS.t3443 18.8801
R8327 VSS.n1977 VSS.t2593 18.8801
R8328 VSS.t4205 VSS.n4284 18.8483
R8329 VSS.n3953 VSS.t2655 18.8483
R8330 VSS.n3886 VSS.t1446 18.8483
R8331 VSS.n3679 VSS.t1960 18.8483
R8332 VSS.n3819 VSS.t1701 18.8483
R8333 VSS.n3771 VSS.t1145 18.8483
R8334 VSS.n3723 VSS.t3260 18.8483
R8335 VSS.n2347 VSS.t1181 18.8483
R8336 VSS.n2578 VSS.t1727 18.8483
R8337 VSS.n5969 VSS.t3246 18.8483
R8338 VSS.n5899 VSS.t4012 18.8483
R8339 VSS.n652 VSS.t2444 18.8483
R8340 VSS.n5690 VSS.t1315 18.8483
R8341 VSS.n5784 VSS.t1564 18.8483
R8342 VSS.n481 VSS.t1825 18.8483
R8343 VSS.n555 VSS.t2420 18.8483
R8344 VSS.n5225 VSS.t3350 18.8483
R8345 VSS.n5177 VSS.t3399 18.8483
R8346 VSS.n5110 VSS.t1592 18.8483
R8347 VSS.n4952 VSS.t1852 18.8483
R8348 VSS.n5043 VSS.t1340 18.8483
R8349 VSS.n5299 VSS.t2767 18.8483
R8350 VSS.n5551 VSS.t4170 18.8483
R8351 VSS.n876 VSS.t43 18.8483
R8352 VSS.n5503 VSS.t1619 18.8483
R8353 VSS.n1101 VSS.t1878 18.8483
R8354 VSS.n1033 VSS.t1364 18.8483
R8355 VSS.n966 VSS.t3454 18.8483
R8356 VSS.n1740 VSS.t2292 18.8483
R8357 VSS.n1432 VSS.t71 18.8483
R8358 VSS.n1525 VSS.t1645 18.8483
R8359 VSS.n1673 VSS.t1906 18.8483
R8360 VSS.n1598 VSS.t1392 18.8483
R8361 VSS.n4098 VSS.t2942 18.8483
R8362 VSS.t3276 VSS.n4181 18.8483
R8363 VSS.t1101 VSS.n2954 18.8483
R8364 VSS.t1673 VSS.n3307 18.8483
R8365 VSS.t1933 VSS.n3108 18.8483
R8366 VSS.t1418 VSS.n3179 18.8483
R8367 VSS.t4201 VSS.n3243 18.8483
R8368 VSS.t2552 VSS.n3288 18.8483
R8369 VSS.t2955 VSS.n1477 18.8483
R8370 VSS.t3115 VSS.n921 18.8483
R8371 VSS.t2609 VSS.n4997 18.8483
R8372 VSS.n2506 VSS.t1991 18.8483
R8373 VSS.n3392 VSS.t1476 18.8483
R8374 VSS.n2432 VSS.t2253 18.8483
R8375 VSS.t3234 VSS.n3459 18.8483
R8376 VSS.t2624 VSS.n2208 18.8483
R8377 VSS.n281 VSS.t1751 18.6022
R8378 VSS.n205 VSS.t1489 18.6022
R8379 VSS.n4445 VSS.t1240 18.6022
R8380 VSS.n4409 VSS.t2686 18.6022
R8381 VSS.n4318 VSS.t2847 18.6022
R8382 VSS.n4569 VSS.t3334 18.6022
R8383 VSS.n3522 VSS.t2573 18.5658
R8384 VSS.t2572 VSS.n3520 18.5658
R8385 VSS.n4195 VSS.t3462 18.5658
R8386 VSS.t3461 VSS.n1186 18.5658
R8387 VSS.n5400 VSS.t2569 18.5658
R8388 VSS.t2568 VSS.n1166 18.5658
R8389 VSS.n5389 VSS.t2879 18.5658
R8390 VSS.t2878 VSS.n5387 18.5658
R8391 VSS.n5377 VSS.t4130 18.5658
R8392 VSS.t4129 VSS.n5375 18.5658
R8393 VSS.n6237 VSS.t4126 18.5658
R8394 VSS.n4233 VSS.t4125 18.5658
R8395 VSS.t2563 VSS.n4251 18.5323
R8396 VSS.n542 VSS.t3268 18.5323
R8397 VSS.n5956 VSS.t2967 18.5323
R8398 VSS.n5886 VSS.t4000 18.5323
R8399 VSS.n639 VSS.t2438 18.5323
R8400 VSS.n5677 VSS.t1293 18.5323
R8401 VSS.n5771 VSS.t1551 18.5323
R8402 VSS.n468 VSS.t1811 18.5323
R8403 VSS.t4077 VSS.n3255 18.5323
R8404 VSS.t3319 VSS.n3191 18.5323
R8405 VSS.t1405 VSS.n3120 18.5323
R8406 VSS.t1919 VSS.n2966 18.5323
R8407 VSS.t1660 VSS.n2876 18.5323
R8408 VSS.t86 VSS.n2902 18.5323
R8409 VSS.t3197 VSS.n1268 18.5323
R8410 VSS.t2546 VSS.n1443 18.5323
R8411 VSS.n4083 VSS.t2706 18.5323
R8412 VSS.n1583 VSS.t1377 18.5323
R8413 VSS.n1658 VSS.t1893 18.5323
R8414 VSS.n1510 VSS.t1632 18.5323
R8415 VSS.n1417 VSS.t58 18.5323
R8416 VSS.n1725 VSS.t3412 18.5323
R8417 VSS.t2844 VSS.n887 18.5323
R8418 VSS.n951 VSS.t3174 18.5323
R8419 VSS.n1018 VSS.t1349 18.5323
R8420 VSS.n1086 VSS.t1865 18.5323
R8421 VSS.n5488 VSS.t1605 18.5323
R8422 VSS.n861 VSS.t30 18.5323
R8423 VSS.n5536 VSS.t2872 18.5323
R8424 VSS.t4295 VSS.n4963 18.5323
R8425 VSS.n5284 VSS.t2754 18.5323
R8426 VSS.n5028 VSS.t1297 18.5323
R8427 VSS.n4937 VSS.t1838 18.5323
R8428 VSS.n5095 VSS.t1579 18.5323
R8429 VSS.n5162 VSS.t17 18.5323
R8430 VSS.n5210 VSS.t2327 18.5323
R8431 VSS.t4292 VSS.n3425 18.5323
R8432 VSS.n2332 VSS.t1160 18.5323
R8433 VSS.n2563 VSS.t1714 18.5323
R8434 VSS.n2491 VSS.t1973 18.5323
R8435 VSS.n3377 VSS.t1461 18.5323
R8436 VSS.n2417 VSS.t2649 18.5323
R8437 VSS.t3190 VSS.n2174 18.5323
R8438 VSS.n3938 VSS.t4185 18.5323
R8439 VSS.n3871 VSS.t1433 18.5323
R8440 VSS.n3664 VSS.t1946 18.5323
R8441 VSS.n3804 VSS.t1686 18.5323
R8442 VSS.n3756 VSS.t1124 18.5323
R8443 VSS.n3708 VSS.t4120 18.5323
R8444 VSS.t3604 VSS.n3473 18.333
R8445 VSS.t4103 VSS.n3011 18.333
R8446 VSS.t3497 VSS.n1133 18.333
R8447 VSS.t3130 VSS.n4848 18.333
R8448 VSS.t2637 VSS.n4881 18.333
R8449 VSS.t3066 VSS.n393 18.333
R8450 VSS.t1794 VSS.n264 18.2932
R8451 VSS.t1534 VSS.n188 18.2932
R8452 VSS.t1276 VSS.n4430 18.2932
R8453 VSS.t3383 VSS.n4391 18.2932
R8454 VSS.t2854 VSS.n4303 18.2932
R8455 VSS.t2473 VSS.n4554 18.2932
R8456 VSS.t4204 VSS.n4285 18.1509
R8457 VSS.n3952 VSS.t2652 18.1509
R8458 VSS.n3885 VSS.t1445 18.1509
R8459 VSS.n3678 VSS.t1957 18.1509
R8460 VSS.n3818 VSS.t1698 18.1509
R8461 VSS.n3770 VSS.t1144 18.1509
R8462 VSS.n3722 VSS.t3259 18.1509
R8463 VSS.n2346 VSS.t1176 18.1509
R8464 VSS.n2577 VSS.t1724 18.1509
R8465 VSS.t2419 VSS.n526 18.1509
R8466 VSS.t3243 VSS.n5940 18.1509
R8467 VSS.t4010 VSS.n5870 18.1509
R8468 VSS.t2443 VSS.n623 18.1509
R8469 VSS.t1314 VSS.n5661 18.1509
R8470 VSS.t1563 VSS.n5755 18.1509
R8471 VSS.t1822 VSS.n452 18.1509
R8472 VSS.n5224 VSS.t3349 18.1509
R8473 VSS.n5176 VSS.t3396 18.1509
R8474 VSS.n5109 VSS.t1589 18.1509
R8475 VSS.n4951 VSS.t1849 18.1509
R8476 VSS.n5042 VSS.t1301 18.1509
R8477 VSS.n5298 VSS.t2766 18.1509
R8478 VSS.n5550 VSS.t4169 18.1509
R8479 VSS.n875 VSS.t42 18.1509
R8480 VSS.n5502 VSS.t1616 18.1509
R8481 VSS.n1100 VSS.t1877 18.1509
R8482 VSS.n1032 VSS.t1361 18.1509
R8483 VSS.n965 VSS.t3453 18.1509
R8484 VSS.n1739 VSS.t2291 18.1509
R8485 VSS.n1431 VSS.t70 18.1509
R8486 VSS.n1524 VSS.t1644 18.1509
R8487 VSS.n1672 VSS.t1903 18.1509
R8488 VSS.n1597 VSS.t1389 18.1509
R8489 VSS.n4097 VSS.t2941 18.1509
R8490 VSS.t3275 VSS.n4182 18.1509
R8491 VSS.t97 VSS.n2955 18.1509
R8492 VSS.t1670 VSS.n3308 18.1509
R8493 VSS.t1930 VSS.n3109 18.1509
R8494 VSS.t1417 VSS.n3180 18.1509
R8495 VSS.t4199 VSS.n3244 18.1509
R8496 VSS.t2551 VSS.n3289 18.1509
R8497 VSS.t2954 VSS.n1478 18.1509
R8498 VSS.t3114 VSS.n922 18.1509
R8499 VSS.t2608 VSS.n4998 18.1509
R8500 VSS.n2505 VSS.t1988 18.1509
R8501 VSS.n3391 VSS.t1473 18.1509
R8502 VSS.n2431 VSS.t2252 18.1509
R8503 VSS.t3231 VSS.n3460 18.1509
R8504 VSS.t2623 VSS.n2209 18.1509
R8505 VSS.n1933 VSS.t202 17.9424
R8506 VSS.n3587 VSS.t204 17.9424
R8507 VSS.n1939 VSS.t4074 17.7189
R8508 VSS.n1947 VSS.t4068 17.7189
R8509 VSS.t2598 VSS.n1955 17.7031
R8510 VSS.n2109 VSS.t110 17.6674
R8511 VSS.t144 VSS.n1967 17.6421
R8512 VSS.n2110 VSS.t4060 17.5986
R8513 VSS.n1944 VSS.t4070 17.5642
R8514 VSS.n1940 VSS.t4069 17.5642
R8515 VSS.n2293 VSS.t2231 17.5468
R8516 VSS.n3509 VSS.t2203 17.5468
R8517 VSS.n3053 VSS.t2175 17.5468
R8518 VSS.n5415 VSS.t2147 17.5468
R8519 VSS.n4832 VSS.t2118 17.5468
R8520 VSS.n5371 VSS.t2090 17.5468
R8521 VSS.t1798 VSS.n267 17.545
R8522 VSS.t1538 VSS.n191 17.545
R8523 VSS.t1280 VSS.n4419 17.545
R8524 VSS.t3387 VSS.n4394 17.545
R8525 VSS.t2858 VSS.n4292 17.545
R8526 VSS.t2981 VSS.n4543 17.545
R8527 VSS.n4234 VSS.t4134 17.3681
R8528 VSS.n1922 VSS.t181 17.3394
R8529 VSS.n169 VSS.t1745 17.3368
R8530 VSS.n161 VSS.t1741 17.3368
R8531 VSS.n161 VSS.t1749 17.3368
R8532 VSS.n164 VSS.t2010 17.3368
R8533 VSS.n6207 VSS.t2015 17.3368
R8534 VSS.n4216 VSS.t3468 17.3368
R8535 VSS.n4618 VSS.t2601 17.3368
R8536 VSS.n4714 VSS.t99 17.3368
R8537 VSS.n4714 VSS.t3344 17.3368
R8538 VSS.n4619 VSS.t101 17.2958
R8539 VSS.n2061 VSS.t142 17.2954
R8540 VSS.n4566 VSS.t2528 17.2762
R8541 VSS.n4315 VSS.t2535 17.2762
R8542 VSS.n4406 VSS.t3218 17.2762
R8543 VSS.n4442 VSS.t3210 17.2762
R8544 VSS.n203 VSS.t3222 17.2762
R8545 VSS.n279 VSS.t3220 17.2762
R8546 VSS.n113 VSS.t2522 17.2762
R8547 VSS.n4253 VSS.t2537 17.2762
R8548 VSS.n3920 VSS.t2519 17.2762
R8549 VSS.n3853 VSS.t2810 17.2762
R8550 VSS.n3646 VSS.t2932 17.2762
R8551 VSS.n3786 VSS.t2934 17.2762
R8552 VSS.n3738 VSS.t2930 17.2762
R8553 VSS.n3690 VSS.t2517 17.2762
R8554 VSS.n2314 VSS.t661 17.2762
R8555 VSS.n2545 VSS.t869 17.2762
R8556 VSS.n2280 VSS.t1088 17.2762
R8557 VSS.n4781 VSS.t3514 17.2762
R8558 VSS.n4821 VSS.t3475 17.2762
R8559 VSS.n1163 VSS.t4164 17.2762
R8560 VSS.n3041 VSS.t3062 17.2762
R8561 VSS.n2240 VSS.t2808 17.2762
R8562 VSS.n5954 VSS.t3001 17.2762
R8563 VSS.n5884 VSS.t2999 17.2762
R8564 VSS.n637 VSS.t2997 17.2762
R8565 VSS.n5675 VSS.t3060 17.2762
R8566 VSS.n5769 VSS.t2806 17.2762
R8567 VSS.n466 VSS.t2993 17.2762
R8568 VSS.n425 VSS.t2804 17.2762
R8569 VSS.n540 VSS.t3003 17.2762
R8570 VSS.n5192 VSS.t3096 17.2762
R8571 VSS.n5144 VSS.t2541 17.2762
R8572 VSS.n5077 VSS.t2545 17.2762
R8573 VSS.n4919 VSS.t2543 17.2762
R8574 VSS.n5010 VSS.t3518 17.2762
R8575 VSS.n5266 VSS.t3094 17.2762
R8576 VSS.n5518 VSS.t2309 17.2762
R8577 VSS.n843 VSS.t2305 17.2762
R8578 VSS.n5470 VSS.t2303 17.2762
R8579 VSS.n1068 VSS.t3477 17.2762
R8580 VSS.n1000 VSS.t2301 17.2762
R8581 VSS.n933 VSS.t2307 17.2762
R8582 VSS.n1707 VSS.t3520 17.2762
R8583 VSS.n1399 VSS.t2539 17.2762
R8584 VSS.n1492 VSS.t2526 17.2762
R8585 VSS.n1640 VSS.t2524 17.2762
R8586 VSS.n1565 VSS.t2530 17.2762
R8587 VSS.n4065 VSS.t3516 17.2762
R8588 VSS.n1270 VSS.t2989 17.2762
R8589 VSS.n2904 VSS.t2677 17.2762
R8590 VSS.n2878 VSS.t2681 17.2762
R8591 VSS.n2968 VSS.t2679 17.2762
R8592 VSS.n3122 VSS.t3037 17.2762
R8593 VSS.n3193 VSS.t2995 17.2762
R8594 VSS.n3257 VSS.t2991 17.2762
R8595 VSS.n1446 VSS.t3092 17.2762
R8596 VSS.n890 VSS.t2311 17.2762
R8597 VSS.n4966 VSS.t3090 17.2762
R8598 VSS.n2473 VSS.t991 17.2762
R8599 VSS.n3359 VSS.t761 17.2762
R8600 VSS.n2399 VSS.t575 17.2762
R8601 VSS.n3428 VSS.t494 17.2762
R8602 VSS.n2177 VSS.t2973 17.2762
R8603 VSS.t3635 VSS.n4266 17.2706
R8604 VSS.t2423 VSS.n529 17.2706
R8605 VSS.t3249 VSS.n5943 17.2706
R8606 VSS.t3649 VSS.n5873 17.2706
R8607 VSS.t2447 VSS.n626 17.2706
R8608 VSS.t1318 VSS.n5664 17.2706
R8609 VSS.t1567 VSS.n5758 17.2706
R8610 VSS.t1828 VSS.n455 17.2706
R8611 VSS.t2555 VSS.n3270 17.2706
R8612 VSS.t3653 VSS.n3206 17.2706
R8613 VSS.t1421 VSS.n3135 17.2706
R8614 VSS.t1936 VSS.n2981 17.2706
R8615 VSS.t1676 VSS.n2891 17.2706
R8616 VSS.t1104 VSS.n2917 17.2706
R8617 VSS.t3279 VSS.n1283 17.2706
R8618 VSS.t2958 VSS.n1459 17.2706
R8619 VSS.n4093 VSS.t2945 17.2706
R8620 VSS.n1593 VSS.t1395 17.2706
R8621 VSS.n1668 VSS.t1909 17.2706
R8622 VSS.n1520 VSS.t1648 17.2706
R8623 VSS.n1427 VSS.t74 17.2706
R8624 VSS.n1735 VSS.t2295 17.2706
R8625 VSS.t3118 VSS.n903 17.2706
R8626 VSS.n961 VSS.t3457 17.2706
R8627 VSS.n1028 VSS.t1367 17.2706
R8628 VSS.n1096 VSS.t1881 17.2706
R8629 VSS.n5498 VSS.t1622 17.2706
R8630 VSS.n871 VSS.t46 17.2706
R8631 VSS.n5546 VSS.t3645 17.2706
R8632 VSS.t2612 VSS.n4979 17.2706
R8633 VSS.n5294 VSS.t2770 17.2706
R8634 VSS.n5038 VSS.t1343 17.2706
R8635 VSS.n4947 VSS.t1855 17.2706
R8636 VSS.n5105 VSS.t1595 17.2706
R8637 VSS.n5172 VSS.t3402 17.2706
R8638 VSS.n5220 VSS.t3353 17.2706
R8639 VSS.t3237 VSS.n3441 17.2706
R8640 VSS.n2342 VSS.t1184 17.2706
R8641 VSS.n2573 VSS.t1730 17.2706
R8642 VSS.n2501 VSS.t1994 17.2706
R8643 VSS.n3387 VSS.t1479 17.2706
R8644 VSS.n2427 VSS.t2256 17.2706
R8645 VSS.t2627 VSS.n2190 17.2706
R8646 VSS.n3948 VSS.t2658 17.2706
R8647 VSS.n3881 VSS.t1449 17.2706
R8648 VSS.n3674 VSS.t1963 17.2706
R8649 VSS.n3814 VSS.t1704 17.2706
R8650 VSS.n3766 VSS.t1148 17.2706
R8651 VSS.n3718 VSS.t3263 17.2706
R8652 VSS.n6205 VSS.t2028 17.2607
R8653 VSS.t2233 VSS.n2270 17.2497
R8654 VSS.n3510 VSS.t2205 17.2497
R8655 VSS.t2177 VSS.n3031 17.2497
R8656 VSS.t2149 VSS.n1153 17.2497
R8657 VSS.t2121 VSS.n4811 17.2497
R8658 VSS.n5372 VSS.t2093 17.2497
R8659 VSS.t2065 VSS.n414 17.2497
R8660 VSS.n4579 VSS.t3702 17.2395
R8661 VSS.n4328 VSS.t3798 17.2395
R8662 VSS.n4503 VSS.t3823 17.2395
R8663 VSS.n4455 VSS.t3850 17.2395
R8664 VSS.n217 VSS.t3882 17.2395
R8665 VSS.n292 VSS.t3914 17.2395
R8666 VSS.n117 VSS.t3948 17.2395
R8667 VSS.n4282 VSS.t3750 17.2395
R8668 VSS.n3933 VSS.t3813 17.2395
R8669 VSS.n3866 VSS.t3874 17.2395
R8670 VSS.n3659 VSS.t3938 17.2395
R8671 VSS.n3799 VSS.t3906 17.2395
R8672 VSS.n3751 VSS.t3843 17.2395
R8673 VSS.n3703 VSS.t3795 17.2395
R8674 VSS.n2327 VSS.t3846 17.2395
R8675 VSS.n2558 VSS.t3910 17.2395
R8676 VSS.n2295 VSS.t3990 17.2395
R8677 VSS.n4788 VSS.t3960 17.2395
R8678 VSS.n4834 VSS.t3966 17.2395
R8679 VSS.n5417 VSS.t3972 17.2395
R8680 VSS.n3055 VSS.t3978 17.2395
R8681 VSS.n2247 VSS.t3984 17.2395
R8682 VSS.n5966 VSS.t3771 17.2395
R8683 VSS.n5896 VSS.t3718 17.2395
R8684 VSS.n649 VSS.t3694 17.2395
R8685 VSS.n5687 VSS.t3853 17.2395
R8686 VSS.n5781 VSS.t3885 17.2395
R8687 VSS.n478 VSS.t3918 17.2395
R8688 VSS.n6000 VSS.t3954 17.2395
R8689 VSS.n552 VSS.t3754 17.2395
R8690 VSS.n5205 VSS.t3776 17.2395
R8691 VSS.n5157 VSS.t3827 17.2395
R8692 VSS.n5090 VSS.t3890 17.2395
R8693 VSS.n4932 VSS.t3922 17.2395
R8694 VSS.n5023 VSS.t3858 17.2395
R8695 VSS.n5279 VSS.t3805 17.2395
R8696 VSS.n5531 VSS.t3785 17.2395
R8697 VSS.n856 VSS.t3831 17.2395
R8698 VSS.n5483 VSS.t3894 17.2395
R8699 VSS.n1081 VSS.t3925 17.2395
R8700 VSS.n1013 VSS.t3862 17.2395
R8701 VSS.n946 VSS.t3808 17.2395
R8702 VSS.n1720 VSS.t3787 17.2395
R8703 VSS.n1412 VSS.t3835 17.2395
R8704 VSS.n1505 VSS.t3897 17.2395
R8705 VSS.n1653 VSS.t3930 17.2395
R8706 VSS.n1578 VSS.t3866 17.2395
R8707 VSS.n4078 VSS.t3810 17.2395
R8708 VSS.n4179 VSS.t3789 17.2395
R8709 VSS.n2952 VSS.t3839 17.2395
R8710 VSS.n3305 VSS.t3902 17.2395
R8711 VSS.n3106 VSS.t3934 17.2395
R8712 VSS.n3177 VSS.t3870 17.2395
R8713 VSS.n3241 VSS.t3710 17.2395
R8714 VSS.n3286 VSS.t3766 17.2395
R8715 VSS.n1475 VSS.t3763 17.2395
R8716 VSS.n919 VSS.t3759 17.2395
R8717 VSS.n4995 VSS.t3723 17.2395
R8718 VSS.n2486 VSS.t3942 17.2395
R8719 VSS.n3372 VSS.t3878 17.2395
R8720 VSS.n2412 VSS.t3820 17.2395
R8721 VSS.n2044 VSS.t3746 17.2395
R8722 VSS.n2044 VSS.t3747 17.2395
R8723 VSS.n2010 VSS.t3735 17.2395
R8724 VSS.n2010 VSS.t3744 17.2395
R8725 VSS.n3457 VSS.t3716 17.2395
R8726 VSS.n2206 VSS.t3768 17.2395
R8727 VSS.n4551 VSS.t2384 17.2297
R8728 VSS.n4300 VSS.t4017 17.2297
R8729 VSS.n4388 VSS.t2430 17.2297
R8730 VSS.n4427 VSS.t1283 17.2297
R8731 VSS.n185 VSS.t1543 17.2297
R8732 VSS.n261 VSS.t1803 17.2297
R8733 VSS.n106 VSS.t2045 17.2297
R8734 VSS.n4269 VSS.t3183 17.2297
R8735 VSS.n3930 VSS.t2661 17.2297
R8736 VSS.n3863 VSS.t1452 17.2297
R8737 VSS.n3656 VSS.t1966 17.2297
R8738 VSS.n3796 VSS.t1707 17.2297
R8739 VSS.n3748 VSS.t1153 17.2297
R8740 VSS.n3700 VSS.t3252 17.2297
R8741 VSS.n2324 VSS.t1189 17.2297
R8742 VSS.n2555 VSS.t1733 17.2297
R8743 VSS.n2263 VSS.t2243 17.2297
R8744 VSS.n4770 VSS.t2103 17.2297
R8745 VSS.n4804 VSS.t2131 17.2297
R8746 VSS.n1146 VSS.t2159 17.2297
R8747 VSS.n3024 VSS.t2187 17.2297
R8748 VSS.n2229 VSS.t2215 17.2297
R8749 VSS.n5937 VSS.t2321 17.2297
R8750 VSS.n5867 VSS.t2746 17.2297
R8751 VSS.n620 VSS.t10 17.2297
R8752 VSS.n5658 VSS.t1321 17.2297
R8753 VSS.n5752 VSS.t1570 17.2297
R8754 VSS.n449 VSS.t1831 17.2297
R8755 VSS.n407 VSS.t2075 17.2297
R8756 VSS.n524 VSS.t4300 17.2297
R8757 VSS.n5202 VSS.t2865 17.2297
R8758 VSS.n5154 VSS.t23 17.2297
R8759 VSS.n5087 VSS.t1598 17.2297
R8760 VSS.n4929 VSS.t1858 17.2297
R8761 VSS.n5020 VSS.t1346 17.2297
R8762 VSS.n5276 VSS.t2714 17.2297
R8763 VSS.n5528 VSS.t3405 17.2297
R8764 VSS.n853 VSS.t51 17.2297
R8765 VSS.n5480 VSS.t1625 17.2297
R8766 VSS.n1078 VSS.t1884 17.2297
R8767 VSS.n1010 VSS.t1370 17.2297
R8768 VSS.n943 VSS.t2699 17.2297
R8769 VSS.n1717 VSS.t3225 17.2297
R8770 VSS.n1409 VSS.t79 17.2297
R8771 VSS.n1502 VSS.t1651 17.2297
R8772 VSS.n1650 VSS.t1912 17.2297
R8773 VSS.n1575 VSS.t1398 17.2297
R8774 VSS.n4075 VSS.t2950 17.2297
R8775 VSS.n1286 VSS.t2719 17.2297
R8776 VSS.n2920 VSS.t1109 17.2297
R8777 VSS.n2894 VSS.t1679 17.2297
R8778 VSS.n2984 VSS.t1939 17.2297
R8779 VSS.n3138 VSS.t1424 17.2297
R8780 VSS.n3209 VSS.t2616 17.2297
R8781 VSS.n3273 VSS.t2478 17.2297
R8782 VSS.n1462 VSS.t4092 17.2297
R8783 VSS.n906 VSS.t4230 17.2297
R8784 VSS.n4982 VSS.t2922 17.2297
R8785 VSS.n2483 VSS.t1997 17.2297
R8786 VSS.n3369 VSS.t1482 17.2297
R8787 VSS.n2409 VSS.t2460 17.2297
R8788 VSS.n2025 VSS.t4309 17.2297
R8789 VSS.n2025 VSS.t4278 17.2297
R8790 VSS.n1990 VSS.t4148 17.2297
R8791 VSS.n1990 VSS.t2576 17.2297
R8792 VSS.n3444 VSS.t2738 17.2297
R8793 VSS.n2193 VSS.t2489 17.2297
R8794 VSS.n3586 VSS.t185 17.2278
R8795 VSS.n2060 VSS.t183 17.2278
R8796 VSS.n4580 VSS.t2381 17.2268
R8797 VSS.n4559 VSS.t2511 17.2268
R8798 VSS.n4329 VSS.t3792 17.2268
R8799 VSS.n4308 VSS.t2604 17.2268
R8800 VSS.n4504 VSS.t2427 17.2268
R8801 VSS.n4399 VSS.t3825 17.2268
R8802 VSS.n4456 VSS.t1288 17.2268
R8803 VSS.n4435 VSS.t1245 17.2268
R8804 VSS.n218 VSS.t1540 17.2268
R8805 VSS.n196 VSS.t1502 17.2268
R8806 VSS.n293 VSS.t1800 17.2268
R8807 VSS.n272 VSS.t1766 17.2268
R8808 VSS.n118 VSS.t2050 17.2268
R8809 VSS.n109 VSS.t2036 17.2268
R8810 VSS.n4281 VSS.t3180 17.2268
R8811 VSS.n4263 VSS.t3530 17.2268
R8812 VSS.n3932 VSS.t2654 17.2268
R8813 VSS.n3926 VSS.t3815 17.2268
R8814 VSS.n3865 VSS.t1456 17.2268
R8815 VSS.n3859 VSS.t1443 17.2268
R8816 VSS.n3658 VSS.t1959 17.2268
R8817 VSS.n3652 VSS.t1955 17.2268
R8818 VSS.n3798 VSS.t1700 17.2268
R8819 VSS.n3792 VSS.t1696 17.2268
R8820 VSS.n3750 VSS.t1150 17.2268
R8821 VSS.n3744 VSS.t1142 17.2268
R8822 VSS.n3702 VSS.t3256 17.2268
R8823 VSS.n3696 VSS.t3741 17.2268
R8824 VSS.n2326 VSS.t1186 17.2268
R8825 VSS.n2320 VSS.t1179 17.2268
R8826 VSS.n2557 VSS.t1726 17.2268
R8827 VSS.n2551 VSS.t1722 17.2268
R8828 VSS.n2296 VSS.t2240 17.2268
R8829 VSS.n2273 VSS.t2232 17.2268
R8830 VSS.n4789 VSS.t2100 17.2268
R8831 VSS.n4777 VSS.t2091 17.2268
R8832 VSS.n4835 VSS.t2128 17.2268
R8833 VSS.n4814 VSS.t2119 17.2268
R8834 VSS.n5418 VSS.t2156 17.2268
R8835 VSS.n1156 VSS.t2148 17.2268
R8836 VSS.n3056 VSS.t2184 17.2268
R8837 VSS.n3034 VSS.t2176 17.2268
R8838 VSS.n2248 VSS.t2212 17.2268
R8839 VSS.n2236 VSS.t2204 17.2268
R8840 VSS.n5967 VSS.t3245 17.2268
R8841 VSS.n5947 VSS.t3340 17.2268
R8842 VSS.n5897 VSS.t3720 17.2268
R8843 VSS.n5877 VSS.t3800 17.2268
R8844 VSS.n650 VSS.t7 17.2268
R8845 VSS.n630 VSS.t2471 17.2268
R8846 VSS.n5688 VSS.t1325 17.2268
R8847 VSS.n5668 VSS.t1312 17.2268
R8848 VSS.n5782 VSS.t1574 17.2268
R8849 VSS.n5762 VSS.t1561 17.2268
R8850 VSS.n479 VSS.t1824 17.2268
R8851 VSS.n459 VSS.t1820 17.2268
R8852 VSS.n6001 VSS.t2072 17.2268
R8853 VSS.n418 VSS.t2064 17.2268
R8854 VSS.n553 VSS.t3732 17.2268
R8855 VSS.n533 VSS.t3108 17.2268
R8856 VSS.n5204 VSS.t2425 17.2268
R8857 VSS.n5198 VSS.t2558 17.2268
R8858 VSS.n5156 VSS.t3398 17.2268
R8859 VSS.n5150 VSS.t3394 17.2268
R8860 VSS.n5089 VSS.t1591 17.2268
R8861 VSS.n5083 VSS.t1587 17.2268
R8862 VSS.n4931 VSS.t1851 17.2268
R8863 VSS.n4925 VSS.t1846 17.2268
R8864 VSS.n5022 VSS.t1339 17.2268
R8865 VSS.n5016 VSS.t1336 17.2268
R8866 VSS.n5278 VSS.t2711 17.2268
R8867 VSS.n5272 VSS.t2764 17.2268
R8868 VSS.n5530 VSS.t3782 17.2268
R8869 VSS.n5524 VSS.t3084 17.2268
R8870 VSS.n855 VSS.t48 17.2268
R8871 VSS.n849 VSS.t40 17.2268
R8872 VSS.n5482 VSS.t1618 17.2268
R8873 VSS.n5476 VSS.t1614 17.2268
R8874 VSS.n1080 VSS.t1888 17.2268
R8875 VSS.n1074 VSS.t1875 17.2268
R8876 VSS.n1012 VSS.t1363 17.2268
R8877 VSS.n1006 VSS.t1359 17.2268
R8878 VSS.n945 VSS.t2696 17.2268
R8879 VSS.n939 VSS.t2733 17.2268
R8880 VSS.n1719 VSS.t3229 17.2268
R8881 VSS.n1713 VSS.t3780 17.2268
R8882 VSS.n1411 VSS.t76 17.2268
R8883 VSS.n1405 VSS.t68 17.2268
R8884 VSS.n1504 VSS.t1655 17.2268
R8885 VSS.n1498 VSS.t1642 17.2268
R8886 VSS.n1652 VSS.t1905 17.2268
R8887 VSS.n1646 VSS.t1901 17.2268
R8888 VSS.n1577 VSS.t1391 17.2268
R8889 VSS.n1571 VSS.t1387 17.2268
R8890 VSS.n4077 VSS.t2947 17.2268
R8891 VSS.n4071 VSS.t3325 17.2268
R8892 VSS.n4178 VSS.t2723 17.2268
R8893 VSS.n1280 VSS.t3203 17.2268
R8894 VSS.n2951 VSS.t1106 17.2268
R8895 VSS.n2914 VSS.t1099 17.2268
R8896 VSS.n3304 VSS.t1672 17.2268
R8897 VSS.n2888 VSS.t1668 17.2268
R8898 VSS.n3105 VSS.t1932 17.2268
R8899 VSS.n2978 VSS.t1928 17.2268
R8900 VSS.n3176 VSS.t1428 17.2268
R8901 VSS.n3132 VSS.t1415 17.2268
R8902 VSS.n3240 VSS.t3817 17.2268
R8903 VSS.n3203 VSS.t3708 17.2268
R8904 VSS.n3285 VSS.t2475 17.2268
R8905 VSS.n3267 VSS.t2917 17.2268
R8906 VSS.n1474 VSS.t3730 17.2268
R8907 VSS.n1456 VSS.t3761 17.2268
R8908 VSS.n918 VSS.t2983 17.2268
R8909 VSS.n900 VSS.t3314 17.2268
R8910 VSS.n4994 VSS.t2919 17.2268
R8911 VSS.n4976 VSS.t3725 17.2268
R8912 VSS.n2485 VSS.t1990 17.2268
R8913 VSS.n2479 VSS.t1986 17.2268
R8914 VSS.n3371 VSS.t1475 17.2268
R8915 VSS.n3365 VSS.t1471 17.2268
R8916 VSS.n2411 VSS.t2455 17.2268
R8917 VSS.n2405 VSS.t2453 17.2268
R8918 VSS.n2030 VSS.t3713 17.2268
R8919 VSS.n2030 VSS.t3562 17.2268
R8920 VSS.n2041 VSS.t3216 17.2268
R8921 VSS.n2041 VSS.t3560 17.2268
R8922 VSS.n2002 VSS.t3737 17.2268
R8923 VSS.n2002 VSS.t3009 17.2268
R8924 VSS.n2011 VSS.t3110 17.2268
R8925 VSS.n2011 VSS.t3230 17.2268
R8926 VSS.n3456 VSS.t3233 17.2268
R8927 VSS.n3438 VSS.t3739 17.2268
R8928 VSS.n2205 VSS.t2486 17.2268
R8929 VSS.n2187 VSS.t2633 17.2268
R8930 VSS.n4571 VSS.t3356 17.2142
R8931 VSS.n4320 VSS.t2852 17.2142
R8932 VSS.n4411 VSS.t2691 17.2142
R8933 VSS.n4447 VSS.t1233 17.2142
R8934 VSS.n207 VSS.t1495 17.2142
R8935 VSS.n283 VSS.t1757 17.2142
R8936 VSS.n115 VSS.t2032 17.2142
R8937 VSS.n4260 VSS.t3188 17.2142
R8938 VSS.n3924 VSS.t4190 17.2142
R8939 VSS.n3857 VSS.t1438 17.2142
R8940 VSS.n3650 VSS.t1950 17.2142
R8941 VSS.n3790 VSS.t1691 17.2142
R8942 VSS.n3742 VSS.t1138 17.2142
R8943 VSS.n3694 VSS.t4136 17.2142
R8944 VSS.n2318 VSS.t1174 17.2142
R8945 VSS.n2549 VSS.t1718 17.2142
R8946 VSS.n2287 VSS.t2227 17.2142
R8947 VSS.n4785 VSS.t2087 17.2142
R8948 VSS.n4826 VSS.t2115 17.2142
R8949 VSS.n5409 VSS.t2143 17.2142
R8950 VSS.n3047 VSS.t2171 17.2142
R8951 VSS.n2244 VSS.t2199 17.2142
R8952 VSS.n5958 VSS.t4209 17.2142
R8953 VSS.n5888 VSS.t4004 17.2142
R8954 VSS.n641 VSS.t2467 17.2142
R8955 VSS.n5679 VSS.t1305 17.2142
R8956 VSS.n5773 VSS.t1556 17.2142
R8957 VSS.n470 VSS.t1815 17.2142
R8958 VSS.n430 VSS.t2059 17.2142
R8959 VSS.n544 VSS.t3212 17.2142
R8960 VSS.n5196 VSS.t2590 17.2142
R8961 VSS.n5148 VSS.t3389 17.2142
R8962 VSS.n5081 VSS.t1583 17.2142
R8963 VSS.n4923 VSS.t1842 17.2142
R8964 VSS.n5014 VSS.t1328 17.2142
R8965 VSS.n5270 VSS.t2759 17.2142
R8966 VSS.n5522 VSS.t3079 17.2142
R8967 VSS.n847 VSS.t35 17.2142
R8968 VSS.n5474 VSS.t1609 17.2142
R8969 VSS.n1072 VSS.t1870 17.2142
R8970 VSS.n1004 VSS.t1354 17.2142
R8971 VSS.n937 VSS.t2729 17.2142
R8972 VSS.n1711 VSS.t4313 17.2142
R8973 VSS.n1403 VSS.t63 17.2142
R8974 VSS.n1496 VSS.t1637 17.2142
R8975 VSS.n1644 VSS.t1897 17.2142
R8976 VSS.n1569 VSS.t1382 17.2142
R8977 VSS.n4069 VSS.t2773 17.2142
R8978 VSS.n1277 VSS.t3205 17.2142
R8979 VSS.n2911 VSS.t95 17.2142
R8980 VSS.n2885 VSS.t1664 17.2142
R8981 VSS.n2975 VSS.t1923 17.2142
R8982 VSS.n3129 VSS.t1410 17.2142
R8983 VSS.n3200 VSS.t4193 17.2142
R8984 VSS.n3264 VSS.t2784 17.2142
R8985 VSS.n1453 VSS.t3359 17.2142
R8986 VSS.n897 VSS.t3332 17.2142
R8987 VSS.n4973 VSS.t3112 17.2142
R8988 VSS.n2477 VSS.t1981 17.2142
R8989 VSS.n3363 VSS.t1466 17.2142
R8990 VSS.n2403 VSS.t2449 17.2142
R8991 VSS.n3435 VSS.t4321 17.2142
R8992 VSS.n2184 VSS.t2629 17.2142
R8993 VSS.n4549 VSS.t2386 17.212
R8994 VSS.n4298 VSS.t4019 17.212
R8995 VSS.n4386 VSS.t2432 17.212
R8996 VSS.n4425 VSS.t1285 17.212
R8997 VSS.n183 VSS.t1545 17.212
R8998 VSS.n259 VSS.t1805 17.212
R8999 VSS.n104 VSS.t2047 17.212
R9000 VSS.n4277 VSS.t3184 17.212
R9001 VSS.n3928 VSS.t2662 17.212
R9002 VSS.n3861 VSS.t1453 17.212
R9003 VSS.n3654 VSS.t1967 17.212
R9004 VSS.n3794 VSS.t1708 17.212
R9005 VSS.n3746 VSS.t1154 17.212
R9006 VSS.n3698 VSS.t3253 17.212
R9007 VSS.n2322 VSS.t1190 17.212
R9008 VSS.n2553 VSS.t1734 17.212
R9009 VSS.n2261 VSS.t2245 17.212
R9010 VSS.n4768 VSS.t2105 17.212
R9011 VSS.n4802 VSS.t2133 17.212
R9012 VSS.n1144 VSS.t2161 17.212
R9013 VSS.n3022 VSS.t2189 17.212
R9014 VSS.n2227 VSS.t2217 17.212
R9015 VSS.n5935 VSS.t2319 17.212
R9016 VSS.n5865 VSS.t2748 17.212
R9017 VSS.n618 VSS.t11 17.212
R9018 VSS.n5656 VSS.t1322 17.212
R9019 VSS.n5750 VSS.t1571 17.212
R9020 VSS.n447 VSS.t1832 17.212
R9021 VSS.n405 VSS.t2077 17.212
R9022 VSS.n521 VSS.t4301 17.212
R9023 VSS.n5200 VSS.t2866 17.212
R9024 VSS.n5152 VSS.t24 17.212
R9025 VSS.n5085 VSS.t1599 17.212
R9026 VSS.n4927 VSS.t1859 17.212
R9027 VSS.n5018 VSS.t1347 17.212
R9028 VSS.n5274 VSS.t2715 17.212
R9029 VSS.n5526 VSS.t3406 17.212
R9030 VSS.n851 VSS.t52 17.212
R9031 VSS.n5478 VSS.t1626 17.212
R9032 VSS.n1076 VSS.t1885 17.212
R9033 VSS.n1008 VSS.t1371 17.212
R9034 VSS.n941 VSS.t2700 17.212
R9035 VSS.n1715 VSS.t3226 17.212
R9036 VSS.n1407 VSS.t80 17.212
R9037 VSS.n1500 VSS.t1652 17.212
R9038 VSS.n1648 VSS.t1913 17.212
R9039 VSS.n1573 VSS.t1399 17.212
R9040 VSS.n4073 VSS.t2951 17.212
R9041 VSS.n4174 VSS.t2720 17.212
R9042 VSS.n2947 VSS.t1110 17.212
R9043 VSS.n3300 VSS.t1680 17.212
R9044 VSS.n3101 VSS.t1940 17.212
R9045 VSS.n3172 VSS.t1425 17.212
R9046 VSS.n3236 VSS.t2617 17.212
R9047 VSS.n3281 VSS.t2479 17.212
R9048 VSS.n1470 VSS.t4093 17.212
R9049 VSS.n914 VSS.t4231 17.212
R9050 VSS.n4990 VSS.t2923 17.212
R9051 VSS.n2481 VSS.t1998 17.212
R9052 VSS.n3367 VSS.t1483 17.212
R9053 VSS.n2407 VSS.t2458 17.212
R9054 VSS.n2022 VSS.t4308 17.212
R9055 VSS.n2022 VSS.t4276 17.212
R9056 VSS.n1988 VSS.t4149 17.212
R9057 VSS.n1988 VSS.t2578 17.212
R9058 VSS.n3452 VSS.t2736 17.212
R9059 VSS.n2201 VSS.t2490 17.212
R9060 VSS.n4605 VSS.t2391 17.2025
R9061 VSS.n4533 VSS.t4025 17.2025
R9062 VSS.n4380 VSS.t2437 17.2025
R9063 VSS.n4489 VSS.t1292 17.2025
R9064 VSS.n6169 VSS.t1550 17.2025
R9065 VSS.n253 VSS.t1810 17.2025
R9066 VSS.n6227 VSS.t2054 17.2025
R9067 VSS.n4272 VSS.t3267 17.2025
R9068 VSS.n3984 VSS.t2648 17.2025
R9069 VSS.n3910 VSS.t1460 17.2025
R9070 VSS.n3639 VSS.t1972 17.2025
R9071 VSS.n3843 VSS.t1713 17.2025
R9072 VSS.n3776 VSS.t1159 17.2025
R9073 VSS.n3728 VSS.t4291 17.2025
R9074 VSS.n3415 VSS.t1195 17.2025
R9075 VSS.n2538 VSS.t1739 17.2025
R9076 VSS.n2302 VSS.t2250 17.2025
R9077 VSS.n4795 VSS.t2110 17.2025
R9078 VSS.n4841 VSS.t2138 17.2025
R9079 VSS.n5424 VSS.t2166 17.2025
R9080 VSS.n3062 VSS.t2194 17.2025
R9081 VSS.n2254 VSS.t2222 17.2025
R9082 VSS.n5929 VSS.t2326 17.2025
R9083 VSS.n5859 VSS.t2753 17.2025
R9084 VSS.n612 VSS.t16 17.2025
R9085 VSS.n5650 VSS.t1310 17.2025
R9086 VSS.n5744 VSS.t1578 17.2025
R9087 VSS.n484 VSS.t1837 17.2025
R9088 VSS.n6007 VSS.t2082 17.2025
R9089 VSS.n515 VSS.t4307 17.2025
R9090 VSS.n5323 VSS.t2871 17.2025
R9091 VSS.n5182 VSS.t29 17.2025
R9092 VSS.n5134 VSS.t1604 17.2025
R9093 VSS.n4912 VSS.t1864 17.2025
R9094 VSS.n5067 VSS.t1333 17.2025
R9095 VSS.n5259 VSS.t3173 17.2025
R9096 VSS.n5582 VSS.t3411 17.2025
R9097 VSS.n836 VSS.t57 17.2025
R9098 VSS.n5508 VSS.t1631 17.2025
R9099 VSS.n5460 VSS.t1892 17.2025
R9100 VSS.n1058 VSS.t1376 17.2025
R9101 VSS.n990 VSS.t2705 17.2025
R9102 VSS.n4121 VSS.t3196 17.2025
R9103 VSS.n1392 VSS.t85 17.2025
R9104 VSS.n1697 VSS.t1659 17.2025
R9105 VSS.n1633 VSS.t1918 17.2025
R9106 VSS.n1558 VSS.t1404 17.2025
R9107 VSS.n4058 VSS.t3318 17.2025
R9108 VSS.n4169 VSS.t2727 17.2025
R9109 VSS.n2942 VSS.t1123 17.2025
R9110 VSS.n2869 VSS.t1685 17.2025
R9111 VSS.n3096 VSS.t1945 17.2025
R9112 VSS.n3167 VSS.t1432 17.2025
R9113 VSS.n3231 VSS.t2622 17.2025
R9114 VSS.n3276 VSS.t2484 17.2025
R9115 VSS.n1465 VSS.t4099 17.2025
R9116 VSS.n909 VSS.t2987 17.2025
R9117 VSS.n4985 VSS.t2928 17.2025
R9118 VSS.n2466 VSS.t2003 17.2025
R9119 VSS.n3352 VSS.t1488 17.2025
R9120 VSS.n2392 VSS.t2465 17.2025
R9121 VSS.n2016 VSS.t2685 17.2025
R9122 VSS.n2016 VSS.t2937 17.2025
R9123 VSS.n3570 VSS.t4 17.2025
R9124 VSS.n3570 VSS.t2581 17.2025
R9125 VSS.n3447 VSS.t2743 17.2025
R9126 VSS.n2196 VSS.t2675 17.2025
R9127 VSS.n4565 VSS.t3335 17.174
R9128 VSS.n4314 VSS.t2848 17.174
R9129 VSS.n4405 VSS.t2687 17.174
R9130 VSS.n4441 VSS.t1241 17.174
R9131 VSS.n202 VSS.t1259 17.174
R9132 VSS.n278 VSS.t1517 17.174
R9133 VSS.n112 VSS.t1777 17.174
R9134 VSS.n4255 VSS.t238 17.174
R9135 VSS.n165 VSS.t1498 17.174
R9136 VSS.n6192 VSS.t2314 17.174
R9137 VSS.n6189 VSS.t1977 17.174
R9138 VSS.n6189 VSS.t2007 17.174
R9139 VSS.n6186 VSS.t4244 17.174
R9140 VSS.n6186 VSS.t4243 17.174
R9141 VSS.n6216 VSS.t2019 17.174
R9142 VSS.n6214 VSS.t2587 17.174
R9143 VSS.n4223 VSS.t3472 17.174
R9144 VSS.n4223 VSS.t105 17.174
R9145 VSS.n4222 VSS.t4113 17.174
R9146 VSS.n4222 VSS.t4115 17.174
R9147 VSS.n4218 VSS.t3575 17.174
R9148 VSS.n4706 VSS.t103 17.174
R9149 VSS.n4704 VSS.t3039 17.174
R9150 VSS.n3921 VSS.t2515 17.174
R9151 VSS.n3854 VSS.t1434 17.174
R9152 VSS.n3647 VSS.t1493 17.174
R9153 VSS.n3787 VSS.t1236 17.174
R9154 VSS.n3739 VSS.t1125 17.174
R9155 VSS.n3691 VSS.t3533 17.174
R9156 VSS.n2315 VSS.t1161 17.174
R9157 VSS.n2546 VSS.t1247 17.174
R9158 VSS.n2279 VSS.t1764 17.174
R9159 VSS.n4780 VSS.t1755 17.174
R9160 VSS.n4820 VSS.t1773 17.174
R9161 VSS.n1162 VSS.t1771 17.174
R9162 VSS.n3040 VSS.t1769 17.174
R9163 VSS.n2239 VSS.t1761 17.174
R9164 VSS.n5953 VSS.t2968 17.174
R9165 VSS.n5883 VSS.t3422 17.174
R9166 VSS.n636 VSS.t2439 17.174
R9167 VSS.n5674 VSS.t1294 17.174
R9168 VSS.n5768 VSS.t1257 17.174
R9169 VSS.n465 VSS.t1515 17.174
R9170 VSS.n424 VSS.t1775 17.174
R9171 VSS.n539 VSS.t253 17.174
R9172 VSS.n5193 VSS.t2328 17.174
R9173 VSS.n5145 VSS.t18 17.174
R9174 VSS.n5078 VSS.t1238 17.174
R9175 VSS.n4920 VSS.t1513 17.174
R9176 VSS.n5011 VSS.t1298 17.174
R9177 VSS.n5267 VSS.t2755 17.174
R9178 VSS.n5519 VSS.t2873 17.174
R9179 VSS.n844 VSS.t31 17.174
R9180 VSS.n5471 VSS.t1255 17.174
R9181 VSS.n1069 VSS.t1511 17.174
R9182 VSS.n1001 VSS.t1350 17.174
R9183 VSS.n934 VSS.t3175 17.174
R9184 VSS.n1708 VSS.t3413 17.174
R9185 VSS.n1400 VSS.t59 17.174
R9186 VSS.n1493 VSS.t1253 17.174
R9187 VSS.n1641 VSS.t1509 17.174
R9188 VSS.n1566 VSS.t1378 17.174
R9189 VSS.n4066 VSS.t2707 17.174
R9190 VSS.n1272 VSS.t3198 17.174
R9191 VSS.n2906 VSS.t87 17.174
R9192 VSS.n2880 VSS.t1251 17.174
R9193 VSS.n2970 VSS.t1504 17.174
R9194 VSS.n3124 VSS.t1406 17.174
R9195 VSS.n3195 VSS.t3320 17.174
R9196 VSS.n3259 VSS.t315 17.174
R9197 VSS.n1448 VSS.t273 17.174
R9198 VSS.n892 VSS.t266 17.174
R9199 VSS.n4968 VSS.t261 17.174
R9200 VSS.n2474 VSS.t1507 17.174
R9201 VSS.n3360 VSS.t1462 17.174
R9202 VSS.n2400 VSS.t2513 17.174
R9203 VSS.n3430 VSS.t3240 17.174
R9204 VSS.n2179 VSS.t328 17.174
R9205 VSS.n2102 VSS.n2099 17.0893
R9206 VSS.n2075 VSS.n2074 17.048
R9207 VSS.t2238 VSS.n2269 17.0431
R9208 VSS.t2210 VSS.n2221 17.0431
R9209 VSS.t2182 VSS.n3030 17.0431
R9210 VSS.t2154 VSS.n1152 17.0431
R9211 VSS.t2126 VSS.n4810 17.0431
R9212 VSS.t2098 VSS.n4762 17.0431
R9213 VSS.t2070 VSS.n413 17.0431
R9214 VSS.n6194 VSS.n6178 17.0268
R9215 VSS.t2592 VSS.n1966 17.0231
R9216 VSS.n2101 VSS.t171 17.0211
R9217 VSS.n2072 VSS.t137 17.0211
R9218 VSS.n3583 VSS.n3582 17.0168
R9219 VSS.n2062 VSS.n2059 17.0017
R9220 VSS.n2087 VSS.n2086 17.0017
R9221 VSS.n2096 VSS.n2095 17.0017
R9222 VSS.n4624 VSS.n4244 17.001
R9223 VSS.n1975 VSS.n1921 17.001
R9224 VSS.n4719 VSS.n4712 17.001
R9225 VSS.n325 VSS.t346 17.0005
R9226 VSS.n324 VSS.t343 17.0005
R9227 VSS.n4349 VSS.t496 17.0005
R9228 VSS.n4350 VSS.t502 17.0005
R9229 VSS.n4519 VSS.t587 17.0005
R9230 VSS.n4520 VSS.t593 17.0005
R9231 VSS.n4357 VSS.t675 17.0005
R9232 VSS.n4358 VSS.t677 17.0005
R9233 VSS.n4476 VSS.t765 17.0005
R9234 VSS.n4477 VSS.t771 17.0005
R9235 VSS.n308 VSS.t909 17.0005
R9236 VSS.n309 VSS.t913 17.0005
R9237 VSS.n314 VSS.t1006 17.0005
R9238 VSS.n313 VSS.t1000 17.0005
R9239 VSS.n4 VSS.t207 17.0005
R9240 VSS.n5 VSS.t197 17.0005
R9241 VSS.n4750 VSS.t210 17.0005
R9242 VSS.n1171 VSS.t219 17.0005
R9243 VSS.n1173 VSS.t216 17.0005
R9244 VSS.n5396 VSS.t222 17.0005
R9245 VSS.n5398 VSS.t213 17.0005
R9246 VSS.n4197 VSS.t225 17.0005
R9247 VSS.n4198 VSS.t228 17.0005
R9248 VSS.n2215 VSS.t231 17.0005
R9249 VSS.n2217 VSS.t153 17.0005
R9250 VSS.t3635 VSS.n4274 17.0005
R9251 VSS.t3635 VSS.n4271 17.0005
R9252 VSS.t3635 VSS.n62 17.0005
R9253 VSS.t3635 VSS.n4285 17.0005
R9254 VSS.t3635 VSS.n4267 17.0005
R9255 VSS.n4289 VSS.t3635 17.0005
R9256 VSS.t3635 VSS.n4252 17.0005
R9257 VSS.t3635 VSS.n4254 17.0005
R9258 VSS.t3635 VSS.n4258 17.0005
R9259 VSS.t3635 VSS.n4248 17.0005
R9260 VSS.t3635 VSS.n4259 17.0005
R9261 VSS.t3635 VSS.n4246 17.0005
R9262 VSS.t3635 VSS.n4262 17.0005
R9263 VSS.n6212 VSS.n6203 17.0005
R9264 VSS.n6210 VSS.n6203 17.0005
R9265 VSS.n6208 VSS.n6203 17.0005
R9266 VSS.n6206 VSS.n6203 17.0005
R9267 VSS.n6203 VSS.n6200 17.0005
R9268 VSS.n6203 VSS.n6199 17.0005
R9269 VSS.n6203 VSS.n6198 17.0005
R9270 VSS.n6203 VSS.n140 17.0005
R9271 VSS.n6203 VSS.n142 17.0005
R9272 VSS.n6203 VSS.n139 17.0005
R9273 VSS.n6213 VSS.n6203 17.0005
R9274 VSS.n6194 VSS.n6185 17.0005
R9275 VSS.n6195 VSS.n6194 17.0005
R9276 VSS.n6194 VSS.n6184 17.0005
R9277 VSS.n6194 VSS.n6188 17.0005
R9278 VSS.n6194 VSS.n6182 17.0005
R9279 VSS.n6194 VSS.n6176 17.0005
R9280 VSS.n6194 VSS.n6180 17.0005
R9281 VSS.n6194 VSS.n147 17.0005
R9282 VSS.n6194 VSS.n6193 17.0005
R9283 VSS.n171 VSS.n158 17.0005
R9284 VSS.n171 VSS.n157 17.0005
R9285 VSS.n171 VSS.n160 17.0005
R9286 VSS.n171 VSS.n155 17.0005
R9287 VSS.n171 VSS.n151 17.0005
R9288 VSS.n171 VSS.n153 17.0005
R9289 VSS.n171 VSS.n150 17.0005
R9290 VSS.n4215 VSS.t3005 17.0005
R9291 VSS.n4708 VSS.n4617 17.0005
R9292 VSS.n4708 VSS.n4622 17.0005
R9293 VSS.n4708 VSS.n4616 17.0005
R9294 VSS.n4732 VSS.n4225 17.0005
R9295 VSS.n4732 VSS.n4226 17.0005
R9296 VSS.n4732 VSS.n4221 17.0005
R9297 VSS.n4732 VSS.n4229 17.0005
R9298 VSS.n4732 VSS.n4219 17.0005
R9299 VSS.n4732 VSS.n4231 17.0005
R9300 VSS.n4732 VSS.n4214 17.0005
R9301 VSS.n4732 VSS.n4731 17.0005
R9302 VSS.n4708 VSS.n4707 17.0005
R9303 VSS.n4147 VSS.t331 17.0005
R9304 VSS.n4148 VSS.t364 17.0005
R9305 VSS.n1356 VSS.t510 17.0005
R9306 VSS.n1357 VSS.t512 17.0005
R9307 VSS.n4140 VSS.t605 17.0005
R9308 VSS.n4142 VSS.t601 17.0005
R9309 VSS.n3155 VSS.t699 17.0005
R9310 VSS.n3156 VSS.t695 17.0005
R9311 VSS.n2843 VSS.t792 17.0005
R9312 VSS.n2844 VSS.t788 17.0005
R9313 VSS.n2849 VSS.t937 17.0005
R9314 VSS.n2850 VSS.t933 17.0005
R9315 VSS.n3084 VSS.t1024 17.0005
R9316 VSS.n3085 VSS.t1020 17.0005
R9317 VSS.n3543 VSS.t241 17.0005
R9318 VSS.n3544 VSS.t244 17.0005
R9319 VSS.n2152 VSS.t368 17.0005
R9320 VSS.n2154 VSS.t366 17.0005
R9321 VSS.n4005 VSS.t515 17.0005
R9322 VSS.n4007 VSS.t518 17.0005
R9323 VSS.n3972 VSS.t611 17.0005
R9324 VSS.n3973 VSS.t613 17.0005
R9325 VSS.n4012 VSS.t701 17.0005
R9326 VSS.n4013 VSS.t697 17.0005
R9327 VSS.n3321 VSS.t798 17.0005
R9328 VSS.n3322 VSS.t794 17.0005
R9329 VSS.n3999 VSS.t941 17.0005
R9330 VSS.n4001 VSS.t935 17.0005
R9331 VSS.n3618 VSS.t1030 17.0005
R9332 VSS.n3619 VSS.t1026 17.0005
R9333 VSS.n3952 VSS.t2658 17.0005
R9334 VSS.n3954 VSS.t2658 17.0005
R9335 VSS.n3885 VSS.t1449 17.0005
R9336 VSS.n3887 VSS.t1449 17.0005
R9337 VSS.n3678 VSS.t1963 17.0005
R9338 VSS.n3680 VSS.t1963 17.0005
R9339 VSS.n3818 VSS.t1704 17.0005
R9340 VSS.n3820 VSS.t1704 17.0005
R9341 VSS.n3770 VSS.t1148 17.0005
R9342 VSS.n3772 VSS.t1148 17.0005
R9343 VSS.n3722 VSS.t3263 17.0005
R9344 VSS.n3724 VSS.t3263 17.0005
R9345 VSS.n3730 VSS.n3684 17.0005
R9346 VSS.n3730 VSS.n3729 17.0005
R9347 VSS.n3731 VSS.n3730 17.0005
R9348 VSS.n3778 VSS.n3732 17.0005
R9349 VSS.n3778 VSS.n3777 17.0005
R9350 VSS.n3779 VSS.n3778 17.0005
R9351 VSS.n3845 VSS.n3780 17.0005
R9352 VSS.n3845 VSS.n3844 17.0005
R9353 VSS.n3846 VSS.n3845 17.0005
R9354 VSS.n3990 VSS.n3640 17.0005
R9355 VSS.n3991 VSS.n3990 17.0005
R9356 VSS.n3990 VSS.n3989 17.0005
R9357 VSS.n3912 VSS.n3847 17.0005
R9358 VSS.n3912 VSS.n3911 17.0005
R9359 VSS.n3913 VSS.n3912 17.0005
R9360 VSS.n3986 VSS.n3914 17.0005
R9361 VSS.n3986 VSS.n3985 17.0005
R9362 VSS.n3987 VSS.n3986 17.0005
R9363 VSS.n1913 VSS.t191 17.0005
R9364 VSS.n1904 VSS.t378 17.0005
R9365 VSS.n1906 VSS.t375 17.0005
R9366 VSS.n2371 VSS.t522 17.0005
R9367 VSS.n2372 VSS.t520 17.0005
R9368 VSS.n2444 VSS.t615 17.0005
R9369 VSS.n2445 VSS.t617 17.0005
R9370 VSS.n3404 VSS.t703 17.0005
R9371 VSS.n3405 VSS.t705 17.0005
R9372 VSS.n3331 VSS.t800 17.0005
R9373 VSS.n3332 VSS.t796 17.0005
R9374 VSS.n2518 VSS.t945 17.0005
R9375 VSS.n2519 VSS.t943 17.0005
R9376 VSS.n1888 VSS.t1032 17.0005
R9377 VSS.n1890 VSS.t1034 17.0005
R9378 VSS.n2346 VSS.t1184 17.0005
R9379 VSS.n2348 VSS.t1184 17.0005
R9380 VSS.n2577 VSS.t1730 17.0005
R9381 VSS.n2579 VSS.t1730 17.0005
R9382 VSS.n5982 VSS.t349 17.0005
R9383 VSS.n5909 VSS.t498 17.0005
R9384 VSS.n5839 VSS.t595 17.0005
R9385 VSS.n5629 VSS.t683 17.0005
R9386 VSS.n5698 VSS.t767 17.0005
R9387 VSS.n5724 VSS.t915 17.0005
R9388 VSS.n584 VSS.t998 17.0005
R9389 VSS.n4752 VSS.t194 17.0005
R9390 VSS.n5984 VSS.t340 17.0005
R9391 VSS.t3249 VSS.n437 17.0005
R9392 VSS.t3249 VSS.n5955 17.0005
R9393 VSS.t3249 VSS.n5952 17.0005
R9394 VSS.t3249 VSS.n5950 17.0005
R9395 VSS.t3249 VSS.n5961 17.0005
R9396 VSS.t3249 VSS.n5949 17.0005
R9397 VSS.t3249 VSS.n5963 17.0005
R9398 VSS.t3249 VSS.n5946 17.0005
R9399 VSS.t3249 VSS.n5940 17.0005
R9400 VSS.t3249 VSS.n5939 17.0005
R9401 VSS.n5910 VSS.t500 17.0005
R9402 VSS.t3649 VSS.n438 17.0005
R9403 VSS.t3649 VSS.n5885 17.0005
R9404 VSS.t3649 VSS.n5882 17.0005
R9405 VSS.t3649 VSS.n5880 17.0005
R9406 VSS.t3649 VSS.n5891 17.0005
R9407 VSS.t3649 VSS.n5879 17.0005
R9408 VSS.t3649 VSS.n5893 17.0005
R9409 VSS.t3649 VSS.n5876 17.0005
R9410 VSS.t3649 VSS.n5870 17.0005
R9411 VSS.t3649 VSS.n5869 17.0005
R9412 VSS.n5840 VSS.t591 17.0005
R9413 VSS.t2447 VSS.n439 17.0005
R9414 VSS.t2447 VSS.n638 17.0005
R9415 VSS.t2447 VSS.n635 17.0005
R9416 VSS.t2447 VSS.n633 17.0005
R9417 VSS.t2447 VSS.n644 17.0005
R9418 VSS.t2447 VSS.n632 17.0005
R9419 VSS.t2447 VSS.n646 17.0005
R9420 VSS.t2447 VSS.n629 17.0005
R9421 VSS.t2447 VSS.n623 17.0005
R9422 VSS.t2447 VSS.n622 17.0005
R9423 VSS.n5630 VSS.t689 17.0005
R9424 VSS.t1318 VSS.n440 17.0005
R9425 VSS.t1318 VSS.n5676 17.0005
R9426 VSS.t1318 VSS.n5673 17.0005
R9427 VSS.t1318 VSS.n5671 17.0005
R9428 VSS.t1318 VSS.n5682 17.0005
R9429 VSS.t1318 VSS.n5670 17.0005
R9430 VSS.t1318 VSS.n5684 17.0005
R9431 VSS.t1318 VSS.n5667 17.0005
R9432 VSS.t1318 VSS.n5661 17.0005
R9433 VSS.t1318 VSS.n5660 17.0005
R9434 VSS.n5699 VSS.t773 17.0005
R9435 VSS.t1567 VSS.n441 17.0005
R9436 VSS.t1567 VSS.n5770 17.0005
R9437 VSS.t1567 VSS.n5767 17.0005
R9438 VSS.t1567 VSS.n5765 17.0005
R9439 VSS.t1567 VSS.n5776 17.0005
R9440 VSS.t1567 VSS.n5764 17.0005
R9441 VSS.t1567 VSS.n5778 17.0005
R9442 VSS.t1567 VSS.n5761 17.0005
R9443 VSS.t1567 VSS.n5755 17.0005
R9444 VSS.t1567 VSS.n5754 17.0005
R9445 VSS.n5725 VSS.t911 17.0005
R9446 VSS.n5994 VSS.t1828 17.0005
R9447 VSS.t1828 VSS.n467 17.0005
R9448 VSS.t1828 VSS.n464 17.0005
R9449 VSS.t1828 VSS.n462 17.0005
R9450 VSS.t1828 VSS.n473 17.0005
R9451 VSS.t1828 VSS.n461 17.0005
R9452 VSS.t1828 VSS.n475 17.0005
R9453 VSS.t1828 VSS.n458 17.0005
R9454 VSS.t1828 VSS.n452 17.0005
R9455 VSS.t1828 VSS.n451 17.0005
R9456 VSS.n586 VSS.t1004 17.0005
R9457 VSS.t2423 VSS.n436 17.0005
R9458 VSS.t2423 VSS.n541 17.0005
R9459 VSS.t2423 VSS.n538 17.0005
R9460 VSS.t2423 VSS.n536 17.0005
R9461 VSS.t2423 VSS.n547 17.0005
R9462 VSS.t2423 VSS.n535 17.0005
R9463 VSS.t2423 VSS.n549 17.0005
R9464 VSS.t2423 VSS.n532 17.0005
R9465 VSS.t2423 VSS.n526 17.0005
R9466 VSS.t2423 VSS.n523 17.0005
R9467 VSS.t2423 VSS.n516 17.0005
R9468 VSS.n558 VSS.t2423 17.0005
R9469 VSS.t2423 VSS.n486 17.0005
R9470 VSS.t3649 VSS.n5860 17.0005
R9471 VSS.n5902 VSS.t3649 17.0005
R9472 VSS.t3649 VSS.n487 17.0005
R9473 VSS.t1318 VSS.n5651 17.0005
R9474 VSS.n5693 VSS.t1318 17.0005
R9475 VSS.t1318 VSS.n488 17.0005
R9476 VSS.t1828 VSS.n442 17.0005
R9477 VSS.t1828 VSS.n485 17.0005
R9478 VSS.t1828 VSS.n5993 17.0005
R9479 VSS.t1567 VSS.n5745 17.0005
R9480 VSS.n5787 VSS.t1567 17.0005
R9481 VSS.t1567 VSS.n489 17.0005
R9482 VSS.t2447 VSS.n613 17.0005
R9483 VSS.n655 VSS.t2447 17.0005
R9484 VSS.t2447 VSS.n490 17.0005
R9485 VSS.t3249 VSS.n5930 17.0005
R9486 VSS.n5972 VSS.t3249 17.0005
R9487 VSS.t3249 VSS.n491 17.0005
R9488 VSS.n5813 VSS.t337 17.0005
R9489 VSS.n5814 VSS.t352 17.0005
R9490 VSS.n5312 VSS.t504 17.0005
R9491 VSS.n5313 VSS.t491 17.0005
R9492 VSS.n5806 VSS.t597 17.0005
R9493 VSS.n5808 VSS.t585 17.0005
R9494 VSS.n726 VSS.t687 17.0005
R9495 VSS.n728 VSS.t685 17.0005
R9496 VSS.n5800 VSS.t777 17.0005
R9497 VSS.n5802 VSS.t775 17.0005
R9498 VSS.n4891 VSS.t917 17.0005
R9499 VSS.n4892 VSS.t919 17.0005
R9500 VSS.n5336 VSS.t1010 17.0005
R9501 VSS.n5337 VSS.t1002 17.0005
R9502 VSS.n5224 VSS.t3353 17.0005
R9503 VSS.n5226 VSS.t3353 17.0005
R9504 VSS.n5176 VSS.t3402 17.0005
R9505 VSS.n5178 VSS.t3402 17.0005
R9506 VSS.n5109 VSS.t1595 17.0005
R9507 VSS.n5111 VSS.t1595 17.0005
R9508 VSS.n4951 VSS.t1855 17.0005
R9509 VSS.n4953 VSS.t1855 17.0005
R9510 VSS.n5042 VSS.t1343 17.0005
R9511 VSS.n5044 VSS.t1343 17.0005
R9512 VSS.n5298 VSS.t2770 17.0005
R9513 VSS.n5300 VSS.t2770 17.0005
R9514 VSS.n5304 VSS.n5260 17.0005
R9515 VSS.n5305 VSS.n5304 17.0005
R9516 VSS.n5304 VSS.n5003 17.0005
R9517 VSS.n5069 VSS.n5004 17.0005
R9518 VSS.n5069 VSS.n5068 17.0005
R9519 VSS.n5070 VSS.n5069 17.0005
R9520 VSS.n5329 VSS.n4913 17.0005
R9521 VSS.n5330 VSS.n5329 17.0005
R9522 VSS.n5329 VSS.n5328 17.0005
R9523 VSS.n5136 VSS.n5071 17.0005
R9524 VSS.n5136 VSS.n5135 17.0005
R9525 VSS.n5137 VSS.n5136 17.0005
R9526 VSS.n5184 VSS.n5138 17.0005
R9527 VSS.n5184 VSS.n5183 17.0005
R9528 VSS.n5185 VSS.n5184 17.0005
R9529 VSS.n5325 VSS.n5186 17.0005
R9530 VSS.n5325 VSS.n5324 17.0005
R9531 VSS.n5326 VSS.n5325 17.0005
R9532 VSS.n5604 VSS.t355 17.0005
R9533 VSS.n5605 VSS.t334 17.0005
R9534 VSS.n5571 VSS.t506 17.0005
R9535 VSS.n5572 VSS.t471 17.0005
R9536 VSS.n5597 VSS.t599 17.0005
R9537 VSS.n5599 VSS.t589 17.0005
R9538 VSS.n815 VSS.t691 17.0005
R9539 VSS.n816 VSS.t681 17.0005
R9540 VSS.n809 VSS.t779 17.0005
R9541 VSS.n811 VSS.t769 17.0005
R9542 VSS.n801 VSS.t925 17.0005
R9543 VSS.n803 VSS.t927 17.0005
R9544 VSS.n5449 VSS.t1016 17.0005
R9545 VSS.n5450 VSS.t1008 17.0005
R9546 VSS.n5550 VSS.t3645 17.0005
R9547 VSS.n5552 VSS.t3645 17.0005
R9548 VSS.n875 VSS.t46 17.0005
R9549 VSS.n877 VSS.t46 17.0005
R9550 VSS.n5502 VSS.t1622 17.0005
R9551 VSS.n5504 VSS.t1622 17.0005
R9552 VSS.n1100 VSS.t1881 17.0005
R9553 VSS.n1102 VSS.t1881 17.0005
R9554 VSS.n1032 VSS.t1367 17.0005
R9555 VSS.n1034 VSS.t1367 17.0005
R9556 VSS.n965 VSS.t3457 17.0005
R9557 VSS.n967 VSS.t3457 17.0005
R9558 VSS.n992 VSS.n927 17.0005
R9559 VSS.n992 VSS.n991 17.0005
R9560 VSS.n993 VSS.n992 17.0005
R9561 VSS.n1060 VSS.n994 17.0005
R9562 VSS.n1060 VSS.n1059 17.0005
R9563 VSS.n1061 VSS.n1060 17.0005
R9564 VSS.n5462 VSS.n1062 17.0005
R9565 VSS.n5462 VSS.n5461 17.0005
R9566 VSS.n5463 VSS.n5462 17.0005
R9567 VSS.n5510 VSS.n5464 17.0005
R9568 VSS.n5510 VSS.n5509 17.0005
R9569 VSS.n5511 VSS.n5510 17.0005
R9570 VSS.n5588 VSS.n837 17.0005
R9571 VSS.n5589 VSS.n5588 17.0005
R9572 VSS.n5588 VSS.n5587 17.0005
R9573 VSS.n5584 VSS.n5512 17.0005
R9574 VSS.n5584 VSS.n5583 17.0005
R9575 VSS.n5585 VSS.n5584 17.0005
R9576 VSS.n1760 VSS.t358 17.0005
R9577 VSS.n1761 VSS.t361 17.0005
R9578 VSS.n4110 VSS.t508 17.0005
R9579 VSS.n4111 VSS.t473 17.0005
R9580 VSS.n1365 VSS.t603 17.0005
R9581 VSS.n1366 VSS.t583 17.0005
R9582 VSS.n1371 VSS.t693 17.0005
R9583 VSS.n1372 VSS.t679 17.0005
R9584 VSS.n1611 VSS.t790 17.0005
R9585 VSS.n1612 VSS.t786 17.0005
R9586 VSS.n1685 VSS.t931 17.0005
R9587 VSS.n1686 VSS.t929 17.0005
R9588 VSS.n1201 VSS.t1022 17.0005
R9589 VSS.n1203 VSS.t1018 17.0005
R9590 VSS.n1739 VSS.t2295 17.0005
R9591 VSS.n1741 VSS.t2295 17.0005
R9592 VSS.n1431 VSS.t74 17.0005
R9593 VSS.n1433 VSS.t74 17.0005
R9594 VSS.n1524 VSS.t1648 17.0005
R9595 VSS.n1526 VSS.t1648 17.0005
R9596 VSS.n1672 VSS.t1909 17.0005
R9597 VSS.n1674 VSS.t1909 17.0005
R9598 VSS.n1597 VSS.t1395 17.0005
R9599 VSS.n1599 VSS.t1395 17.0005
R9600 VSS.n4097 VSS.t2945 17.0005
R9601 VSS.n4099 VSS.t2945 17.0005
R9602 VSS.n4103 VSS.n4059 17.0005
R9603 VSS.n4104 VSS.n4103 17.0005
R9604 VSS.n4103 VSS.n1483 17.0005
R9605 VSS.n1603 VSS.n1559 17.0005
R9606 VSS.n1604 VSS.n1603 17.0005
R9607 VSS.n1603 VSS.n1484 17.0005
R9608 VSS.n1678 VSS.n1634 17.0005
R9609 VSS.n1679 VSS.n1678 17.0005
R9610 VSS.n1678 VSS.n1485 17.0005
R9611 VSS.n1699 VSS.n1486 17.0005
R9612 VSS.n1699 VSS.n1698 17.0005
R9613 VSS.n1700 VSS.n1699 17.0005
R9614 VSS.n4127 VSS.n1393 17.0005
R9615 VSS.n4128 VSS.n4127 17.0005
R9616 VSS.n4127 VSS.n4126 17.0005
R9617 VSS.n4123 VSS.n1701 17.0005
R9618 VSS.n4123 VSS.n4122 17.0005
R9619 VSS.n4124 VSS.n4123 17.0005
R9620 VSS.t3279 VSS.n4171 17.0005
R9621 VSS.t3279 VSS.n4168 17.0005
R9622 VSS.t3279 VSS.n1288 17.0005
R9623 VSS.t3279 VSS.n4182 17.0005
R9624 VSS.t3279 VSS.n1284 17.0005
R9625 VSS.t1104 VSS.n2944 17.0005
R9626 VSS.t1104 VSS.n2941 17.0005
R9627 VSS.n2959 VSS.t1104 17.0005
R9628 VSS.t1104 VSS.n2955 17.0005
R9629 VSS.t1104 VSS.n2918 17.0005
R9630 VSS.t1676 VSS.n3297 17.0005
R9631 VSS.n3312 VSS.t1676 17.0005
R9632 VSS.t1676 VSS.n3295 17.0005
R9633 VSS.t1676 VSS.n3308 17.0005
R9634 VSS.t1676 VSS.n2892 17.0005
R9635 VSS.t1936 VSS.n3098 17.0005
R9636 VSS.t1936 VSS.n3095 17.0005
R9637 VSS.n3113 VSS.t1936 17.0005
R9638 VSS.t1936 VSS.n3109 17.0005
R9639 VSS.t1936 VSS.n2982 17.0005
R9640 VSS.t1421 VSS.n3169 17.0005
R9641 VSS.t1421 VSS.n3166 17.0005
R9642 VSS.n3184 VSS.t1421 17.0005
R9643 VSS.t1421 VSS.n3180 17.0005
R9644 VSS.t1421 VSS.n3136 17.0005
R9645 VSS.t3653 VSS.n3233 17.0005
R9646 VSS.t3653 VSS.n3230 17.0005
R9647 VSS.n3248 VSS.t3653 17.0005
R9648 VSS.t3653 VSS.n3244 17.0005
R9649 VSS.t3653 VSS.n3207 17.0005
R9650 VSS.t2555 VSS.n3278 17.0005
R9651 VSS.t2555 VSS.n3275 17.0005
R9652 VSS.n3293 VSS.t2555 17.0005
R9653 VSS.t2555 VSS.n3289 17.0005
R9654 VSS.t2555 VSS.n3271 17.0005
R9655 VSS.t2555 VSS.n1256 17.0005
R9656 VSS.t2555 VSS.n3256 17.0005
R9657 VSS.t2555 VSS.n3258 17.0005
R9658 VSS.t2555 VSS.n3262 17.0005
R9659 VSS.t2555 VSS.n3252 17.0005
R9660 VSS.t2555 VSS.n3263 17.0005
R9661 VSS.t2555 VSS.n3250 17.0005
R9662 VSS.t2555 VSS.n3266 17.0005
R9663 VSS.t3653 VSS.n1257 17.0005
R9664 VSS.t3653 VSS.n3192 17.0005
R9665 VSS.t3653 VSS.n3194 17.0005
R9666 VSS.t3653 VSS.n3198 17.0005
R9667 VSS.t3653 VSS.n3188 17.0005
R9668 VSS.t3653 VSS.n3199 17.0005
R9669 VSS.t3653 VSS.n3186 17.0005
R9670 VSS.t3653 VSS.n3202 17.0005
R9671 VSS.t1421 VSS.n1258 17.0005
R9672 VSS.t1421 VSS.n3121 17.0005
R9673 VSS.t1421 VSS.n3123 17.0005
R9674 VSS.t1421 VSS.n3127 17.0005
R9675 VSS.t1421 VSS.n3117 17.0005
R9676 VSS.t1421 VSS.n3128 17.0005
R9677 VSS.t1421 VSS.n3115 17.0005
R9678 VSS.t1421 VSS.n3131 17.0005
R9679 VSS.t1936 VSS.n1259 17.0005
R9680 VSS.t1936 VSS.n2967 17.0005
R9681 VSS.t1936 VSS.n2969 17.0005
R9682 VSS.t1936 VSS.n2973 17.0005
R9683 VSS.t1936 VSS.n2963 17.0005
R9684 VSS.t1936 VSS.n2974 17.0005
R9685 VSS.t1936 VSS.n2961 17.0005
R9686 VSS.t1936 VSS.n2977 17.0005
R9687 VSS.t1676 VSS.n1260 17.0005
R9688 VSS.t1676 VSS.n2877 17.0005
R9689 VSS.t1676 VSS.n2879 17.0005
R9690 VSS.t1676 VSS.n2883 17.0005
R9691 VSS.t1676 VSS.n2873 17.0005
R9692 VSS.t1676 VSS.n2884 17.0005
R9693 VSS.t1676 VSS.n2871 17.0005
R9694 VSS.t1676 VSS.n2887 17.0005
R9695 VSS.t1104 VSS.n1261 17.0005
R9696 VSS.t1104 VSS.n2903 17.0005
R9697 VSS.t1104 VSS.n2905 17.0005
R9698 VSS.t1104 VSS.n2909 17.0005
R9699 VSS.t1104 VSS.n2899 17.0005
R9700 VSS.t1104 VSS.n2910 17.0005
R9701 VSS.t1104 VSS.n2897 17.0005
R9702 VSS.t1104 VSS.n2913 17.0005
R9703 VSS.n4186 VSS.t3279 17.0005
R9704 VSS.t3279 VSS.n1269 17.0005
R9705 VSS.t3279 VSS.n1271 17.0005
R9706 VSS.t3279 VSS.n1275 17.0005
R9707 VSS.t3279 VSS.n1265 17.0005
R9708 VSS.t3279 VSS.n1276 17.0005
R9709 VSS.t3279 VSS.n1263 17.0005
R9710 VSS.t3279 VSS.n1279 17.0005
R9711 VSS.n1229 VSS.n1205 17.0005
R9712 VSS.n1236 VSS.n1205 17.0005
R9713 VSS.n1235 VSS.n1205 17.0005
R9714 VSS.n1239 VSS.n1205 17.0005
R9715 VSS.n1220 VSS.n1205 17.0005
R9716 VSS.n1240 VSS.n1205 17.0005
R9717 VSS.n1219 VSS.n1205 17.0005
R9718 VSS.n1241 VSS.n1205 17.0005
R9719 VSS.n1217 VSS.n1205 17.0005
R9720 VSS.n4191 VSS.n1205 17.0005
R9721 VSS.n1216 VSS.n1205 17.0005
R9722 VSS.n1247 VSS.n1205 17.0005
R9723 VSS.n1246 VSS.n1205 17.0005
R9724 VSS.n1254 VSS.n1205 17.0005
R9725 VSS.n1253 VSS.n1205 17.0005
R9726 VSS.n4188 VSS.n1205 17.0005
R9727 VSS.n1680 VSS.n1206 17.0005
R9728 VSS.n1230 VSS.n1206 17.0005
R9729 VSS.n1682 VSS.n1206 17.0005
R9730 VSS.n1224 VSS.n1206 17.0005
R9731 VSS.n1630 VSS.n1206 17.0005
R9732 VSS.n1237 VSS.n1206 17.0005
R9733 VSS.n1220 VSS.n1206 17.0005
R9734 VSS.n1240 VSS.n1206 17.0005
R9735 VSS.n1219 VSS.n1206 17.0005
R9736 VSS.n1241 VSS.n1206 17.0005
R9737 VSS.n1217 VSS.n1206 17.0005
R9738 VSS.n4191 VSS.n1206 17.0005
R9739 VSS.n1216 VSS.n1206 17.0005
R9740 VSS.n1245 VSS.n1206 17.0005
R9741 VSS.n1215 VSS.n1206 17.0005
R9742 VSS.n1247 VSS.n1206 17.0005
R9743 VSS.n1214 VSS.n1206 17.0005
R9744 VSS.n1255 VSS.n1206 17.0005
R9745 VSS.n1212 VSS.n1206 17.0005
R9746 VSS.n4189 VSS.n1206 17.0005
R9747 VSS.n1229 VSS.n1199 17.0005
R9748 VSS.n1236 VSS.n1199 17.0005
R9749 VSS.n1235 VSS.n1199 17.0005
R9750 VSS.n1239 VSS.n1199 17.0005
R9751 VSS.n1220 VSS.n1199 17.0005
R9752 VSS.n1240 VSS.n1199 17.0005
R9753 VSS.n1219 VSS.n1199 17.0005
R9754 VSS.n1241 VSS.n1199 17.0005
R9755 VSS.n1217 VSS.n1199 17.0005
R9756 VSS.n4191 VSS.n1199 17.0005
R9757 VSS.n1216 VSS.n1199 17.0005
R9758 VSS.n1245 VSS.n1199 17.0005
R9759 VSS.n1215 VSS.n1199 17.0005
R9760 VSS.n1247 VSS.n1199 17.0005
R9761 VSS.n1246 VSS.n1199 17.0005
R9762 VSS.n1254 VSS.n1199 17.0005
R9763 VSS.n1253 VSS.n1199 17.0005
R9764 VSS.n4188 VSS.n1199 17.0005
R9765 VSS.n1696 VSS.n1207 17.0005
R9766 VSS.n1230 VSS.n1207 17.0005
R9767 VSS.n1694 VSS.n1207 17.0005
R9768 VSS.n1224 VSS.n1207 17.0005
R9769 VSS.n1543 VSS.n1207 17.0005
R9770 VSS.n1237 VSS.n1207 17.0005
R9771 VSS.n1223 VSS.n1207 17.0005
R9772 VSS.n1239 VSS.n1207 17.0005
R9773 VSS.n1220 VSS.n1207 17.0005
R9774 VSS.n1240 VSS.n1207 17.0005
R9775 VSS.n1219 VSS.n1207 17.0005
R9776 VSS.n1241 VSS.n1207 17.0005
R9777 VSS.n1217 VSS.n1207 17.0005
R9778 VSS.n4191 VSS.n1207 17.0005
R9779 VSS.n1216 VSS.n1207 17.0005
R9780 VSS.n1245 VSS.n1207 17.0005
R9781 VSS.n1215 VSS.n1207 17.0005
R9782 VSS.n1247 VSS.n1207 17.0005
R9783 VSS.n1214 VSS.n1207 17.0005
R9784 VSS.n1255 VSS.n1207 17.0005
R9785 VSS.n1212 VSS.n1207 17.0005
R9786 VSS.n4189 VSS.n1207 17.0005
R9787 VSS.n1229 VSS.n1198 17.0005
R9788 VSS.n1236 VSS.n1198 17.0005
R9789 VSS.n1235 VSS.n1198 17.0005
R9790 VSS.n1239 VSS.n1198 17.0005
R9791 VSS.n1220 VSS.n1198 17.0005
R9792 VSS.n1240 VSS.n1198 17.0005
R9793 VSS.n1219 VSS.n1198 17.0005
R9794 VSS.n1241 VSS.n1198 17.0005
R9795 VSS.n1217 VSS.n1198 17.0005
R9796 VSS.n4191 VSS.n1198 17.0005
R9797 VSS.n1216 VSS.n1198 17.0005
R9798 VSS.n1245 VSS.n1198 17.0005
R9799 VSS.n1215 VSS.n1198 17.0005
R9800 VSS.n1247 VSS.n1198 17.0005
R9801 VSS.n1246 VSS.n1198 17.0005
R9802 VSS.n1254 VSS.n1198 17.0005
R9803 VSS.n1253 VSS.n1198 17.0005
R9804 VSS.n4188 VSS.n1198 17.0005
R9805 VSS.n1605 VSS.n1208 17.0005
R9806 VSS.n1230 VSS.n1208 17.0005
R9807 VSS.n1607 VSS.n1208 17.0005
R9808 VSS.n1224 VSS.n1208 17.0005
R9809 VSS.n1556 VSS.n1208 17.0005
R9810 VSS.n1237 VSS.n1208 17.0005
R9811 VSS.n1223 VSS.n1208 17.0005
R9812 VSS.n1239 VSS.n1208 17.0005
R9813 VSS.n1220 VSS.n1208 17.0005
R9814 VSS.n1240 VSS.n1208 17.0005
R9815 VSS.n1219 VSS.n1208 17.0005
R9816 VSS.n1241 VSS.n1208 17.0005
R9817 VSS.n1217 VSS.n1208 17.0005
R9818 VSS.n4191 VSS.n1208 17.0005
R9819 VSS.n1216 VSS.n1208 17.0005
R9820 VSS.n1245 VSS.n1208 17.0005
R9821 VSS.n1215 VSS.n1208 17.0005
R9822 VSS.n1247 VSS.n1208 17.0005
R9823 VSS.n1214 VSS.n1208 17.0005
R9824 VSS.n1255 VSS.n1208 17.0005
R9825 VSS.n1212 VSS.n1208 17.0005
R9826 VSS.n4189 VSS.n1208 17.0005
R9827 VSS.n1229 VSS.n1197 17.0005
R9828 VSS.n1236 VSS.n1197 17.0005
R9829 VSS.n1235 VSS.n1197 17.0005
R9830 VSS.n1239 VSS.n1197 17.0005
R9831 VSS.n1220 VSS.n1197 17.0005
R9832 VSS.n1240 VSS.n1197 17.0005
R9833 VSS.n1219 VSS.n1197 17.0005
R9834 VSS.n1241 VSS.n1197 17.0005
R9835 VSS.n1217 VSS.n1197 17.0005
R9836 VSS.n4191 VSS.n1197 17.0005
R9837 VSS.n1216 VSS.n1197 17.0005
R9838 VSS.n1245 VSS.n1197 17.0005
R9839 VSS.n1215 VSS.n1197 17.0005
R9840 VSS.n1247 VSS.n1197 17.0005
R9841 VSS.n1246 VSS.n1197 17.0005
R9842 VSS.n1254 VSS.n1197 17.0005
R9843 VSS.n1253 VSS.n1197 17.0005
R9844 VSS.n4188 VSS.n1197 17.0005
R9845 VSS.n4129 VSS.n1209 17.0005
R9846 VSS.n1230 VSS.n1209 17.0005
R9847 VSS.n4131 VSS.n1209 17.0005
R9848 VSS.n1224 VSS.n1209 17.0005
R9849 VSS.n1389 VSS.n1209 17.0005
R9850 VSS.n1237 VSS.n1209 17.0005
R9851 VSS.n1223 VSS.n1209 17.0005
R9852 VSS.n1239 VSS.n1209 17.0005
R9853 VSS.n1220 VSS.n1209 17.0005
R9854 VSS.n1240 VSS.n1209 17.0005
R9855 VSS.n1219 VSS.n1209 17.0005
R9856 VSS.n1241 VSS.n1209 17.0005
R9857 VSS.n1217 VSS.n1209 17.0005
R9858 VSS.n4191 VSS.n1209 17.0005
R9859 VSS.n1216 VSS.n1209 17.0005
R9860 VSS.n1245 VSS.n1209 17.0005
R9861 VSS.n1215 VSS.n1209 17.0005
R9862 VSS.n1247 VSS.n1209 17.0005
R9863 VSS.n1214 VSS.n1209 17.0005
R9864 VSS.n1255 VSS.n1209 17.0005
R9865 VSS.n1212 VSS.n1209 17.0005
R9866 VSS.n4189 VSS.n1209 17.0005
R9867 VSS.n1229 VSS.n1196 17.0005
R9868 VSS.n1236 VSS.n1196 17.0005
R9869 VSS.n1235 VSS.n1196 17.0005
R9870 VSS.n1239 VSS.n1196 17.0005
R9871 VSS.n1220 VSS.n1196 17.0005
R9872 VSS.n1240 VSS.n1196 17.0005
R9873 VSS.n1219 VSS.n1196 17.0005
R9874 VSS.n1241 VSS.n1196 17.0005
R9875 VSS.n1217 VSS.n1196 17.0005
R9876 VSS.n4191 VSS.n1196 17.0005
R9877 VSS.n1216 VSS.n1196 17.0005
R9878 VSS.n1245 VSS.n1196 17.0005
R9879 VSS.n1215 VSS.n1196 17.0005
R9880 VSS.n1247 VSS.n1196 17.0005
R9881 VSS.n1246 VSS.n1196 17.0005
R9882 VSS.n1254 VSS.n1196 17.0005
R9883 VSS.n1253 VSS.n1196 17.0005
R9884 VSS.n4188 VSS.n1196 17.0005
R9885 VSS.n4105 VSS.n1210 17.0005
R9886 VSS.n1230 VSS.n1210 17.0005
R9887 VSS.n4107 VSS.n1210 17.0005
R9888 VSS.n1224 VSS.n1210 17.0005
R9889 VSS.n4055 VSS.n1210 17.0005
R9890 VSS.n1237 VSS.n1210 17.0005
R9891 VSS.n1223 VSS.n1210 17.0005
R9892 VSS.n1239 VSS.n1210 17.0005
R9893 VSS.n1220 VSS.n1210 17.0005
R9894 VSS.n1240 VSS.n1210 17.0005
R9895 VSS.n1219 VSS.n1210 17.0005
R9896 VSS.n1241 VSS.n1210 17.0005
R9897 VSS.n1217 VSS.n1210 17.0005
R9898 VSS.n4191 VSS.n1210 17.0005
R9899 VSS.n1216 VSS.n1210 17.0005
R9900 VSS.n1245 VSS.n1210 17.0005
R9901 VSS.n1215 VSS.n1210 17.0005
R9902 VSS.n1247 VSS.n1210 17.0005
R9903 VSS.n1214 VSS.n1210 17.0005
R9904 VSS.n1255 VSS.n1210 17.0005
R9905 VSS.n1212 VSS.n1210 17.0005
R9906 VSS.n4189 VSS.n1210 17.0005
R9907 VSS.n1229 VSS.n1195 17.0005
R9908 VSS.n1236 VSS.n1195 17.0005
R9909 VSS.n1235 VSS.n1195 17.0005
R9910 VSS.n1239 VSS.n1195 17.0005
R9911 VSS.n1220 VSS.n1195 17.0005
R9912 VSS.n1240 VSS.n1195 17.0005
R9913 VSS.n1219 VSS.n1195 17.0005
R9914 VSS.n1241 VSS.n1195 17.0005
R9915 VSS.n1217 VSS.n1195 17.0005
R9916 VSS.n4191 VSS.n1195 17.0005
R9917 VSS.n1216 VSS.n1195 17.0005
R9918 VSS.n1245 VSS.n1195 17.0005
R9919 VSS.n1215 VSS.n1195 17.0005
R9920 VSS.n1247 VSS.n1195 17.0005
R9921 VSS.n1246 VSS.n1195 17.0005
R9922 VSS.n1254 VSS.n1195 17.0005
R9923 VSS.n1253 VSS.n1195 17.0005
R9924 VSS.n4188 VSS.n1195 17.0005
R9925 VSS.n4120 VSS.n1211 17.0005
R9926 VSS.n1230 VSS.n1211 17.0005
R9927 VSS.n4118 VSS.n1211 17.0005
R9928 VSS.n1224 VSS.n1211 17.0005
R9929 VSS.n1758 VSS.n1211 17.0005
R9930 VSS.n1237 VSS.n1211 17.0005
R9931 VSS.n1223 VSS.n1211 17.0005
R9932 VSS.n1239 VSS.n1211 17.0005
R9933 VSS.n1220 VSS.n1211 17.0005
R9934 VSS.n1240 VSS.n1211 17.0005
R9935 VSS.n1219 VSS.n1211 17.0005
R9936 VSS.n1241 VSS.n1211 17.0005
R9937 VSS.n1217 VSS.n1211 17.0005
R9938 VSS.n4191 VSS.n1211 17.0005
R9939 VSS.n1216 VSS.n1211 17.0005
R9940 VSS.n1245 VSS.n1211 17.0005
R9941 VSS.n1215 VSS.n1211 17.0005
R9942 VSS.n1247 VSS.n1211 17.0005
R9943 VSS.n1214 VSS.n1211 17.0005
R9944 VSS.n1255 VSS.n1211 17.0005
R9945 VSS.n1212 VSS.n1211 17.0005
R9946 VSS.n4189 VSS.n1211 17.0005
R9947 VSS.n1229 VSS.n1194 17.0005
R9948 VSS.n1236 VSS.n1194 17.0005
R9949 VSS.n1235 VSS.n1194 17.0005
R9950 VSS.n1239 VSS.n1194 17.0005
R9951 VSS.n1220 VSS.n1194 17.0005
R9952 VSS.n1240 VSS.n1194 17.0005
R9953 VSS.n1219 VSS.n1194 17.0005
R9954 VSS.n1241 VSS.n1194 17.0005
R9955 VSS.n1217 VSS.n1194 17.0005
R9956 VSS.n4191 VSS.n1194 17.0005
R9957 VSS.n1216 VSS.n1194 17.0005
R9958 VSS.n1245 VSS.n1194 17.0005
R9959 VSS.n1215 VSS.n1194 17.0005
R9960 VSS.n1247 VSS.n1194 17.0005
R9961 VSS.n1246 VSS.n1194 17.0005
R9962 VSS.n1254 VSS.n1194 17.0005
R9963 VSS.n1253 VSS.n1194 17.0005
R9964 VSS.n4188 VSS.n1194 17.0005
R9965 VSS.n4190 VSS.n1228 17.0005
R9966 VSS.n4190 VSS.n1230 17.0005
R9967 VSS.n4190 VSS.n1225 17.0005
R9968 VSS.n4190 VSS.n1224 17.0005
R9969 VSS.n4190 VSS.n1234 17.0005
R9970 VSS.n4190 VSS.n1237 17.0005
R9971 VSS.n4190 VSS.n1223 17.0005
R9972 VSS.n4190 VSS.n1239 17.0005
R9973 VSS.n4190 VSS.n1220 17.0005
R9974 VSS.n4190 VSS.n1240 17.0005
R9975 VSS.n4190 VSS.n1219 17.0005
R9976 VSS.n4190 VSS.n1241 17.0005
R9977 VSS.n4190 VSS.n1217 17.0005
R9978 VSS.n4191 VSS.n4190 17.0005
R9979 VSS.n4190 VSS.n1216 17.0005
R9980 VSS.n4190 VSS.n1245 17.0005
R9981 VSS.n4190 VSS.n1215 17.0005
R9982 VSS.n4190 VSS.n1247 17.0005
R9983 VSS.n4190 VSS.n1214 17.0005
R9984 VSS.n4190 VSS.n1255 17.0005
R9985 VSS.n4190 VSS.n1212 17.0005
R9986 VSS.n4190 VSS.n4189 17.0005
R9987 VSS.t2958 VSS.n1467 17.0005
R9988 VSS.t2958 VSS.n1464 17.0005
R9989 VSS.n1482 VSS.t2958 17.0005
R9990 VSS.t2958 VSS.n1478 17.0005
R9991 VSS.t2958 VSS.n1460 17.0005
R9992 VSS.t2958 VSS.n1445 17.0005
R9993 VSS.t2958 VSS.n1444 17.0005
R9994 VSS.t2958 VSS.n1447 17.0005
R9995 VSS.t2958 VSS.n1451 17.0005
R9996 VSS.t2958 VSS.n1440 17.0005
R9997 VSS.t2958 VSS.n1452 17.0005
R9998 VSS.t2958 VSS.n1438 17.0005
R9999 VSS.t2958 VSS.n1455 17.0005
R10000 VSS.n4080 VSS.t2945 17.0005
R10001 VSS.n4081 VSS.t2945 17.0005
R10002 VSS.n4082 VSS.t2945 17.0005
R10003 VSS.n4085 VSS.t2945 17.0005
R10004 VSS.n4086 VSS.t2945 17.0005
R10005 VSS.n4087 VSS.t2945 17.0005
R10006 VSS.n4089 VSS.t2945 17.0005
R10007 VSS.n4090 VSS.t2945 17.0005
R10008 VSS.n1580 VSS.t1395 17.0005
R10009 VSS.n1581 VSS.t1395 17.0005
R10010 VSS.n1582 VSS.t1395 17.0005
R10011 VSS.n1585 VSS.t1395 17.0005
R10012 VSS.n1586 VSS.t1395 17.0005
R10013 VSS.n1587 VSS.t1395 17.0005
R10014 VSS.n1589 VSS.t1395 17.0005
R10015 VSS.n1590 VSS.t1395 17.0005
R10016 VSS.n1655 VSS.t1909 17.0005
R10017 VSS.n1656 VSS.t1909 17.0005
R10018 VSS.n1657 VSS.t1909 17.0005
R10019 VSS.n1660 VSS.t1909 17.0005
R10020 VSS.n1661 VSS.t1909 17.0005
R10021 VSS.n1662 VSS.t1909 17.0005
R10022 VSS.n1664 VSS.t1909 17.0005
R10023 VSS.n1665 VSS.t1909 17.0005
R10024 VSS.n1507 VSS.t1648 17.0005
R10025 VSS.n1508 VSS.t1648 17.0005
R10026 VSS.n1509 VSS.t1648 17.0005
R10027 VSS.n1512 VSS.t1648 17.0005
R10028 VSS.n1513 VSS.t1648 17.0005
R10029 VSS.n1514 VSS.t1648 17.0005
R10030 VSS.n1516 VSS.t1648 17.0005
R10031 VSS.n1517 VSS.t1648 17.0005
R10032 VSS.n1414 VSS.t74 17.0005
R10033 VSS.n1415 VSS.t74 17.0005
R10034 VSS.n1416 VSS.t74 17.0005
R10035 VSS.n1419 VSS.t74 17.0005
R10036 VSS.n1420 VSS.t74 17.0005
R10037 VSS.n1421 VSS.t74 17.0005
R10038 VSS.n1423 VSS.t74 17.0005
R10039 VSS.n1424 VSS.t74 17.0005
R10040 VSS.n1722 VSS.t2295 17.0005
R10041 VSS.n1723 VSS.t2295 17.0005
R10042 VSS.n1724 VSS.t2295 17.0005
R10043 VSS.n1727 VSS.t2295 17.0005
R10044 VSS.n1728 VSS.t2295 17.0005
R10045 VSS.n1729 VSS.t2295 17.0005
R10046 VSS.n1731 VSS.t2295 17.0005
R10047 VSS.n1732 VSS.t2295 17.0005
R10048 VSS.n807 VSS.n796 17.0005
R10049 VSS.n807 VSS.n797 17.0005
R10050 VSS.n807 VSS.n795 17.0005
R10051 VSS.n807 VSS.n759 17.0005
R10052 VSS.n807 VSS.n750 17.0005
R10053 VSS.n807 VSS.n760 17.0005
R10054 VSS.n807 VSS.n749 17.0005
R10055 VSS.n807 VSS.n761 17.0005
R10056 VSS.n807 VSS.n747 17.0005
R10057 VSS.n807 VSS.n762 17.0005
R10058 VSS.n807 VSS.n746 17.0005
R10059 VSS.n807 VSS.n766 17.0005
R10060 VSS.n807 VSS.n794 17.0005
R10061 VSS.n5602 VSS.n807 17.0005
R10062 VSS.n807 VSS.n793 17.0005
R10063 VSS.n807 VSS.n776 17.0005
R10064 VSS.n5459 VSS.n778 17.0005
R10065 VSS.n778 VSS.n757 17.0005
R10066 VSS.n5457 VSS.n778 17.0005
R10067 VSS.n778 VSS.n755 17.0005
R10068 VSS.n1119 VSS.n778 17.0005
R10069 VSS.n778 VSS.n758 17.0005
R10070 VSS.n778 VSS.n750 17.0005
R10071 VSS.n778 VSS.n760 17.0005
R10072 VSS.n778 VSS.n749 17.0005
R10073 VSS.n778 VSS.n761 17.0005
R10074 VSS.n778 VSS.n747 17.0005
R10075 VSS.n778 VSS.n762 17.0005
R10076 VSS.n778 VSS.n746 17.0005
R10077 VSS.n778 VSS.n765 17.0005
R10078 VSS.n778 VSS.n745 17.0005
R10079 VSS.n778 VSS.n766 17.0005
R10080 VSS.n778 VSS.n744 17.0005
R10081 VSS.n778 VSS.n772 17.0005
R10082 VSS.n778 VSS.n742 17.0005
R10083 VSS.n5621 VSS.n778 17.0005
R10084 VSS.n805 VSS.n796 17.0005
R10085 VSS.n805 VSS.n797 17.0005
R10086 VSS.n805 VSS.n795 17.0005
R10087 VSS.n805 VSS.n759 17.0005
R10088 VSS.n805 VSS.n750 17.0005
R10089 VSS.n805 VSS.n760 17.0005
R10090 VSS.n805 VSS.n749 17.0005
R10091 VSS.n805 VSS.n761 17.0005
R10092 VSS.n805 VSS.n747 17.0005
R10093 VSS.n805 VSS.n762 17.0005
R10094 VSS.n805 VSS.n746 17.0005
R10095 VSS.n805 VSS.n765 17.0005
R10096 VSS.n805 VSS.n745 17.0005
R10097 VSS.n805 VSS.n766 17.0005
R10098 VSS.n805 VSS.n794 17.0005
R10099 VSS.n5602 VSS.n805 17.0005
R10100 VSS.n805 VSS.n793 17.0005
R10101 VSS.n805 VSS.n776 17.0005
R10102 VSS.n5622 VSS.n756 17.0005
R10103 VSS.n5622 VSS.n757 17.0005
R10104 VSS.n5623 VSS.n5622 17.0005
R10105 VSS.n5622 VSS.n755 17.0005
R10106 VSS.n5622 VSS.n739 17.0005
R10107 VSS.n5622 VSS.n758 17.0005
R10108 VSS.n5622 VSS.n754 17.0005
R10109 VSS.n5622 VSS.n759 17.0005
R10110 VSS.n5622 VSS.n750 17.0005
R10111 VSS.n5622 VSS.n760 17.0005
R10112 VSS.n5622 VSS.n749 17.0005
R10113 VSS.n5622 VSS.n761 17.0005
R10114 VSS.n5622 VSS.n747 17.0005
R10115 VSS.n5622 VSS.n762 17.0005
R10116 VSS.n5622 VSS.n746 17.0005
R10117 VSS.n5622 VSS.n765 17.0005
R10118 VSS.n5622 VSS.n745 17.0005
R10119 VSS.n5622 VSS.n766 17.0005
R10120 VSS.n5622 VSS.n744 17.0005
R10121 VSS.n5622 VSS.n772 17.0005
R10122 VSS.n5622 VSS.n742 17.0005
R10123 VSS.n5622 VSS.n5621 17.0005
R10124 VSS.n813 VSS.n796 17.0005
R10125 VSS.n813 VSS.n797 17.0005
R10126 VSS.n813 VSS.n795 17.0005
R10127 VSS.n813 VSS.n759 17.0005
R10128 VSS.n813 VSS.n750 17.0005
R10129 VSS.n813 VSS.n760 17.0005
R10130 VSS.n813 VSS.n749 17.0005
R10131 VSS.n813 VSS.n761 17.0005
R10132 VSS.n813 VSS.n747 17.0005
R10133 VSS.n813 VSS.n762 17.0005
R10134 VSS.n813 VSS.n746 17.0005
R10135 VSS.n813 VSS.n765 17.0005
R10136 VSS.n813 VSS.n745 17.0005
R10137 VSS.n813 VSS.n766 17.0005
R10138 VSS.n813 VSS.n794 17.0005
R10139 VSS.n5602 VSS.n813 17.0005
R10140 VSS.n813 VSS.n793 17.0005
R10141 VSS.n813 VSS.n776 17.0005
R10142 VSS.n1057 VSS.n779 17.0005
R10143 VSS.n779 VSS.n757 17.0005
R10144 VSS.n1055 VSS.n779 17.0005
R10145 VSS.n779 VSS.n755 17.0005
R10146 VSS.n1051 VSS.n779 17.0005
R10147 VSS.n779 VSS.n758 17.0005
R10148 VSS.n779 VSS.n754 17.0005
R10149 VSS.n779 VSS.n759 17.0005
R10150 VSS.n779 VSS.n750 17.0005
R10151 VSS.n779 VSS.n760 17.0005
R10152 VSS.n779 VSS.n749 17.0005
R10153 VSS.n779 VSS.n761 17.0005
R10154 VSS.n779 VSS.n747 17.0005
R10155 VSS.n779 VSS.n762 17.0005
R10156 VSS.n779 VSS.n746 17.0005
R10157 VSS.n779 VSS.n765 17.0005
R10158 VSS.n779 VSS.n745 17.0005
R10159 VSS.n779 VSS.n766 17.0005
R10160 VSS.n779 VSS.n744 17.0005
R10161 VSS.n779 VSS.n772 17.0005
R10162 VSS.n779 VSS.n742 17.0005
R10163 VSS.n5621 VSS.n779 17.0005
R10164 VSS.n799 VSS.n796 17.0005
R10165 VSS.n799 VSS.n797 17.0005
R10166 VSS.n799 VSS.n795 17.0005
R10167 VSS.n799 VSS.n759 17.0005
R10168 VSS.n799 VSS.n750 17.0005
R10169 VSS.n799 VSS.n760 17.0005
R10170 VSS.n799 VSS.n749 17.0005
R10171 VSS.n799 VSS.n761 17.0005
R10172 VSS.n799 VSS.n747 17.0005
R10173 VSS.n799 VSS.n762 17.0005
R10174 VSS.n799 VSS.n746 17.0005
R10175 VSS.n799 VSS.n765 17.0005
R10176 VSS.n799 VSS.n745 17.0005
R10177 VSS.n799 VSS.n766 17.0005
R10178 VSS.n799 VSS.n794 17.0005
R10179 VSS.n5602 VSS.n799 17.0005
R10180 VSS.n799 VSS.n793 17.0005
R10181 VSS.n799 VSS.n776 17.0005
R10182 VSS.n5590 VSS.n775 17.0005
R10183 VSS.n775 VSS.n757 17.0005
R10184 VSS.n5592 VSS.n775 17.0005
R10185 VSS.n775 VSS.n755 17.0005
R10186 VSS.n833 VSS.n775 17.0005
R10187 VSS.n775 VSS.n758 17.0005
R10188 VSS.n775 VSS.n754 17.0005
R10189 VSS.n775 VSS.n759 17.0005
R10190 VSS.n775 VSS.n750 17.0005
R10191 VSS.n775 VSS.n760 17.0005
R10192 VSS.n775 VSS.n749 17.0005
R10193 VSS.n775 VSS.n761 17.0005
R10194 VSS.n775 VSS.n747 17.0005
R10195 VSS.n775 VSS.n762 17.0005
R10196 VSS.n775 VSS.n746 17.0005
R10197 VSS.n775 VSS.n765 17.0005
R10198 VSS.n775 VSS.n745 17.0005
R10199 VSS.n775 VSS.n766 17.0005
R10200 VSS.n775 VSS.n744 17.0005
R10201 VSS.n775 VSS.n772 17.0005
R10202 VSS.n775 VSS.n742 17.0005
R10203 VSS.n5621 VSS.n775 17.0005
R10204 VSS.n5601 VSS.n796 17.0005
R10205 VSS.n5601 VSS.n797 17.0005
R10206 VSS.n5601 VSS.n795 17.0005
R10207 VSS.n5601 VSS.n759 17.0005
R10208 VSS.n5601 VSS.n750 17.0005
R10209 VSS.n5601 VSS.n760 17.0005
R10210 VSS.n5601 VSS.n749 17.0005
R10211 VSS.n5601 VSS.n761 17.0005
R10212 VSS.n5601 VSS.n747 17.0005
R10213 VSS.n5601 VSS.n762 17.0005
R10214 VSS.n5601 VSS.n746 17.0005
R10215 VSS.n5601 VSS.n765 17.0005
R10216 VSS.n5601 VSS.n745 17.0005
R10217 VSS.n5601 VSS.n766 17.0005
R10218 VSS.n5601 VSS.n794 17.0005
R10219 VSS.n5602 VSS.n5601 17.0005
R10220 VSS.n5601 VSS.n793 17.0005
R10221 VSS.n5601 VSS.n776 17.0005
R10222 VSS.n989 VSS.n780 17.0005
R10223 VSS.n780 VSS.n757 17.0005
R10224 VSS.n987 VSS.n780 17.0005
R10225 VSS.n780 VSS.n755 17.0005
R10226 VSS.n984 VSS.n780 17.0005
R10227 VSS.n780 VSS.n758 17.0005
R10228 VSS.n780 VSS.n754 17.0005
R10229 VSS.n780 VSS.n759 17.0005
R10230 VSS.n780 VSS.n750 17.0005
R10231 VSS.n780 VSS.n760 17.0005
R10232 VSS.n780 VSS.n749 17.0005
R10233 VSS.n780 VSS.n761 17.0005
R10234 VSS.n780 VSS.n747 17.0005
R10235 VSS.n780 VSS.n762 17.0005
R10236 VSS.n780 VSS.n746 17.0005
R10237 VSS.n780 VSS.n765 17.0005
R10238 VSS.n780 VSS.n745 17.0005
R10239 VSS.n780 VSS.n766 17.0005
R10240 VSS.n780 VSS.n744 17.0005
R10241 VSS.n780 VSS.n772 17.0005
R10242 VSS.n780 VSS.n742 17.0005
R10243 VSS.n5621 VSS.n780 17.0005
R10244 VSS.n798 VSS.n796 17.0005
R10245 VSS.n798 VSS.n797 17.0005
R10246 VSS.n798 VSS.n795 17.0005
R10247 VSS.n798 VSS.n759 17.0005
R10248 VSS.n798 VSS.n750 17.0005
R10249 VSS.n798 VSS.n760 17.0005
R10250 VSS.n798 VSS.n749 17.0005
R10251 VSS.n798 VSS.n761 17.0005
R10252 VSS.n798 VSS.n747 17.0005
R10253 VSS.n798 VSS.n762 17.0005
R10254 VSS.n798 VSS.n746 17.0005
R10255 VSS.n798 VSS.n765 17.0005
R10256 VSS.n798 VSS.n745 17.0005
R10257 VSS.n798 VSS.n766 17.0005
R10258 VSS.n798 VSS.n794 17.0005
R10259 VSS.n5602 VSS.n798 17.0005
R10260 VSS.n798 VSS.n793 17.0005
R10261 VSS.n798 VSS.n776 17.0005
R10262 VSS.n5581 VSS.n774 17.0005
R10263 VSS.n774 VSS.n757 17.0005
R10264 VSS.n5579 VSS.n774 17.0005
R10265 VSS.n774 VSS.n755 17.0005
R10266 VSS.n5569 VSS.n774 17.0005
R10267 VSS.n774 VSS.n758 17.0005
R10268 VSS.n774 VSS.n754 17.0005
R10269 VSS.n774 VSS.n759 17.0005
R10270 VSS.n774 VSS.n750 17.0005
R10271 VSS.n774 VSS.n760 17.0005
R10272 VSS.n774 VSS.n749 17.0005
R10273 VSS.n774 VSS.n761 17.0005
R10274 VSS.n774 VSS.n747 17.0005
R10275 VSS.n774 VSS.n762 17.0005
R10276 VSS.n774 VSS.n746 17.0005
R10277 VSS.n774 VSS.n765 17.0005
R10278 VSS.n774 VSS.n745 17.0005
R10279 VSS.n774 VSS.n766 17.0005
R10280 VSS.n774 VSS.n744 17.0005
R10281 VSS.n774 VSS.n772 17.0005
R10282 VSS.n774 VSS.n742 17.0005
R10283 VSS.n5621 VSS.n774 17.0005
R10284 VSS.n5603 VSS.n796 17.0005
R10285 VSS.n5603 VSS.n797 17.0005
R10286 VSS.n5603 VSS.n795 17.0005
R10287 VSS.n5603 VSS.n759 17.0005
R10288 VSS.n5603 VSS.n750 17.0005
R10289 VSS.n5603 VSS.n760 17.0005
R10290 VSS.n5603 VSS.n749 17.0005
R10291 VSS.n5603 VSS.n761 17.0005
R10292 VSS.n5603 VSS.n747 17.0005
R10293 VSS.n5603 VSS.n762 17.0005
R10294 VSS.n5603 VSS.n746 17.0005
R10295 VSS.n5603 VSS.n765 17.0005
R10296 VSS.n5603 VSS.n745 17.0005
R10297 VSS.n5603 VSS.n766 17.0005
R10298 VSS.n5603 VSS.n794 17.0005
R10299 VSS.n5603 VSS.n5602 17.0005
R10300 VSS.n5603 VSS.n793 17.0005
R10301 VSS.n5603 VSS.n776 17.0005
R10302 VSS.n5620 VSS.n788 17.0005
R10303 VSS.n5620 VSS.n757 17.0005
R10304 VSS.n5620 VSS.n785 17.0005
R10305 VSS.n5620 VSS.n755 17.0005
R10306 VSS.n5620 VSS.n5612 17.0005
R10307 VSS.n5620 VSS.n758 17.0005
R10308 VSS.n5620 VSS.n754 17.0005
R10309 VSS.n5620 VSS.n759 17.0005
R10310 VSS.n5620 VSS.n750 17.0005
R10311 VSS.n5620 VSS.n760 17.0005
R10312 VSS.n5620 VSS.n749 17.0005
R10313 VSS.n5620 VSS.n761 17.0005
R10314 VSS.n5620 VSS.n747 17.0005
R10315 VSS.n5620 VSS.n762 17.0005
R10316 VSS.n5620 VSS.n746 17.0005
R10317 VSS.n5620 VSS.n765 17.0005
R10318 VSS.n5620 VSS.n745 17.0005
R10319 VSS.n5620 VSS.n766 17.0005
R10320 VSS.n5620 VSS.n744 17.0005
R10321 VSS.n5620 VSS.n772 17.0005
R10322 VSS.n5620 VSS.n742 17.0005
R10323 VSS.n5621 VSS.n5620 17.0005
R10324 VSS.t3118 VSS.n911 17.0005
R10325 VSS.t3118 VSS.n908 17.0005
R10326 VSS.n926 VSS.t3118 17.0005
R10327 VSS.t3118 VSS.n922 17.0005
R10328 VSS.t3118 VSS.n904 17.0005
R10329 VSS.t3118 VSS.n889 17.0005
R10330 VSS.t3118 VSS.n888 17.0005
R10331 VSS.t3118 VSS.n891 17.0005
R10332 VSS.t3118 VSS.n895 17.0005
R10333 VSS.t3118 VSS.n884 17.0005
R10334 VSS.t3118 VSS.n896 17.0005
R10335 VSS.t3118 VSS.n882 17.0005
R10336 VSS.t3118 VSS.n899 17.0005
R10337 VSS.n948 VSS.t3457 17.0005
R10338 VSS.n949 VSS.t3457 17.0005
R10339 VSS.n950 VSS.t3457 17.0005
R10340 VSS.n953 VSS.t3457 17.0005
R10341 VSS.n954 VSS.t3457 17.0005
R10342 VSS.n955 VSS.t3457 17.0005
R10343 VSS.n957 VSS.t3457 17.0005
R10344 VSS.n958 VSS.t3457 17.0005
R10345 VSS.n1015 VSS.t1367 17.0005
R10346 VSS.n1016 VSS.t1367 17.0005
R10347 VSS.n1017 VSS.t1367 17.0005
R10348 VSS.n1020 VSS.t1367 17.0005
R10349 VSS.n1021 VSS.t1367 17.0005
R10350 VSS.n1022 VSS.t1367 17.0005
R10351 VSS.n1024 VSS.t1367 17.0005
R10352 VSS.n1025 VSS.t1367 17.0005
R10353 VSS.n1083 VSS.t1881 17.0005
R10354 VSS.n1084 VSS.t1881 17.0005
R10355 VSS.n1085 VSS.t1881 17.0005
R10356 VSS.n1088 VSS.t1881 17.0005
R10357 VSS.n1089 VSS.t1881 17.0005
R10358 VSS.n1090 VSS.t1881 17.0005
R10359 VSS.n1092 VSS.t1881 17.0005
R10360 VSS.n1093 VSS.t1881 17.0005
R10361 VSS.n5485 VSS.t1622 17.0005
R10362 VSS.n5486 VSS.t1622 17.0005
R10363 VSS.n5487 VSS.t1622 17.0005
R10364 VSS.n5490 VSS.t1622 17.0005
R10365 VSS.n5491 VSS.t1622 17.0005
R10366 VSS.n5492 VSS.t1622 17.0005
R10367 VSS.n5494 VSS.t1622 17.0005
R10368 VSS.n5495 VSS.t1622 17.0005
R10369 VSS.n858 VSS.t46 17.0005
R10370 VSS.n859 VSS.t46 17.0005
R10371 VSS.n860 VSS.t46 17.0005
R10372 VSS.n863 VSS.t46 17.0005
R10373 VSS.n864 VSS.t46 17.0005
R10374 VSS.n865 VSS.t46 17.0005
R10375 VSS.n867 VSS.t46 17.0005
R10376 VSS.n868 VSS.t46 17.0005
R10377 VSS.n5533 VSS.t3645 17.0005
R10378 VSS.n5534 VSS.t3645 17.0005
R10379 VSS.n5535 VSS.t3645 17.0005
R10380 VSS.n5538 VSS.t3645 17.0005
R10381 VSS.n5539 VSS.t3645 17.0005
R10382 VSS.n5540 VSS.t3645 17.0005
R10383 VSS.n5542 VSS.t3645 17.0005
R10384 VSS.n5543 VSS.t3645 17.0005
R10385 VSS.n733 VSS.n722 17.0005
R10386 VSS.n733 VSS.n723 17.0005
R10387 VSS.n733 VSS.n721 17.0005
R10388 VSS.n733 VSS.n686 17.0005
R10389 VSS.n733 VSS.n676 17.0005
R10390 VSS.n733 VSS.n687 17.0005
R10391 VSS.n733 VSS.n675 17.0005
R10392 VSS.n733 VSS.n688 17.0005
R10393 VSS.n733 VSS.n673 17.0005
R10394 VSS.n733 VSS.n689 17.0005
R10395 VSS.n733 VSS.n672 17.0005
R10396 VSS.n733 VSS.n693 17.0005
R10397 VSS.n733 VSS.n720 17.0005
R10398 VSS.n5811 VSS.n733 17.0005
R10399 VSS.n733 VSS.n719 17.0005
R10400 VSS.n733 VSS.n703 17.0005
R10401 VSS.n5331 VSS.n705 17.0005
R10402 VSS.n705 VSS.n682 17.0005
R10403 VSS.n5333 VSS.n705 17.0005
R10404 VSS.n705 VSS.n680 17.0005
R10405 VSS.n4909 VSS.n705 17.0005
R10406 VSS.n705 VSS.n685 17.0005
R10407 VSS.n705 VSS.n676 17.0005
R10408 VSS.n705 VSS.n687 17.0005
R10409 VSS.n705 VSS.n675 17.0005
R10410 VSS.n705 VSS.n688 17.0005
R10411 VSS.n705 VSS.n673 17.0005
R10412 VSS.n705 VSS.n689 17.0005
R10413 VSS.n705 VSS.n672 17.0005
R10414 VSS.n705 VSS.n692 17.0005
R10415 VSS.n705 VSS.n671 17.0005
R10416 VSS.n705 VSS.n693 17.0005
R10417 VSS.n705 VSS.n670 17.0005
R10418 VSS.n705 VSS.n699 17.0005
R10419 VSS.n705 VSS.n668 17.0005
R10420 VSS.n5831 VSS.n705 17.0005
R10421 VSS.n731 VSS.n722 17.0005
R10422 VSS.n731 VSS.n723 17.0005
R10423 VSS.n731 VSS.n721 17.0005
R10424 VSS.n731 VSS.n686 17.0005
R10425 VSS.n731 VSS.n676 17.0005
R10426 VSS.n731 VSS.n687 17.0005
R10427 VSS.n731 VSS.n675 17.0005
R10428 VSS.n731 VSS.n688 17.0005
R10429 VSS.n731 VSS.n673 17.0005
R10430 VSS.n731 VSS.n689 17.0005
R10431 VSS.n731 VSS.n672 17.0005
R10432 VSS.n731 VSS.n692 17.0005
R10433 VSS.n731 VSS.n671 17.0005
R10434 VSS.n731 VSS.n693 17.0005
R10435 VSS.n731 VSS.n720 17.0005
R10436 VSS.n5811 VSS.n731 17.0005
R10437 VSS.n731 VSS.n719 17.0005
R10438 VSS.n731 VSS.n703 17.0005
R10439 VSS.n5133 VSS.n702 17.0005
R10440 VSS.n702 VSS.n682 17.0005
R10441 VSS.n5131 VSS.n702 17.0005
R10442 VSS.n702 VSS.n680 17.0005
R10443 VSS.n5128 VSS.n702 17.0005
R10444 VSS.n702 VSS.n685 17.0005
R10445 VSS.n702 VSS.n679 17.0005
R10446 VSS.n702 VSS.n686 17.0005
R10447 VSS.n702 VSS.n676 17.0005
R10448 VSS.n702 VSS.n687 17.0005
R10449 VSS.n702 VSS.n675 17.0005
R10450 VSS.n702 VSS.n688 17.0005
R10451 VSS.n702 VSS.n673 17.0005
R10452 VSS.n702 VSS.n689 17.0005
R10453 VSS.n702 VSS.n672 17.0005
R10454 VSS.n702 VSS.n692 17.0005
R10455 VSS.n702 VSS.n671 17.0005
R10456 VSS.n702 VSS.n693 17.0005
R10457 VSS.n702 VSS.n670 17.0005
R10458 VSS.n702 VSS.n699 17.0005
R10459 VSS.n702 VSS.n668 17.0005
R10460 VSS.n5831 VSS.n702 17.0005
R10461 VSS.n5804 VSS.n722 17.0005
R10462 VSS.n5804 VSS.n723 17.0005
R10463 VSS.n5804 VSS.n721 17.0005
R10464 VSS.n5804 VSS.n686 17.0005
R10465 VSS.n5804 VSS.n676 17.0005
R10466 VSS.n5804 VSS.n687 17.0005
R10467 VSS.n5804 VSS.n675 17.0005
R10468 VSS.n5804 VSS.n688 17.0005
R10469 VSS.n5804 VSS.n673 17.0005
R10470 VSS.n5804 VSS.n689 17.0005
R10471 VSS.n5804 VSS.n672 17.0005
R10472 VSS.n5804 VSS.n692 17.0005
R10473 VSS.n5804 VSS.n671 17.0005
R10474 VSS.n5804 VSS.n693 17.0005
R10475 VSS.n5804 VSS.n720 17.0005
R10476 VSS.n5811 VSS.n5804 17.0005
R10477 VSS.n5804 VSS.n719 17.0005
R10478 VSS.n5804 VSS.n703 17.0005
R10479 VSS.n5066 VSS.n706 17.0005
R10480 VSS.n706 VSS.n682 17.0005
R10481 VSS.n5064 VSS.n706 17.0005
R10482 VSS.n706 VSS.n680 17.0005
R10483 VSS.n5061 VSS.n706 17.0005
R10484 VSS.n706 VSS.n685 17.0005
R10485 VSS.n706 VSS.n679 17.0005
R10486 VSS.n706 VSS.n686 17.0005
R10487 VSS.n706 VSS.n676 17.0005
R10488 VSS.n706 VSS.n687 17.0005
R10489 VSS.n706 VSS.n675 17.0005
R10490 VSS.n706 VSS.n688 17.0005
R10491 VSS.n706 VSS.n673 17.0005
R10492 VSS.n706 VSS.n689 17.0005
R10493 VSS.n706 VSS.n672 17.0005
R10494 VSS.n706 VSS.n692 17.0005
R10495 VSS.n706 VSS.n671 17.0005
R10496 VSS.n706 VSS.n693 17.0005
R10497 VSS.n706 VSS.n670 17.0005
R10498 VSS.n706 VSS.n699 17.0005
R10499 VSS.n706 VSS.n668 17.0005
R10500 VSS.n5831 VSS.n706 17.0005
R10501 VSS.n730 VSS.n722 17.0005
R10502 VSS.n730 VSS.n723 17.0005
R10503 VSS.n730 VSS.n721 17.0005
R10504 VSS.n730 VSS.n686 17.0005
R10505 VSS.n730 VSS.n676 17.0005
R10506 VSS.n730 VSS.n687 17.0005
R10507 VSS.n730 VSS.n675 17.0005
R10508 VSS.n730 VSS.n688 17.0005
R10509 VSS.n730 VSS.n673 17.0005
R10510 VSS.n730 VSS.n689 17.0005
R10511 VSS.n730 VSS.n672 17.0005
R10512 VSS.n730 VSS.n692 17.0005
R10513 VSS.n730 VSS.n671 17.0005
R10514 VSS.n730 VSS.n693 17.0005
R10515 VSS.n730 VSS.n720 17.0005
R10516 VSS.n5811 VSS.n730 17.0005
R10517 VSS.n730 VSS.n719 17.0005
R10518 VSS.n730 VSS.n703 17.0005
R10519 VSS.n5832 VSS.n681 17.0005
R10520 VSS.n5832 VSS.n682 17.0005
R10521 VSS.n5833 VSS.n5832 17.0005
R10522 VSS.n5832 VSS.n680 17.0005
R10523 VSS.n5832 VSS.n684 17.0005
R10524 VSS.n5832 VSS.n685 17.0005
R10525 VSS.n5832 VSS.n679 17.0005
R10526 VSS.n5832 VSS.n686 17.0005
R10527 VSS.n5832 VSS.n676 17.0005
R10528 VSS.n5832 VSS.n687 17.0005
R10529 VSS.n5832 VSS.n675 17.0005
R10530 VSS.n5832 VSS.n688 17.0005
R10531 VSS.n5832 VSS.n673 17.0005
R10532 VSS.n5832 VSS.n689 17.0005
R10533 VSS.n5832 VSS.n672 17.0005
R10534 VSS.n5832 VSS.n692 17.0005
R10535 VSS.n5832 VSS.n671 17.0005
R10536 VSS.n5832 VSS.n693 17.0005
R10537 VSS.n5832 VSS.n670 17.0005
R10538 VSS.n5832 VSS.n699 17.0005
R10539 VSS.n5832 VSS.n668 17.0005
R10540 VSS.n5832 VSS.n5831 17.0005
R10541 VSS.n5810 VSS.n722 17.0005
R10542 VSS.n5810 VSS.n723 17.0005
R10543 VSS.n5810 VSS.n721 17.0005
R10544 VSS.n5810 VSS.n686 17.0005
R10545 VSS.n5810 VSS.n676 17.0005
R10546 VSS.n5810 VSS.n687 17.0005
R10547 VSS.n5810 VSS.n675 17.0005
R10548 VSS.n5810 VSS.n688 17.0005
R10549 VSS.n5810 VSS.n673 17.0005
R10550 VSS.n5810 VSS.n689 17.0005
R10551 VSS.n5810 VSS.n672 17.0005
R10552 VSS.n5810 VSS.n692 17.0005
R10553 VSS.n5810 VSS.n671 17.0005
R10554 VSS.n5810 VSS.n693 17.0005
R10555 VSS.n5810 VSS.n720 17.0005
R10556 VSS.n5811 VSS.n5810 17.0005
R10557 VSS.n5810 VSS.n719 17.0005
R10558 VSS.n5810 VSS.n703 17.0005
R10559 VSS.n5306 VSS.n707 17.0005
R10560 VSS.n707 VSS.n682 17.0005
R10561 VSS.n5308 VSS.n707 17.0005
R10562 VSS.n707 VSS.n680 17.0005
R10563 VSS.n5257 VSS.n707 17.0005
R10564 VSS.n707 VSS.n685 17.0005
R10565 VSS.n707 VSS.n679 17.0005
R10566 VSS.n707 VSS.n686 17.0005
R10567 VSS.n707 VSS.n676 17.0005
R10568 VSS.n707 VSS.n687 17.0005
R10569 VSS.n707 VSS.n675 17.0005
R10570 VSS.n707 VSS.n688 17.0005
R10571 VSS.n707 VSS.n673 17.0005
R10572 VSS.n707 VSS.n689 17.0005
R10573 VSS.n707 VSS.n672 17.0005
R10574 VSS.n707 VSS.n692 17.0005
R10575 VSS.n707 VSS.n671 17.0005
R10576 VSS.n707 VSS.n693 17.0005
R10577 VSS.n707 VSS.n670 17.0005
R10578 VSS.n707 VSS.n699 17.0005
R10579 VSS.n707 VSS.n668 17.0005
R10580 VSS.n5831 VSS.n707 17.0005
R10581 VSS.n724 VSS.n722 17.0005
R10582 VSS.n724 VSS.n723 17.0005
R10583 VSS.n724 VSS.n721 17.0005
R10584 VSS.n724 VSS.n686 17.0005
R10585 VSS.n724 VSS.n676 17.0005
R10586 VSS.n724 VSS.n687 17.0005
R10587 VSS.n724 VSS.n675 17.0005
R10588 VSS.n724 VSS.n688 17.0005
R10589 VSS.n724 VSS.n673 17.0005
R10590 VSS.n724 VSS.n689 17.0005
R10591 VSS.n724 VSS.n672 17.0005
R10592 VSS.n724 VSS.n692 17.0005
R10593 VSS.n724 VSS.n671 17.0005
R10594 VSS.n724 VSS.n693 17.0005
R10595 VSS.n724 VSS.n720 17.0005
R10596 VSS.n5811 VSS.n724 17.0005
R10597 VSS.n724 VSS.n719 17.0005
R10598 VSS.n724 VSS.n703 17.0005
R10599 VSS.n5322 VSS.n701 17.0005
R10600 VSS.n701 VSS.n682 17.0005
R10601 VSS.n5320 VSS.n701 17.0005
R10602 VSS.n701 VSS.n680 17.0005
R10603 VSS.n5243 VSS.n701 17.0005
R10604 VSS.n701 VSS.n685 17.0005
R10605 VSS.n701 VSS.n679 17.0005
R10606 VSS.n701 VSS.n686 17.0005
R10607 VSS.n701 VSS.n676 17.0005
R10608 VSS.n701 VSS.n687 17.0005
R10609 VSS.n701 VSS.n675 17.0005
R10610 VSS.n701 VSS.n688 17.0005
R10611 VSS.n701 VSS.n673 17.0005
R10612 VSS.n701 VSS.n689 17.0005
R10613 VSS.n701 VSS.n672 17.0005
R10614 VSS.n701 VSS.n692 17.0005
R10615 VSS.n701 VSS.n671 17.0005
R10616 VSS.n701 VSS.n693 17.0005
R10617 VSS.n701 VSS.n670 17.0005
R10618 VSS.n701 VSS.n699 17.0005
R10619 VSS.n701 VSS.n668 17.0005
R10620 VSS.n5831 VSS.n701 17.0005
R10621 VSS.n5812 VSS.n722 17.0005
R10622 VSS.n5812 VSS.n723 17.0005
R10623 VSS.n5812 VSS.n721 17.0005
R10624 VSS.n5812 VSS.n686 17.0005
R10625 VSS.n5812 VSS.n676 17.0005
R10626 VSS.n5812 VSS.n687 17.0005
R10627 VSS.n5812 VSS.n675 17.0005
R10628 VSS.n5812 VSS.n688 17.0005
R10629 VSS.n5812 VSS.n673 17.0005
R10630 VSS.n5812 VSS.n689 17.0005
R10631 VSS.n5812 VSS.n672 17.0005
R10632 VSS.n5812 VSS.n692 17.0005
R10633 VSS.n5812 VSS.n671 17.0005
R10634 VSS.n5812 VSS.n693 17.0005
R10635 VSS.n5812 VSS.n720 17.0005
R10636 VSS.n5812 VSS.n5811 17.0005
R10637 VSS.n5812 VSS.n719 17.0005
R10638 VSS.n5812 VSS.n703 17.0005
R10639 VSS.n5830 VSS.n715 17.0005
R10640 VSS.n5830 VSS.n682 17.0005
R10641 VSS.n5830 VSS.n712 17.0005
R10642 VSS.n5830 VSS.n680 17.0005
R10643 VSS.n5830 VSS.n5822 17.0005
R10644 VSS.n5830 VSS.n685 17.0005
R10645 VSS.n5830 VSS.n679 17.0005
R10646 VSS.n5830 VSS.n686 17.0005
R10647 VSS.n5830 VSS.n676 17.0005
R10648 VSS.n5830 VSS.n687 17.0005
R10649 VSS.n5830 VSS.n675 17.0005
R10650 VSS.n5830 VSS.n688 17.0005
R10651 VSS.n5830 VSS.n673 17.0005
R10652 VSS.n5830 VSS.n689 17.0005
R10653 VSS.n5830 VSS.n672 17.0005
R10654 VSS.n5830 VSS.n692 17.0005
R10655 VSS.n5830 VSS.n671 17.0005
R10656 VSS.n5830 VSS.n693 17.0005
R10657 VSS.n5830 VSS.n670 17.0005
R10658 VSS.n5830 VSS.n699 17.0005
R10659 VSS.n5830 VSS.n668 17.0005
R10660 VSS.n5831 VSS.n5830 17.0005
R10661 VSS.t2612 VSS.n4987 17.0005
R10662 VSS.t2612 VSS.n4984 17.0005
R10663 VSS.n5002 VSS.t2612 17.0005
R10664 VSS.t2612 VSS.n4998 17.0005
R10665 VSS.t2612 VSS.n4980 17.0005
R10666 VSS.t2612 VSS.n4965 17.0005
R10667 VSS.t2612 VSS.n4964 17.0005
R10668 VSS.t2612 VSS.n4967 17.0005
R10669 VSS.t2612 VSS.n4971 17.0005
R10670 VSS.t2612 VSS.n4960 17.0005
R10671 VSS.t2612 VSS.n4972 17.0005
R10672 VSS.t2612 VSS.n4958 17.0005
R10673 VSS.t2612 VSS.n4975 17.0005
R10674 VSS.n5281 VSS.t2770 17.0005
R10675 VSS.n5282 VSS.t2770 17.0005
R10676 VSS.n5283 VSS.t2770 17.0005
R10677 VSS.n5286 VSS.t2770 17.0005
R10678 VSS.n5287 VSS.t2770 17.0005
R10679 VSS.n5288 VSS.t2770 17.0005
R10680 VSS.n5290 VSS.t2770 17.0005
R10681 VSS.n5291 VSS.t2770 17.0005
R10682 VSS.n5025 VSS.t1343 17.0005
R10683 VSS.n5026 VSS.t1343 17.0005
R10684 VSS.n5027 VSS.t1343 17.0005
R10685 VSS.n5030 VSS.t1343 17.0005
R10686 VSS.n5031 VSS.t1343 17.0005
R10687 VSS.n5032 VSS.t1343 17.0005
R10688 VSS.n5034 VSS.t1343 17.0005
R10689 VSS.n5035 VSS.t1343 17.0005
R10690 VSS.n4934 VSS.t1855 17.0005
R10691 VSS.n4935 VSS.t1855 17.0005
R10692 VSS.n4936 VSS.t1855 17.0005
R10693 VSS.n4939 VSS.t1855 17.0005
R10694 VSS.n4940 VSS.t1855 17.0005
R10695 VSS.n4941 VSS.t1855 17.0005
R10696 VSS.n4943 VSS.t1855 17.0005
R10697 VSS.n4944 VSS.t1855 17.0005
R10698 VSS.n5092 VSS.t1595 17.0005
R10699 VSS.n5093 VSS.t1595 17.0005
R10700 VSS.n5094 VSS.t1595 17.0005
R10701 VSS.n5097 VSS.t1595 17.0005
R10702 VSS.n5098 VSS.t1595 17.0005
R10703 VSS.n5099 VSS.t1595 17.0005
R10704 VSS.n5101 VSS.t1595 17.0005
R10705 VSS.n5102 VSS.t1595 17.0005
R10706 VSS.n5159 VSS.t3402 17.0005
R10707 VSS.n5160 VSS.t3402 17.0005
R10708 VSS.n5161 VSS.t3402 17.0005
R10709 VSS.n5164 VSS.t3402 17.0005
R10710 VSS.n5165 VSS.t3402 17.0005
R10711 VSS.n5166 VSS.t3402 17.0005
R10712 VSS.n5168 VSS.t3402 17.0005
R10713 VSS.n5169 VSS.t3402 17.0005
R10714 VSS.n5207 VSS.t3353 17.0005
R10715 VSS.n5208 VSS.t3353 17.0005
R10716 VSS.n5209 VSS.t3353 17.0005
R10717 VSS.n5212 VSS.t3353 17.0005
R10718 VSS.n5213 VSS.t3353 17.0005
R10719 VSS.n5214 VSS.t3353 17.0005
R10720 VSS.n5216 VSS.t3353 17.0005
R10721 VSS.n5217 VSS.t3353 17.0005
R10722 VSS.n588 VSS.n492 17.0005
R10723 VSS.n594 VSS.n588 17.0005
R10724 VSS.n593 VSS.n588 17.0005
R10725 VSS.n588 VSS.n564 17.0005
R10726 VSS.n588 VSS.n507 17.0005
R10727 VSS.n588 VSS.n565 17.0005
R10728 VSS.n588 VSS.n506 17.0005
R10729 VSS.n588 VSS.n566 17.0005
R10730 VSS.n588 VSS.n504 17.0005
R10731 VSS.n588 VSS.n567 17.0005
R10732 VSS.n588 VSS.n503 17.0005
R10733 VSS.n588 VSS.n571 17.0005
R10734 VSS.n592 VSS.n588 17.0005
R10735 VSS.n5986 VSS.n588 17.0005
R10736 VSS.n591 VSS.n588 17.0005
R10737 VSS.n5988 VSS.n588 17.0005
R10738 VSS.n5718 VSS.n496 17.0005
R10739 VSS.n5991 VSS.n496 17.0005
R10740 VSS.n5720 VSS.n496 17.0005
R10741 VSS.n511 VSS.n496 17.0005
R10742 VSS.n5716 VSS.n496 17.0005
R10743 VSS.n562 VSS.n496 17.0005
R10744 VSS.n507 VSS.n496 17.0005
R10745 VSS.n565 VSS.n496 17.0005
R10746 VSS.n506 VSS.n496 17.0005
R10747 VSS.n566 VSS.n496 17.0005
R10748 VSS.n504 VSS.n496 17.0005
R10749 VSS.n567 VSS.n496 17.0005
R10750 VSS.n503 VSS.n496 17.0005
R10751 VSS.n570 VSS.n496 17.0005
R10752 VSS.n502 VSS.n496 17.0005
R10753 VSS.n571 VSS.n496 17.0005
R10754 VSS.n501 VSS.n496 17.0005
R10755 VSS.n577 VSS.n496 17.0005
R10756 VSS.n499 VSS.n496 17.0005
R10757 VSS.n5989 VSS.n496 17.0005
R10758 VSS.n581 VSS.n492 17.0005
R10759 VSS.n594 VSS.n581 17.0005
R10760 VSS.n593 VSS.n581 17.0005
R10761 VSS.n581 VSS.n564 17.0005
R10762 VSS.n581 VSS.n507 17.0005
R10763 VSS.n581 VSS.n565 17.0005
R10764 VSS.n581 VSS.n506 17.0005
R10765 VSS.n581 VSS.n566 17.0005
R10766 VSS.n581 VSS.n504 17.0005
R10767 VSS.n581 VSS.n567 17.0005
R10768 VSS.n581 VSS.n503 17.0005
R10769 VSS.n581 VSS.n570 17.0005
R10770 VSS.n581 VSS.n502 17.0005
R10771 VSS.n581 VSS.n571 17.0005
R10772 VSS.n592 VSS.n581 17.0005
R10773 VSS.n5986 VSS.n581 17.0005
R10774 VSS.n591 VSS.n581 17.0005
R10775 VSS.n5988 VSS.n581 17.0005
R10776 VSS.n5788 VSS.n495 17.0005
R10777 VSS.n5991 VSS.n495 17.0005
R10778 VSS.n5790 VSS.n495 17.0005
R10779 VSS.n511 VSS.n495 17.0005
R10780 VSS.n5742 VSS.n495 17.0005
R10781 VSS.n562 VSS.n495 17.0005
R10782 VSS.n510 VSS.n495 17.0005
R10783 VSS.n564 VSS.n495 17.0005
R10784 VSS.n507 VSS.n495 17.0005
R10785 VSS.n565 VSS.n495 17.0005
R10786 VSS.n506 VSS.n495 17.0005
R10787 VSS.n566 VSS.n495 17.0005
R10788 VSS.n504 VSS.n495 17.0005
R10789 VSS.n567 VSS.n495 17.0005
R10790 VSS.n503 VSS.n495 17.0005
R10791 VSS.n570 VSS.n495 17.0005
R10792 VSS.n502 VSS.n495 17.0005
R10793 VSS.n571 VSS.n495 17.0005
R10794 VSS.n501 VSS.n495 17.0005
R10795 VSS.n577 VSS.n495 17.0005
R10796 VSS.n499 VSS.n495 17.0005
R10797 VSS.n5989 VSS.n495 17.0005
R10798 VSS.n589 VSS.n492 17.0005
R10799 VSS.n594 VSS.n589 17.0005
R10800 VSS.n593 VSS.n589 17.0005
R10801 VSS.n589 VSS.n564 17.0005
R10802 VSS.n589 VSS.n507 17.0005
R10803 VSS.n589 VSS.n565 17.0005
R10804 VSS.n589 VSS.n506 17.0005
R10805 VSS.n589 VSS.n566 17.0005
R10806 VSS.n589 VSS.n504 17.0005
R10807 VSS.n589 VSS.n567 17.0005
R10808 VSS.n589 VSS.n503 17.0005
R10809 VSS.n589 VSS.n570 17.0005
R10810 VSS.n589 VSS.n502 17.0005
R10811 VSS.n589 VSS.n571 17.0005
R10812 VSS.n592 VSS.n589 17.0005
R10813 VSS.n5986 VSS.n589 17.0005
R10814 VSS.n591 VSS.n589 17.0005
R10815 VSS.n5988 VSS.n589 17.0005
R10816 VSS.n5694 VSS.n497 17.0005
R10817 VSS.n5991 VSS.n497 17.0005
R10818 VSS.n5696 VSS.n497 17.0005
R10819 VSS.n511 VSS.n497 17.0005
R10820 VSS.n5647 VSS.n497 17.0005
R10821 VSS.n562 VSS.n497 17.0005
R10822 VSS.n510 VSS.n497 17.0005
R10823 VSS.n564 VSS.n497 17.0005
R10824 VSS.n507 VSS.n497 17.0005
R10825 VSS.n565 VSS.n497 17.0005
R10826 VSS.n506 VSS.n497 17.0005
R10827 VSS.n566 VSS.n497 17.0005
R10828 VSS.n504 VSS.n497 17.0005
R10829 VSS.n567 VSS.n497 17.0005
R10830 VSS.n503 VSS.n497 17.0005
R10831 VSS.n570 VSS.n497 17.0005
R10832 VSS.n502 VSS.n497 17.0005
R10833 VSS.n571 VSS.n497 17.0005
R10834 VSS.n501 VSS.n497 17.0005
R10835 VSS.n577 VSS.n497 17.0005
R10836 VSS.n499 VSS.n497 17.0005
R10837 VSS.n5989 VSS.n497 17.0005
R10838 VSS.n580 VSS.n492 17.0005
R10839 VSS.n594 VSS.n580 17.0005
R10840 VSS.n593 VSS.n580 17.0005
R10841 VSS.n580 VSS.n564 17.0005
R10842 VSS.n580 VSS.n507 17.0005
R10843 VSS.n580 VSS.n565 17.0005
R10844 VSS.n580 VSS.n506 17.0005
R10845 VSS.n580 VSS.n566 17.0005
R10846 VSS.n580 VSS.n504 17.0005
R10847 VSS.n580 VSS.n567 17.0005
R10848 VSS.n580 VSS.n503 17.0005
R10849 VSS.n580 VSS.n570 17.0005
R10850 VSS.n580 VSS.n502 17.0005
R10851 VSS.n580 VSS.n571 17.0005
R10852 VSS.n592 VSS.n580 17.0005
R10853 VSS.n5986 VSS.n580 17.0005
R10854 VSS.n591 VSS.n580 17.0005
R10855 VSS.n5988 VSS.n580 17.0005
R10856 VSS.n656 VSS.n494 17.0005
R10857 VSS.n5991 VSS.n494 17.0005
R10858 VSS.n658 VSS.n494 17.0005
R10859 VSS.n511 VSS.n494 17.0005
R10860 VSS.n610 VSS.n494 17.0005
R10861 VSS.n562 VSS.n494 17.0005
R10862 VSS.n510 VSS.n494 17.0005
R10863 VSS.n564 VSS.n494 17.0005
R10864 VSS.n507 VSS.n494 17.0005
R10865 VSS.n565 VSS.n494 17.0005
R10866 VSS.n506 VSS.n494 17.0005
R10867 VSS.n566 VSS.n494 17.0005
R10868 VSS.n504 VSS.n494 17.0005
R10869 VSS.n567 VSS.n494 17.0005
R10870 VSS.n503 VSS.n494 17.0005
R10871 VSS.n570 VSS.n494 17.0005
R10872 VSS.n502 VSS.n494 17.0005
R10873 VSS.n571 VSS.n494 17.0005
R10874 VSS.n501 VSS.n494 17.0005
R10875 VSS.n577 VSS.n494 17.0005
R10876 VSS.n499 VSS.n494 17.0005
R10877 VSS.n5989 VSS.n494 17.0005
R10878 VSS.n590 VSS.n492 17.0005
R10879 VSS.n594 VSS.n590 17.0005
R10880 VSS.n593 VSS.n590 17.0005
R10881 VSS.n590 VSS.n564 17.0005
R10882 VSS.n590 VSS.n507 17.0005
R10883 VSS.n590 VSS.n565 17.0005
R10884 VSS.n590 VSS.n506 17.0005
R10885 VSS.n590 VSS.n566 17.0005
R10886 VSS.n590 VSS.n504 17.0005
R10887 VSS.n590 VSS.n567 17.0005
R10888 VSS.n590 VSS.n503 17.0005
R10889 VSS.n590 VSS.n570 17.0005
R10890 VSS.n590 VSS.n502 17.0005
R10891 VSS.n590 VSS.n571 17.0005
R10892 VSS.n592 VSS.n590 17.0005
R10893 VSS.n5986 VSS.n590 17.0005
R10894 VSS.n591 VSS.n590 17.0005
R10895 VSS.n5988 VSS.n590 17.0005
R10896 VSS.n5903 VSS.n498 17.0005
R10897 VSS.n5991 VSS.n498 17.0005
R10898 VSS.n5905 VSS.n498 17.0005
R10899 VSS.n511 VSS.n498 17.0005
R10900 VSS.n5857 VSS.n498 17.0005
R10901 VSS.n562 VSS.n498 17.0005
R10902 VSS.n510 VSS.n498 17.0005
R10903 VSS.n564 VSS.n498 17.0005
R10904 VSS.n507 VSS.n498 17.0005
R10905 VSS.n565 VSS.n498 17.0005
R10906 VSS.n506 VSS.n498 17.0005
R10907 VSS.n566 VSS.n498 17.0005
R10908 VSS.n504 VSS.n498 17.0005
R10909 VSS.n567 VSS.n498 17.0005
R10910 VSS.n503 VSS.n498 17.0005
R10911 VSS.n570 VSS.n498 17.0005
R10912 VSS.n502 VSS.n498 17.0005
R10913 VSS.n571 VSS.n498 17.0005
R10914 VSS.n501 VSS.n498 17.0005
R10915 VSS.n577 VSS.n498 17.0005
R10916 VSS.n499 VSS.n498 17.0005
R10917 VSS.n5989 VSS.n498 17.0005
R10918 VSS.n579 VSS.n492 17.0005
R10919 VSS.n594 VSS.n579 17.0005
R10920 VSS.n593 VSS.n579 17.0005
R10921 VSS.n579 VSS.n564 17.0005
R10922 VSS.n579 VSS.n507 17.0005
R10923 VSS.n579 VSS.n565 17.0005
R10924 VSS.n579 VSS.n506 17.0005
R10925 VSS.n579 VSS.n566 17.0005
R10926 VSS.n579 VSS.n504 17.0005
R10927 VSS.n579 VSS.n567 17.0005
R10928 VSS.n579 VSS.n503 17.0005
R10929 VSS.n579 VSS.n570 17.0005
R10930 VSS.n579 VSS.n502 17.0005
R10931 VSS.n579 VSS.n571 17.0005
R10932 VSS.n592 VSS.n579 17.0005
R10933 VSS.n5986 VSS.n579 17.0005
R10934 VSS.n591 VSS.n579 17.0005
R10935 VSS.n5988 VSS.n579 17.0005
R10936 VSS.n5973 VSS.n493 17.0005
R10937 VSS.n5991 VSS.n493 17.0005
R10938 VSS.n5975 VSS.n493 17.0005
R10939 VSS.n511 VSS.n493 17.0005
R10940 VSS.n5927 VSS.n493 17.0005
R10941 VSS.n562 VSS.n493 17.0005
R10942 VSS.n510 VSS.n493 17.0005
R10943 VSS.n564 VSS.n493 17.0005
R10944 VSS.n507 VSS.n493 17.0005
R10945 VSS.n565 VSS.n493 17.0005
R10946 VSS.n506 VSS.n493 17.0005
R10947 VSS.n566 VSS.n493 17.0005
R10948 VSS.n504 VSS.n493 17.0005
R10949 VSS.n567 VSS.n493 17.0005
R10950 VSS.n503 VSS.n493 17.0005
R10951 VSS.n570 VSS.n493 17.0005
R10952 VSS.n502 VSS.n493 17.0005
R10953 VSS.n571 VSS.n493 17.0005
R10954 VSS.n501 VSS.n493 17.0005
R10955 VSS.n577 VSS.n493 17.0005
R10956 VSS.n499 VSS.n493 17.0005
R10957 VSS.n5989 VSS.n493 17.0005
R10958 VSS.n5987 VSS.n492 17.0005
R10959 VSS.n5987 VSS.n594 17.0005
R10960 VSS.n5987 VSS.n593 17.0005
R10961 VSS.n5987 VSS.n564 17.0005
R10962 VSS.n5987 VSS.n507 17.0005
R10963 VSS.n5987 VSS.n565 17.0005
R10964 VSS.n5987 VSS.n506 17.0005
R10965 VSS.n5987 VSS.n566 17.0005
R10966 VSS.n5987 VSS.n504 17.0005
R10967 VSS.n5987 VSS.n567 17.0005
R10968 VSS.n5987 VSS.n503 17.0005
R10969 VSS.n5987 VSS.n570 17.0005
R10970 VSS.n5987 VSS.n502 17.0005
R10971 VSS.n5987 VSS.n571 17.0005
R10972 VSS.n5987 VSS.n592 17.0005
R10973 VSS.n5987 VSS.n5986 17.0005
R10974 VSS.n5987 VSS.n591 17.0005
R10975 VSS.n5988 VSS.n5987 17.0005
R10976 VSS.n5990 VSS.n559 17.0005
R10977 VSS.n5991 VSS.n5990 17.0005
R10978 VSS.n5990 VSS.n512 17.0005
R10979 VSS.n5990 VSS.n511 17.0005
R10980 VSS.n5990 VSS.n561 17.0005
R10981 VSS.n5990 VSS.n562 17.0005
R10982 VSS.n5990 VSS.n510 17.0005
R10983 VSS.n5990 VSS.n564 17.0005
R10984 VSS.n5990 VSS.n507 17.0005
R10985 VSS.n5990 VSS.n565 17.0005
R10986 VSS.n5990 VSS.n506 17.0005
R10987 VSS.n5990 VSS.n566 17.0005
R10988 VSS.n5990 VSS.n504 17.0005
R10989 VSS.n5990 VSS.n567 17.0005
R10990 VSS.n5990 VSS.n503 17.0005
R10991 VSS.n5990 VSS.n570 17.0005
R10992 VSS.n5990 VSS.n502 17.0005
R10993 VSS.n5990 VSS.n571 17.0005
R10994 VSS.n5990 VSS.n501 17.0005
R10995 VSS.n5990 VSS.n577 17.0005
R10996 VSS.n5990 VSS.n499 17.0005
R10997 VSS.n5990 VSS.n5989 17.0005
R10998 VSS.n3497 VSS.n3481 17.0005
R10999 VSS.n3497 VSS.n3478 17.0005
R11000 VSS.n3497 VSS.n3485 17.0005
R11001 VSS.n3497 VSS.n3486 17.0005
R11002 VSS.n3497 VSS.n3470 17.0005
R11003 VSS.n3497 VSS.n3496 17.0005
R11004 VSS.n3079 VSS.n3016 17.0005
R11005 VSS.n3080 VSS.n3079 17.0005
R11006 VSS.n3079 VSS.n3067 17.0005
R11007 VSS.n3079 VSS.n3068 17.0005
R11008 VSS.n3079 VSS.n3008 17.0005
R11009 VSS.n3079 VSS.n3078 17.0005
R11010 VSS.n5441 VSS.n1138 17.0005
R11011 VSS.n5442 VSS.n5441 17.0005
R11012 VSS.n5441 VSS.n5429 17.0005
R11013 VSS.n5441 VSS.n5430 17.0005
R11014 VSS.n5441 VSS.n1130 17.0005
R11015 VSS.n5441 VSS.n5440 17.0005
R11016 VSS.n4872 VSS.n4856 17.0005
R11017 VSS.n4872 VSS.n4853 17.0005
R11018 VSS.n4872 VSS.n4860 17.0005
R11019 VSS.n4872 VSS.n4861 17.0005
R11020 VSS.n4872 VSS.n4845 17.0005
R11021 VSS.n4872 VSS.n4871 17.0005
R11022 VSS.n5359 VSS.n4889 17.0005
R11023 VSS.n5359 VSS.n4886 17.0005
R11024 VSS.n5359 VSS.n5347 17.0005
R11025 VSS.n5359 VSS.n5348 17.0005
R11026 VSS.n5359 VSS.n4878 17.0005
R11027 VSS.n5359 VSS.n5358 17.0005
R11028 VSS.n6022 VSS.n399 17.0005
R11029 VSS.n6023 VSS.n6022 17.0005
R11030 VSS.n6022 VSS.n385 17.0005
R11031 VSS.n6022 VSS.n6011 17.0005
R11032 VSS.n6022 VSS.n390 17.0005
R11033 VSS.n6022 VSS.n6021 17.0005
R11034 VSS.n3467 VSS.t2238 17.0005
R11035 VSS.t2238 VSS.n2284 17.0005
R11036 VSS.t2238 VSS.n2278 17.0005
R11037 VSS.t2238 VSS.n2276 17.0005
R11038 VSS.t2238 VSS.n2290 17.0005
R11039 VSS.t2238 VSS.n2275 17.0005
R11040 VSS.t2238 VSS.n2292 17.0005
R11041 VSS.t2238 VSS.n2272 17.0005
R11042 VSS.t2238 VSS.n2266 17.0005
R11043 VSS.t2238 VSS.n2265 17.0005
R11044 VSS.t2238 VSS.n2301 17.0005
R11045 VSS.t2210 VSS.n2241 17.0005
R11046 VSS.t2210 VSS.n2242 17.0005
R11047 VSS.n3500 VSS.t2210 17.0005
R11048 VSS.n3503 VSS.t2210 17.0005
R11049 VSS.n3504 VSS.t2210 17.0005
R11050 VSS.n3505 VSS.t2210 17.0005
R11051 VSS.n3507 VSS.t2210 17.0005
R11052 VSS.n3508 VSS.t2210 17.0005
R11053 VSS.t2210 VSS.n2232 17.0005
R11054 VSS.t2210 VSS.n2231 17.0005
R11055 VSS.t2210 VSS.n2253 17.0005
R11056 VSS.t2210 VSS.n2222 17.0005
R11057 VSS.t2210 VSS.n2255 17.0005
R11058 VSS.t2210 VSS.n3499 17.0005
R11059 VSS.t2182 VSS.n3042 17.0005
R11060 VSS.t2182 VSS.n3044 17.0005
R11061 VSS.t2182 VSS.n3039 17.0005
R11062 VSS.t2182 VSS.n3037 17.0005
R11063 VSS.t2182 VSS.n3050 17.0005
R11064 VSS.t2182 VSS.n3036 17.0005
R11065 VSS.t2182 VSS.n3052 17.0005
R11066 VSS.t2182 VSS.n3033 17.0005
R11067 VSS.t2182 VSS.n3027 17.0005
R11068 VSS.t2182 VSS.n3026 17.0005
R11069 VSS.t2182 VSS.n3061 17.0005
R11070 VSS.t2182 VSS.n3017 17.0005
R11071 VSS.t2182 VSS.n3063 17.0005
R11072 VSS.n3064 VSS.t2182 17.0005
R11073 VSS.t2154 VSS.n1164 17.0005
R11074 VSS.t2154 VSS.n5406 17.0005
R11075 VSS.t2154 VSS.n1161 17.0005
R11076 VSS.t2154 VSS.n1159 17.0005
R11077 VSS.t2154 VSS.n5412 17.0005
R11078 VSS.t2154 VSS.n1158 17.0005
R11079 VSS.t2154 VSS.n5414 17.0005
R11080 VSS.t2154 VSS.n1155 17.0005
R11081 VSS.t2154 VSS.n1149 17.0005
R11082 VSS.t2154 VSS.n1148 17.0005
R11083 VSS.t2154 VSS.n5423 17.0005
R11084 VSS.t2154 VSS.n1139 17.0005
R11085 VSS.t2154 VSS.n5425 17.0005
R11086 VSS.n5426 VSS.t2154 17.0005
R11087 VSS.n4875 VSS.t2126 17.0005
R11088 VSS.t2126 VSS.n4823 17.0005
R11089 VSS.t2126 VSS.n4819 17.0005
R11090 VSS.t2126 VSS.n4817 17.0005
R11091 VSS.t2126 VSS.n4829 17.0005
R11092 VSS.t2126 VSS.n4816 17.0005
R11093 VSS.t2126 VSS.n4831 17.0005
R11094 VSS.t2126 VSS.n4813 17.0005
R11095 VSS.t2126 VSS.n4807 17.0005
R11096 VSS.t2126 VSS.n4806 17.0005
R11097 VSS.t2126 VSS.n4840 17.0005
R11098 VSS.t2126 VSS.n4797 17.0005
R11099 VSS.t2126 VSS.n4842 17.0005
R11100 VSS.t2126 VSS.n4874 17.0005
R11101 VSS.t2098 VSS.n4782 17.0005
R11102 VSS.t2098 VSS.n4783 17.0005
R11103 VSS.n5362 VSS.t2098 17.0005
R11104 VSS.n5365 VSS.t2098 17.0005
R11105 VSS.n5366 VSS.t2098 17.0005
R11106 VSS.n5367 VSS.t2098 17.0005
R11107 VSS.n5369 VSS.t2098 17.0005
R11108 VSS.n5370 VSS.t2098 17.0005
R11109 VSS.t2098 VSS.n4773 17.0005
R11110 VSS.t2098 VSS.n4772 17.0005
R11111 VSS.t2098 VSS.n4794 17.0005
R11112 VSS.t2098 VSS.n4763 17.0005
R11113 VSS.t2098 VSS.n4796 17.0005
R11114 VSS.t2098 VSS.n5361 17.0005
R11115 VSS.t2070 VSS.n426 17.0005
R11116 VSS.t2070 VSS.n427 17.0005
R11117 VSS.t2070 VSS.n423 17.0005
R11118 VSS.t2070 VSS.n421 17.0005
R11119 VSS.t2070 VSS.n433 17.0005
R11120 VSS.t2070 VSS.n420 17.0005
R11121 VSS.t2070 VSS.n435 17.0005
R11122 VSS.t2070 VSS.n417 17.0005
R11123 VSS.t2070 VSS.n5998 17.0005
R11124 VSS.t2070 VSS.n410 17.0005
R11125 VSS.t2070 VSS.n409 17.0005
R11126 VSS.t2070 VSS.n6006 17.0005
R11127 VSS.t2070 VSS.n400 17.0005
R11128 VSS.t2070 VSS.n6008 17.0005
R11129 VSS.n6009 VSS.t2070 17.0005
R11130 VSS.n2505 VSS.t1994 17.0005
R11131 VSS.n2507 VSS.t1994 17.0005
R11132 VSS.n3391 VSS.t1479 17.0005
R11133 VSS.n3393 VSS.t1479 17.0005
R11134 VSS.n2431 VSS.t2256 17.0005
R11135 VSS.n2433 VSS.t2256 17.0005
R11136 VSS.n2437 VSS.n2393 17.0005
R11137 VSS.n2438 VSS.n2437 17.0005
R11138 VSS.n2437 VSS.n2304 17.0005
R11139 VSS.n3397 VSS.n3353 17.0005
R11140 VSS.n3398 VSS.n3397 17.0005
R11141 VSS.n3397 VSS.n2305 17.0005
R11142 VSS.n2511 VSS.n2467 17.0005
R11143 VSS.n2512 VSS.n2511 17.0005
R11144 VSS.n2511 VSS.n2306 17.0005
R11145 VSS.t2238 VSS.n2256 17.0005
R11146 VSS.t2238 VSS.n2303 17.0005
R11147 VSS.t2238 VSS.n3466 17.0005
R11148 VSS.n2583 VSS.n2539 17.0005
R11149 VSS.n2584 VSS.n2583 17.0005
R11150 VSS.n2583 VSS.n2307 17.0005
R11151 VSS.n3417 VSS.n2308 17.0005
R11152 VSS.n3417 VSS.n3416 17.0005
R11153 VSS.n3418 VSS.n3417 17.0005
R11154 VSS.n1958 VSS.t173 17.0005
R11155 VSS.n1978 VSS.t161 17.0005
R11156 VSS.n1973 VSS.t158 17.0005
R11157 VSS.n3580 VSS.t176 17.0005
R11158 VSS.n1959 VSS.t169 17.0005
R11159 VSS.n3579 VSS.t178 17.0005
R11160 VSS.n1909 VSS.t200 17.0005
R11161 VSS.n1933 VSS.t188 17.0005
R11162 VSS.n3587 VSS.t134 17.0005
R11163 VSS.n2091 VSS.t110 17.0005
R11164 VSS.n2090 VSS.t163 17.0005
R11165 VSS.n2100 VSS.t166 17.0005
R11166 VSS.n2081 VSS.t145 17.0005
R11167 VSS.n2082 VSS.t155 17.0005
R11168 VSS.n2073 VSS.t139 17.0005
R11169 VSS.t2940 VSS.n2014 17.0005
R11170 VSS.t2940 VSS.n2008 17.0005
R11171 VSS.n3572 VSS.n2070 17.0005
R11172 VSS.n3572 VSS.n1983 17.0005
R11173 VSS.n3572 VSS.n3571 17.0005
R11174 VSS.n3573 VSS.n3572 17.0005
R11175 VSS.n2105 VSS.n2104 17.0005
R11176 VSS.n2076 VSS.n2071 17.0005
R11177 VSS.n2094 VSS.n2088 17.0005
R11178 VSS.n2085 VSS.n2079 17.0005
R11179 VSS.n3576 VSS.n1968 17.0005
R11180 VSS.n3576 VSS.n1969 17.0005
R11181 VSS.n3577 VSS.n3576 17.0005
R11182 VSS.n3576 VSS.n1971 17.0005
R11183 VSS.n3576 VSS.n1972 17.0005
R11184 VSS.n3576 VSS.n1976 17.0005
R11185 VSS.n3576 VSS.n1967 17.0005
R11186 VSS.n3576 VSS.n1977 17.0005
R11187 VSS.n3576 VSS.n1966 17.0005
R11188 VSS.n3576 VSS.n3575 17.0005
R11189 VSS.n3590 VSS.n1937 17.0005
R11190 VSS.n3590 VSS.n1932 17.0005
R11191 VSS.n3590 VSS.n1938 17.0005
R11192 VSS.n3590 VSS.n1930 17.0005
R11193 VSS.n3590 VSS.n1941 17.0005
R11194 VSS.n3590 VSS.n1942 17.0005
R11195 VSS.n3590 VSS.n1929 17.0005
R11196 VSS.n3590 VSS.n1943 17.0005
R11197 VSS.n3590 VSS.n1927 17.0005
R11198 VSS.n3590 VSS.n1945 17.0005
R11199 VSS.n3590 VSS.n1946 17.0005
R11200 VSS.n3590 VSS.n1926 17.0005
R11201 VSS.n3590 VSS.n3585 17.0005
R11202 VSS.n3590 VSS.n1925 17.0005
R11203 VSS.n3590 VSS.n1924 17.0005
R11204 VSS.n3590 VSS.n3589 17.0005
R11205 VSS.n3591 VSS.n3590 17.0005
R11206 VSS.n3583 VSS.n1963 17.0005
R11207 VSS.n3583 VSS.t187 17.0005
R11208 VSS.n3583 VSS.n1957 17.0005
R11209 VSS.n3583 VSS.n1964 17.0005
R11210 VSS.n3583 VSS.n1956 17.0005
R11211 VSS.n3583 VSS.n1965 17.0005
R11212 VSS.n3583 VSS.n1955 17.0005
R11213 VSS.n3583 VSS.n3578 17.0005
R11214 VSS.n3583 VSS.n1954 17.0005
R11215 VSS.n3584 VSS.n3583 17.0005
R11216 VSS.n3583 VSS.n1952 17.0005
R11217 VSS.n3583 VSS.n1923 17.0005
R11218 VSS.n3610 VSS.n1851 17.0005
R11219 VSS.n3610 VSS.n1852 17.0005
R11220 VSS.n3611 VSS.n3610 17.0005
R11221 VSS.n3610 VSS.n1850 17.0005
R11222 VSS.n3610 VSS.n1854 17.0005
R11223 VSS.n3610 VSS.n1855 17.0005
R11224 VSS.n3610 VSS.n1846 17.0005
R11225 VSS.n3610 VSS.n1856 17.0005
R11226 VSS.n3610 VSS.n1845 17.0005
R11227 VSS.n3610 VSS.n1857 17.0005
R11228 VSS.n3610 VSS.n1843 17.0005
R11229 VSS.n3610 VSS.n1858 17.0005
R11230 VSS.n3610 VSS.n1842 17.0005
R11231 VSS.n3610 VSS.n1861 17.0005
R11232 VSS.n3610 VSS.n1841 17.0005
R11233 VSS.n3610 VSS.n1862 17.0005
R11234 VSS.n3610 VSS.n1840 17.0005
R11235 VSS.n3610 VSS.n1868 17.0005
R11236 VSS.n3610 VSS.n1838 17.0005
R11237 VSS.n3610 VSS.n3609 17.0005
R11238 VSS.n1901 VSS.n1892 17.0005
R11239 VSS.n1902 VSS.n1892 17.0005
R11240 VSS.n1900 VSS.n1892 17.0005
R11241 VSS.n3600 VSS.n1892 17.0005
R11242 VSS.n1892 VSS.n1846 17.0005
R11243 VSS.n1892 VSS.n1856 17.0005
R11244 VSS.n1892 VSS.n1845 17.0005
R11245 VSS.n1892 VSS.n1857 17.0005
R11246 VSS.n1892 VSS.n1843 17.0005
R11247 VSS.n1892 VSS.n1858 17.0005
R11248 VSS.n1892 VSS.n1842 17.0005
R11249 VSS.n1892 VSS.n1861 17.0005
R11250 VSS.n1892 VSS.n1841 17.0005
R11251 VSS.n1892 VSS.n1862 17.0005
R11252 VSS.n1899 VSS.n1892 17.0005
R11253 VSS.n3597 VSS.n1892 17.0005
R11254 VSS.n1898 VSS.n1892 17.0005
R11255 VSS.n3598 VSS.n1892 17.0005
R11256 VSS.n2513 VSS.n1872 17.0005
R11257 VSS.n1872 VSS.n1852 17.0005
R11258 VSS.n2515 VSS.n1872 17.0005
R11259 VSS.n1872 VSS.n1850 17.0005
R11260 VSS.n2463 VSS.n1872 17.0005
R11261 VSS.n1872 VSS.n1855 17.0005
R11262 VSS.n1880 VSS.n1872 17.0005
R11263 VSS.n3600 VSS.n1872 17.0005
R11264 VSS.n1872 VSS.n1846 17.0005
R11265 VSS.n1872 VSS.n1856 17.0005
R11266 VSS.n1872 VSS.n1845 17.0005
R11267 VSS.n1872 VSS.n1857 17.0005
R11268 VSS.n1872 VSS.n1843 17.0005
R11269 VSS.n1872 VSS.n1858 17.0005
R11270 VSS.n1872 VSS.n1842 17.0005
R11271 VSS.n1872 VSS.n1861 17.0005
R11272 VSS.n1872 VSS.n1841 17.0005
R11273 VSS.n1872 VSS.n1862 17.0005
R11274 VSS.n1872 VSS.n1840 17.0005
R11275 VSS.n1872 VSS.n1868 17.0005
R11276 VSS.n1872 VSS.n1838 17.0005
R11277 VSS.n3609 VSS.n1872 17.0005
R11278 VSS.n1901 VSS.n1893 17.0005
R11279 VSS.n1902 VSS.n1893 17.0005
R11280 VSS.n1900 VSS.n1893 17.0005
R11281 VSS.n3600 VSS.n1893 17.0005
R11282 VSS.n1893 VSS.n1846 17.0005
R11283 VSS.n1893 VSS.n1856 17.0005
R11284 VSS.n1893 VSS.n1845 17.0005
R11285 VSS.n1893 VSS.n1857 17.0005
R11286 VSS.n1893 VSS.n1843 17.0005
R11287 VSS.n1893 VSS.n1858 17.0005
R11288 VSS.n1893 VSS.n1842 17.0005
R11289 VSS.n1893 VSS.n1861 17.0005
R11290 VSS.n1893 VSS.n1841 17.0005
R11291 VSS.n1893 VSS.n1862 17.0005
R11292 VSS.n1899 VSS.n1893 17.0005
R11293 VSS.n3597 VSS.n1893 17.0005
R11294 VSS.n1898 VSS.n1893 17.0005
R11295 VSS.n3598 VSS.n1893 17.0005
R11296 VSS.n2585 VSS.n1874 17.0005
R11297 VSS.n1874 VSS.n1852 17.0005
R11298 VSS.n2587 VSS.n1874 17.0005
R11299 VSS.n1874 VSS.n1850 17.0005
R11300 VSS.n2536 VSS.n1874 17.0005
R11301 VSS.n1874 VSS.n1855 17.0005
R11302 VSS.n1880 VSS.n1874 17.0005
R11303 VSS.n3600 VSS.n1874 17.0005
R11304 VSS.n1874 VSS.n1846 17.0005
R11305 VSS.n1874 VSS.n1856 17.0005
R11306 VSS.n1874 VSS.n1845 17.0005
R11307 VSS.n1874 VSS.n1857 17.0005
R11308 VSS.n1874 VSS.n1843 17.0005
R11309 VSS.n1874 VSS.n1858 17.0005
R11310 VSS.n1874 VSS.n1842 17.0005
R11311 VSS.n1874 VSS.n1861 17.0005
R11312 VSS.n1874 VSS.n1841 17.0005
R11313 VSS.n1874 VSS.n1862 17.0005
R11314 VSS.n1874 VSS.n1840 17.0005
R11315 VSS.n1874 VSS.n1868 17.0005
R11316 VSS.n1874 VSS.n1838 17.0005
R11317 VSS.n3609 VSS.n1874 17.0005
R11318 VSS.n1901 VSS.n1894 17.0005
R11319 VSS.n1902 VSS.n1894 17.0005
R11320 VSS.n1900 VSS.n1894 17.0005
R11321 VSS.n3600 VSS.n1894 17.0005
R11322 VSS.n1894 VSS.n1846 17.0005
R11323 VSS.n1894 VSS.n1856 17.0005
R11324 VSS.n1894 VSS.n1845 17.0005
R11325 VSS.n1894 VSS.n1857 17.0005
R11326 VSS.n1894 VSS.n1843 17.0005
R11327 VSS.n1894 VSS.n1858 17.0005
R11328 VSS.n1894 VSS.n1842 17.0005
R11329 VSS.n1894 VSS.n1861 17.0005
R11330 VSS.n1894 VSS.n1841 17.0005
R11331 VSS.n1894 VSS.n1862 17.0005
R11332 VSS.n1899 VSS.n1894 17.0005
R11333 VSS.n3597 VSS.n1894 17.0005
R11334 VSS.n1898 VSS.n1894 17.0005
R11335 VSS.n3598 VSS.n1894 17.0005
R11336 VSS.n3399 VSS.n1871 17.0005
R11337 VSS.n1871 VSS.n1852 17.0005
R11338 VSS.n3401 VSS.n1871 17.0005
R11339 VSS.n1871 VSS.n1850 17.0005
R11340 VSS.n3349 VSS.n1871 17.0005
R11341 VSS.n1871 VSS.n1855 17.0005
R11342 VSS.n1880 VSS.n1871 17.0005
R11343 VSS.n3600 VSS.n1871 17.0005
R11344 VSS.n1871 VSS.n1846 17.0005
R11345 VSS.n1871 VSS.n1856 17.0005
R11346 VSS.n1871 VSS.n1845 17.0005
R11347 VSS.n1871 VSS.n1857 17.0005
R11348 VSS.n1871 VSS.n1843 17.0005
R11349 VSS.n1871 VSS.n1858 17.0005
R11350 VSS.n1871 VSS.n1842 17.0005
R11351 VSS.n1871 VSS.n1861 17.0005
R11352 VSS.n1871 VSS.n1841 17.0005
R11353 VSS.n1871 VSS.n1862 17.0005
R11354 VSS.n1871 VSS.n1840 17.0005
R11355 VSS.n1871 VSS.n1868 17.0005
R11356 VSS.n1871 VSS.n1838 17.0005
R11357 VSS.n3609 VSS.n1871 17.0005
R11358 VSS.n1901 VSS.n1895 17.0005
R11359 VSS.n1902 VSS.n1895 17.0005
R11360 VSS.n1900 VSS.n1895 17.0005
R11361 VSS.n3600 VSS.n1895 17.0005
R11362 VSS.n1895 VSS.n1846 17.0005
R11363 VSS.n1895 VSS.n1856 17.0005
R11364 VSS.n1895 VSS.n1845 17.0005
R11365 VSS.n1895 VSS.n1857 17.0005
R11366 VSS.n1895 VSS.n1843 17.0005
R11367 VSS.n1895 VSS.n1858 17.0005
R11368 VSS.n1895 VSS.n1842 17.0005
R11369 VSS.n1895 VSS.n1861 17.0005
R11370 VSS.n1895 VSS.n1841 17.0005
R11371 VSS.n1895 VSS.n1862 17.0005
R11372 VSS.n1899 VSS.n1895 17.0005
R11373 VSS.n3597 VSS.n1895 17.0005
R11374 VSS.n1898 VSS.n1895 17.0005
R11375 VSS.n3598 VSS.n1895 17.0005
R11376 VSS.n3414 VSS.n1875 17.0005
R11377 VSS.n1875 VSS.n1852 17.0005
R11378 VSS.n3412 VSS.n1875 17.0005
R11379 VSS.n1875 VSS.n1850 17.0005
R11380 VSS.n2365 VSS.n1875 17.0005
R11381 VSS.n1875 VSS.n1855 17.0005
R11382 VSS.n1880 VSS.n1875 17.0005
R11383 VSS.n3600 VSS.n1875 17.0005
R11384 VSS.n1875 VSS.n1846 17.0005
R11385 VSS.n1875 VSS.n1856 17.0005
R11386 VSS.n1875 VSS.n1845 17.0005
R11387 VSS.n1875 VSS.n1857 17.0005
R11388 VSS.n1875 VSS.n1843 17.0005
R11389 VSS.n1875 VSS.n1858 17.0005
R11390 VSS.n1875 VSS.n1842 17.0005
R11391 VSS.n1875 VSS.n1861 17.0005
R11392 VSS.n1875 VSS.n1841 17.0005
R11393 VSS.n1875 VSS.n1862 17.0005
R11394 VSS.n1875 VSS.n1840 17.0005
R11395 VSS.n1875 VSS.n1868 17.0005
R11396 VSS.n1875 VSS.n1838 17.0005
R11397 VSS.n3609 VSS.n1875 17.0005
R11398 VSS.n1901 VSS.n1896 17.0005
R11399 VSS.n1902 VSS.n1896 17.0005
R11400 VSS.n1900 VSS.n1896 17.0005
R11401 VSS.n3600 VSS.n1896 17.0005
R11402 VSS.n1896 VSS.n1846 17.0005
R11403 VSS.n1896 VSS.n1856 17.0005
R11404 VSS.n1896 VSS.n1845 17.0005
R11405 VSS.n1896 VSS.n1857 17.0005
R11406 VSS.n1896 VSS.n1843 17.0005
R11407 VSS.n1896 VSS.n1858 17.0005
R11408 VSS.n1896 VSS.n1842 17.0005
R11409 VSS.n1896 VSS.n1861 17.0005
R11410 VSS.n1896 VSS.n1841 17.0005
R11411 VSS.n1896 VSS.n1862 17.0005
R11412 VSS.n1899 VSS.n1896 17.0005
R11413 VSS.n3597 VSS.n1896 17.0005
R11414 VSS.n1898 VSS.n1896 17.0005
R11415 VSS.n3598 VSS.n1896 17.0005
R11416 VSS.n2439 VSS.n1870 17.0005
R11417 VSS.n1870 VSS.n1852 17.0005
R11418 VSS.n2441 VSS.n1870 17.0005
R11419 VSS.n1870 VSS.n1850 17.0005
R11420 VSS.n2389 VSS.n1870 17.0005
R11421 VSS.n1870 VSS.n1855 17.0005
R11422 VSS.n1880 VSS.n1870 17.0005
R11423 VSS.n3600 VSS.n1870 17.0005
R11424 VSS.n1870 VSS.n1846 17.0005
R11425 VSS.n1870 VSS.n1856 17.0005
R11426 VSS.n1870 VSS.n1845 17.0005
R11427 VSS.n1870 VSS.n1857 17.0005
R11428 VSS.n1870 VSS.n1843 17.0005
R11429 VSS.n1870 VSS.n1858 17.0005
R11430 VSS.n1870 VSS.n1842 17.0005
R11431 VSS.n1870 VSS.n1861 17.0005
R11432 VSS.n1870 VSS.n1841 17.0005
R11433 VSS.n1870 VSS.n1862 17.0005
R11434 VSS.n1870 VSS.n1840 17.0005
R11435 VSS.n1870 VSS.n1868 17.0005
R11436 VSS.n1870 VSS.n1838 17.0005
R11437 VSS.n3609 VSS.n1870 17.0005
R11438 VSS.n1901 VSS.n1897 17.0005
R11439 VSS.n1902 VSS.n1897 17.0005
R11440 VSS.n1900 VSS.n1897 17.0005
R11441 VSS.n3600 VSS.n1897 17.0005
R11442 VSS.n1897 VSS.n1846 17.0005
R11443 VSS.n1897 VSS.n1856 17.0005
R11444 VSS.n1897 VSS.n1845 17.0005
R11445 VSS.n1897 VSS.n1857 17.0005
R11446 VSS.n1897 VSS.n1843 17.0005
R11447 VSS.n1897 VSS.n1858 17.0005
R11448 VSS.n1897 VSS.n1842 17.0005
R11449 VSS.n1897 VSS.n1861 17.0005
R11450 VSS.n1897 VSS.n1841 17.0005
R11451 VSS.n1897 VSS.n1862 17.0005
R11452 VSS.n1899 VSS.n1897 17.0005
R11453 VSS.n3597 VSS.n1897 17.0005
R11454 VSS.n1898 VSS.n1897 17.0005
R11455 VSS.n3598 VSS.n1897 17.0005
R11456 VSS.n3599 VSS.n1901 17.0005
R11457 VSS.n3599 VSS.n1902 17.0005
R11458 VSS.n3599 VSS.n1900 17.0005
R11459 VSS.n3600 VSS.n3599 17.0005
R11460 VSS.n3599 VSS.n1846 17.0005
R11461 VSS.n3599 VSS.n1856 17.0005
R11462 VSS.n3599 VSS.n1845 17.0005
R11463 VSS.n3599 VSS.n1857 17.0005
R11464 VSS.n3599 VSS.n1843 17.0005
R11465 VSS.n3599 VSS.n1858 17.0005
R11466 VSS.n3599 VSS.n1842 17.0005
R11467 VSS.n3599 VSS.n1861 17.0005
R11468 VSS.n3599 VSS.n1841 17.0005
R11469 VSS.n3599 VSS.n1862 17.0005
R11470 VSS.n3599 VSS.n1899 17.0005
R11471 VSS.n3599 VSS.n3597 17.0005
R11472 VSS.n3599 VSS.n1898 17.0005
R11473 VSS.n3599 VSS.n3598 17.0005
R11474 VSS.n3595 VSS.n1916 17.0005
R11475 VSS.n3595 VSS.n1917 17.0005
R11476 VSS.n3595 VSS.n1912 17.0005
R11477 VSS.n3595 VSS.n1918 17.0005
R11478 VSS.n3595 VSS.n1911 17.0005
R11479 VSS.n3595 VSS.n1919 17.0005
R11480 VSS.n3596 VSS.n3595 17.0005
R11481 VSS.n3595 VSS.n1920 17.0005
R11482 VSS.n3595 VSS.n1873 17.0005
R11483 VSS.n3595 VSS.n1869 17.0005
R11484 VSS.n3595 VSS.n1908 17.0005
R11485 VSS.n3595 VSS.n3594 17.0005
R11486 VSS.n3608 VSS.n1884 17.0005
R11487 VSS.n3608 VSS.n1852 17.0005
R11488 VSS.n3608 VSS.n1881 17.0005
R11489 VSS.n3608 VSS.n1850 17.0005
R11490 VSS.n3608 VSS.n1886 17.0005
R11491 VSS.n3608 VSS.n1855 17.0005
R11492 VSS.n3608 VSS.n1880 17.0005
R11493 VSS.n3608 VSS.n3600 17.0005
R11494 VSS.n3608 VSS.n1846 17.0005
R11495 VSS.n3608 VSS.n1856 17.0005
R11496 VSS.n3608 VSS.n1845 17.0005
R11497 VSS.n3608 VSS.n1857 17.0005
R11498 VSS.n3608 VSS.n1843 17.0005
R11499 VSS.n3608 VSS.n1858 17.0005
R11500 VSS.n3608 VSS.n1842 17.0005
R11501 VSS.n3608 VSS.n1861 17.0005
R11502 VSS.n3608 VSS.n1841 17.0005
R11503 VSS.n3608 VSS.n1862 17.0005
R11504 VSS.n3608 VSS.n1840 17.0005
R11505 VSS.n3608 VSS.n1868 17.0005
R11506 VSS.n3608 VSS.n1838 17.0005
R11507 VSS.n3609 VSS.n3608 17.0005
R11508 VSS.t3237 VSS.n3449 17.0005
R11509 VSS.t3237 VSS.n3446 17.0005
R11510 VSS.n3464 VSS.t3237 17.0005
R11511 VSS.t3237 VSS.n3460 17.0005
R11512 VSS.t3237 VSS.n3442 17.0005
R11513 VSS.t3237 VSS.n3427 17.0005
R11514 VSS.t3237 VSS.n3426 17.0005
R11515 VSS.t3237 VSS.n3429 17.0005
R11516 VSS.t3237 VSS.n3433 17.0005
R11517 VSS.t3237 VSS.n3422 17.0005
R11518 VSS.t3237 VSS.n3434 17.0005
R11519 VSS.t3237 VSS.n3420 17.0005
R11520 VSS.t3237 VSS.n3437 17.0005
R11521 VSS.n2329 VSS.t1184 17.0005
R11522 VSS.n2330 VSS.t1184 17.0005
R11523 VSS.n2331 VSS.t1184 17.0005
R11524 VSS.n2334 VSS.t1184 17.0005
R11525 VSS.n2335 VSS.t1184 17.0005
R11526 VSS.n2336 VSS.t1184 17.0005
R11527 VSS.n2338 VSS.t1184 17.0005
R11528 VSS.n2339 VSS.t1184 17.0005
R11529 VSS.n2560 VSS.t1730 17.0005
R11530 VSS.n2561 VSS.t1730 17.0005
R11531 VSS.n2562 VSS.t1730 17.0005
R11532 VSS.n2565 VSS.t1730 17.0005
R11533 VSS.n2566 VSS.t1730 17.0005
R11534 VSS.n2567 VSS.t1730 17.0005
R11535 VSS.n2569 VSS.t1730 17.0005
R11536 VSS.n2570 VSS.t1730 17.0005
R11537 VSS.n2488 VSS.t1994 17.0005
R11538 VSS.n2489 VSS.t1994 17.0005
R11539 VSS.n2490 VSS.t1994 17.0005
R11540 VSS.n2493 VSS.t1994 17.0005
R11541 VSS.n2494 VSS.t1994 17.0005
R11542 VSS.n2495 VSS.t1994 17.0005
R11543 VSS.n2497 VSS.t1994 17.0005
R11544 VSS.n2498 VSS.t1994 17.0005
R11545 VSS.n3374 VSS.t1479 17.0005
R11546 VSS.n3375 VSS.t1479 17.0005
R11547 VSS.n3376 VSS.t1479 17.0005
R11548 VSS.n3379 VSS.t1479 17.0005
R11549 VSS.n3380 VSS.t1479 17.0005
R11550 VSS.n3381 VSS.t1479 17.0005
R11551 VSS.n3383 VSS.t1479 17.0005
R11552 VSS.n3384 VSS.t1479 17.0005
R11553 VSS.n2414 VSS.t2256 17.0005
R11554 VSS.n2415 VSS.t2256 17.0005
R11555 VSS.n2416 VSS.t2256 17.0005
R11556 VSS.n2419 VSS.t2256 17.0005
R11557 VSS.n2420 VSS.t2256 17.0005
R11558 VSS.n2421 VSS.t2256 17.0005
R11559 VSS.n2423 VSS.t2256 17.0005
R11560 VSS.n2424 VSS.t2256 17.0005
R11561 VSS.n1829 VSS.n1824 17.0005
R11562 VSS.n1829 VSS.n1825 17.0005
R11563 VSS.n1829 VSS.n1823 17.0005
R11564 VSS.n1829 VSS.n1789 17.0005
R11565 VSS.n1829 VSS.n1780 17.0005
R11566 VSS.n1829 VSS.n1790 17.0005
R11567 VSS.n1829 VSS.n1779 17.0005
R11568 VSS.n1829 VSS.n1791 17.0005
R11569 VSS.n1829 VSS.n1777 17.0005
R11570 VSS.n1829 VSS.n1792 17.0005
R11571 VSS.n1829 VSS.n1776 17.0005
R11572 VSS.n1829 VSS.n1796 17.0005
R11573 VSS.n1829 VSS.n1822 17.0005
R11574 VSS.n4010 VSS.n1829 17.0005
R11575 VSS.n1829 VSS.n1821 17.0005
R11576 VSS.n1829 VSS.n1808 17.0005
R11577 VSS.n3992 VSS.n1807 17.0005
R11578 VSS.n1807 VSS.n1787 17.0005
R11579 VSS.n3994 VSS.n1807 17.0005
R11580 VSS.n1807 VSS.n1785 17.0005
R11581 VSS.n3636 VSS.n1807 17.0005
R11582 VSS.n1807 VSS.n1788 17.0005
R11583 VSS.n1807 VSS.n1780 17.0005
R11584 VSS.n1807 VSS.n1790 17.0005
R11585 VSS.n1807 VSS.n1779 17.0005
R11586 VSS.n1807 VSS.n1791 17.0005
R11587 VSS.n1807 VSS.n1777 17.0005
R11588 VSS.n1807 VSS.n1792 17.0005
R11589 VSS.n1807 VSS.n1776 17.0005
R11590 VSS.n1807 VSS.n1795 17.0005
R11591 VSS.n1807 VSS.n1775 17.0005
R11592 VSS.n1807 VSS.n1796 17.0005
R11593 VSS.n1807 VSS.n1774 17.0005
R11594 VSS.n1807 VSS.n1802 17.0005
R11595 VSS.n1807 VSS.n1772 17.0005
R11596 VSS.n4030 VSS.n1807 17.0005
R11597 VSS.n4003 VSS.n1824 17.0005
R11598 VSS.n4003 VSS.n1825 17.0005
R11599 VSS.n4003 VSS.n1823 17.0005
R11600 VSS.n4003 VSS.n1789 17.0005
R11601 VSS.n4003 VSS.n1780 17.0005
R11602 VSS.n4003 VSS.n1790 17.0005
R11603 VSS.n4003 VSS.n1779 17.0005
R11604 VSS.n4003 VSS.n1791 17.0005
R11605 VSS.n4003 VSS.n1777 17.0005
R11606 VSS.n4003 VSS.n1792 17.0005
R11607 VSS.n4003 VSS.n1776 17.0005
R11608 VSS.n4003 VSS.n1795 17.0005
R11609 VSS.n4003 VSS.n1775 17.0005
R11610 VSS.n4003 VSS.n1796 17.0005
R11611 VSS.n4003 VSS.n1822 17.0005
R11612 VSS.n4010 VSS.n4003 17.0005
R11613 VSS.n4003 VSS.n1821 17.0005
R11614 VSS.n4003 VSS.n1808 17.0005
R11615 VSS.n3842 VSS.n1809 17.0005
R11616 VSS.n1809 VSS.n1787 17.0005
R11617 VSS.n3840 VSS.n1809 17.0005
R11618 VSS.n1809 VSS.n1785 17.0005
R11619 VSS.n3837 VSS.n1809 17.0005
R11620 VSS.n1809 VSS.n1788 17.0005
R11621 VSS.n1809 VSS.n1784 17.0005
R11622 VSS.n1809 VSS.n1789 17.0005
R11623 VSS.n1809 VSS.n1780 17.0005
R11624 VSS.n1809 VSS.n1790 17.0005
R11625 VSS.n1809 VSS.n1779 17.0005
R11626 VSS.n1809 VSS.n1791 17.0005
R11627 VSS.n1809 VSS.n1777 17.0005
R11628 VSS.n1809 VSS.n1792 17.0005
R11629 VSS.n1809 VSS.n1776 17.0005
R11630 VSS.n1809 VSS.n1795 17.0005
R11631 VSS.n1809 VSS.n1775 17.0005
R11632 VSS.n1809 VSS.n1796 17.0005
R11633 VSS.n1809 VSS.n1774 17.0005
R11634 VSS.n1809 VSS.n1802 17.0005
R11635 VSS.n1809 VSS.n1772 17.0005
R11636 VSS.n4030 VSS.n1809 17.0005
R11637 VSS.n1827 VSS.n1824 17.0005
R11638 VSS.n1827 VSS.n1825 17.0005
R11639 VSS.n1827 VSS.n1823 17.0005
R11640 VSS.n1827 VSS.n1789 17.0005
R11641 VSS.n1827 VSS.n1780 17.0005
R11642 VSS.n1827 VSS.n1790 17.0005
R11643 VSS.n1827 VSS.n1779 17.0005
R11644 VSS.n1827 VSS.n1791 17.0005
R11645 VSS.n1827 VSS.n1777 17.0005
R11646 VSS.n1827 VSS.n1792 17.0005
R11647 VSS.n1827 VSS.n1776 17.0005
R11648 VSS.n1827 VSS.n1795 17.0005
R11649 VSS.n1827 VSS.n1775 17.0005
R11650 VSS.n1827 VSS.n1796 17.0005
R11651 VSS.n1827 VSS.n1822 17.0005
R11652 VSS.n4010 VSS.n1827 17.0005
R11653 VSS.n1827 VSS.n1821 17.0005
R11654 VSS.n1827 VSS.n1808 17.0005
R11655 VSS.n3909 VSS.n1805 17.0005
R11656 VSS.n1805 VSS.n1787 17.0005
R11657 VSS.n3907 VSS.n1805 17.0005
R11658 VSS.n1805 VSS.n1785 17.0005
R11659 VSS.n3904 VSS.n1805 17.0005
R11660 VSS.n1805 VSS.n1788 17.0005
R11661 VSS.n1805 VSS.n1784 17.0005
R11662 VSS.n1805 VSS.n1789 17.0005
R11663 VSS.n1805 VSS.n1780 17.0005
R11664 VSS.n1805 VSS.n1790 17.0005
R11665 VSS.n1805 VSS.n1779 17.0005
R11666 VSS.n1805 VSS.n1791 17.0005
R11667 VSS.n1805 VSS.n1777 17.0005
R11668 VSS.n1805 VSS.n1792 17.0005
R11669 VSS.n1805 VSS.n1776 17.0005
R11670 VSS.n1805 VSS.n1795 17.0005
R11671 VSS.n1805 VSS.n1775 17.0005
R11672 VSS.n1805 VSS.n1796 17.0005
R11673 VSS.n1805 VSS.n1774 17.0005
R11674 VSS.n1805 VSS.n1802 17.0005
R11675 VSS.n1805 VSS.n1772 17.0005
R11676 VSS.n4030 VSS.n1805 17.0005
R11677 VSS.n4011 VSS.n1824 17.0005
R11678 VSS.n4011 VSS.n1825 17.0005
R11679 VSS.n4011 VSS.n1823 17.0005
R11680 VSS.n4011 VSS.n1789 17.0005
R11681 VSS.n4011 VSS.n1780 17.0005
R11682 VSS.n4011 VSS.n1790 17.0005
R11683 VSS.n4011 VSS.n1779 17.0005
R11684 VSS.n4011 VSS.n1791 17.0005
R11685 VSS.n4011 VSS.n1777 17.0005
R11686 VSS.n4011 VSS.n1792 17.0005
R11687 VSS.n4011 VSS.n1776 17.0005
R11688 VSS.n4011 VSS.n1795 17.0005
R11689 VSS.n4011 VSS.n1775 17.0005
R11690 VSS.n4011 VSS.n1796 17.0005
R11691 VSS.n4011 VSS.n1822 17.0005
R11692 VSS.n4011 VSS.n4010 17.0005
R11693 VSS.n4011 VSS.n1821 17.0005
R11694 VSS.n4011 VSS.n1808 17.0005
R11695 VSS.n4029 VSS.n1817 17.0005
R11696 VSS.n4029 VSS.n1787 17.0005
R11697 VSS.n4029 VSS.n1814 17.0005
R11698 VSS.n4029 VSS.n1785 17.0005
R11699 VSS.n4029 VSS.n4021 17.0005
R11700 VSS.n4029 VSS.n1788 17.0005
R11701 VSS.n4029 VSS.n1784 17.0005
R11702 VSS.n4029 VSS.n1789 17.0005
R11703 VSS.n4029 VSS.n1780 17.0005
R11704 VSS.n4029 VSS.n1790 17.0005
R11705 VSS.n4029 VSS.n1779 17.0005
R11706 VSS.n4029 VSS.n1791 17.0005
R11707 VSS.n4029 VSS.n1777 17.0005
R11708 VSS.n4029 VSS.n1792 17.0005
R11709 VSS.n4029 VSS.n1776 17.0005
R11710 VSS.n4029 VSS.n1795 17.0005
R11711 VSS.n4029 VSS.n1775 17.0005
R11712 VSS.n4029 VSS.n1796 17.0005
R11713 VSS.n4029 VSS.n1774 17.0005
R11714 VSS.n4029 VSS.n1802 17.0005
R11715 VSS.n4029 VSS.n1772 17.0005
R11716 VSS.n4030 VSS.n4029 17.0005
R11717 VSS.n1826 VSS.n1824 17.0005
R11718 VSS.n1826 VSS.n1825 17.0005
R11719 VSS.n1826 VSS.n1823 17.0005
R11720 VSS.n1826 VSS.n1789 17.0005
R11721 VSS.n1826 VSS.n1780 17.0005
R11722 VSS.n1826 VSS.n1790 17.0005
R11723 VSS.n1826 VSS.n1779 17.0005
R11724 VSS.n1826 VSS.n1791 17.0005
R11725 VSS.n1826 VSS.n1777 17.0005
R11726 VSS.n1826 VSS.n1792 17.0005
R11727 VSS.n1826 VSS.n1776 17.0005
R11728 VSS.n1826 VSS.n1795 17.0005
R11729 VSS.n1826 VSS.n1775 17.0005
R11730 VSS.n1826 VSS.n1796 17.0005
R11731 VSS.n1826 VSS.n1822 17.0005
R11732 VSS.n4010 VSS.n1826 17.0005
R11733 VSS.n1826 VSS.n1821 17.0005
R11734 VSS.n1826 VSS.n1808 17.0005
R11735 VSS.n3983 VSS.n1804 17.0005
R11736 VSS.n1804 VSS.n1787 17.0005
R11737 VSS.n3981 VSS.n1804 17.0005
R11738 VSS.n1804 VSS.n1785 17.0005
R11739 VSS.n3971 VSS.n1804 17.0005
R11740 VSS.n1804 VSS.n1788 17.0005
R11741 VSS.n1804 VSS.n1784 17.0005
R11742 VSS.n1804 VSS.n1789 17.0005
R11743 VSS.n1804 VSS.n1780 17.0005
R11744 VSS.n1804 VSS.n1790 17.0005
R11745 VSS.n1804 VSS.n1779 17.0005
R11746 VSS.n1804 VSS.n1791 17.0005
R11747 VSS.n1804 VSS.n1777 17.0005
R11748 VSS.n1804 VSS.n1792 17.0005
R11749 VSS.n1804 VSS.n1776 17.0005
R11750 VSS.n1804 VSS.n1795 17.0005
R11751 VSS.n1804 VSS.n1775 17.0005
R11752 VSS.n1804 VSS.n1796 17.0005
R11753 VSS.n1804 VSS.n1774 17.0005
R11754 VSS.n1804 VSS.n1802 17.0005
R11755 VSS.n1804 VSS.n1772 17.0005
R11756 VSS.n4030 VSS.n1804 17.0005
R11757 VSS.n4009 VSS.n1824 17.0005
R11758 VSS.n4009 VSS.n1825 17.0005
R11759 VSS.n4009 VSS.n1823 17.0005
R11760 VSS.n4009 VSS.n1789 17.0005
R11761 VSS.n4009 VSS.n1780 17.0005
R11762 VSS.n4009 VSS.n1790 17.0005
R11763 VSS.n4009 VSS.n1779 17.0005
R11764 VSS.n4009 VSS.n1791 17.0005
R11765 VSS.n4009 VSS.n1777 17.0005
R11766 VSS.n4009 VSS.n1792 17.0005
R11767 VSS.n4009 VSS.n1776 17.0005
R11768 VSS.n4009 VSS.n1795 17.0005
R11769 VSS.n4009 VSS.n1775 17.0005
R11770 VSS.n4009 VSS.n1796 17.0005
R11771 VSS.n4009 VSS.n1822 17.0005
R11772 VSS.n4010 VSS.n4009 17.0005
R11773 VSS.n4009 VSS.n1821 17.0005
R11774 VSS.n4009 VSS.n1808 17.0005
R11775 VSS.n4031 VSS.n1786 17.0005
R11776 VSS.n4031 VSS.n1787 17.0005
R11777 VSS.n4032 VSS.n4031 17.0005
R11778 VSS.n4031 VSS.n1785 17.0005
R11779 VSS.n4031 VSS.n1769 17.0005
R11780 VSS.n4031 VSS.n1788 17.0005
R11781 VSS.n4031 VSS.n1784 17.0005
R11782 VSS.n4031 VSS.n1789 17.0005
R11783 VSS.n4031 VSS.n1780 17.0005
R11784 VSS.n4031 VSS.n1790 17.0005
R11785 VSS.n4031 VSS.n1779 17.0005
R11786 VSS.n4031 VSS.n1791 17.0005
R11787 VSS.n4031 VSS.n1777 17.0005
R11788 VSS.n4031 VSS.n1792 17.0005
R11789 VSS.n4031 VSS.n1776 17.0005
R11790 VSS.n4031 VSS.n1795 17.0005
R11791 VSS.n4031 VSS.n1775 17.0005
R11792 VSS.n4031 VSS.n1796 17.0005
R11793 VSS.n4031 VSS.n1774 17.0005
R11794 VSS.n4031 VSS.n1802 17.0005
R11795 VSS.n4031 VSS.n1772 17.0005
R11796 VSS.n4031 VSS.n4030 17.0005
R11797 VSS.n2156 VSS.n2140 17.0005
R11798 VSS.n2156 VSS.n2141 17.0005
R11799 VSS.n2156 VSS.n2139 17.0005
R11800 VSS.n2156 VSS.n2142 17.0005
R11801 VSS.n2156 VSS.n2138 17.0005
R11802 VSS.n2156 VSS.n2143 17.0005
R11803 VSS.n2156 VSS.n2137 17.0005
R11804 VSS.n2156 VSS.n2144 17.0005
R11805 VSS.n2156 VSS.n2136 17.0005
R11806 VSS.n2156 VSS.n2145 17.0005
R11807 VSS.n2156 VSS.n2135 17.0005
R11808 VSS.n2156 VSS.n2147 17.0005
R11809 VSS.n2156 VSS.n2133 17.0005
R11810 VSS.n2156 VSS.n2148 17.0005
R11811 VSS.n2156 VSS.n2132 17.0005
R11812 VSS.n3541 VSS.n2156 17.0005
R11813 VSS.n3542 VSS.n2140 17.0005
R11814 VSS.n3542 VSS.n2141 17.0005
R11815 VSS.n3542 VSS.n2139 17.0005
R11816 VSS.n3542 VSS.n2142 17.0005
R11817 VSS.n3542 VSS.n2138 17.0005
R11818 VSS.n3542 VSS.n2143 17.0005
R11819 VSS.n3542 VSS.n2137 17.0005
R11820 VSS.n3542 VSS.n2144 17.0005
R11821 VSS.n3542 VSS.n2136 17.0005
R11822 VSS.n3542 VSS.n2145 17.0005
R11823 VSS.n3542 VSS.n2135 17.0005
R11824 VSS.n3542 VSS.n2146 17.0005
R11825 VSS.n3542 VSS.n2134 17.0005
R11826 VSS.n3542 VSS.n2147 17.0005
R11827 VSS.n3542 VSS.n2133 17.0005
R11828 VSS.n3542 VSS.n2148 17.0005
R11829 VSS.n3542 VSS.n2132 17.0005
R11830 VSS.n3542 VSS.n3541 17.0005
R11831 VSS.n3539 VSS.n2167 17.0005
R11832 VSS.n3539 VSS.n3525 17.0005
R11833 VSS.n3539 VSS.n2164 17.0005
R11834 VSS.n3539 VSS.n2163 17.0005
R11835 VSS.n3539 VSS.n3529 17.0005
R11836 VSS.n3539 VSS.n3530 17.0005
R11837 VSS.n3539 VSS.n2138 17.0005
R11838 VSS.n3539 VSS.n2143 17.0005
R11839 VSS.n3539 VSS.n2137 17.0005
R11840 VSS.n3539 VSS.n2144 17.0005
R11841 VSS.n3539 VSS.n2136 17.0005
R11842 VSS.n3539 VSS.n2145 17.0005
R11843 VSS.n3539 VSS.n2135 17.0005
R11844 VSS.n3539 VSS.n2146 17.0005
R11845 VSS.n3539 VSS.n2134 17.0005
R11846 VSS.n3539 VSS.n2147 17.0005
R11847 VSS.n3539 VSS.n2158 17.0005
R11848 VSS.n3539 VSS.n3538 17.0005
R11849 VSS.n3540 VSS.n3539 17.0005
R11850 VSS.n3539 VSS.n2149 17.0005
R11851 VSS.t2627 VSS.n2198 17.0005
R11852 VSS.t2627 VSS.n2195 17.0005
R11853 VSS.n2213 VSS.t2627 17.0005
R11854 VSS.t2627 VSS.n2209 17.0005
R11855 VSS.t2627 VSS.n2191 17.0005
R11856 VSS.t2627 VSS.n2176 17.0005
R11857 VSS.t2627 VSS.n2175 17.0005
R11858 VSS.t2627 VSS.n2178 17.0005
R11859 VSS.t2627 VSS.n2182 17.0005
R11860 VSS.t2627 VSS.n2171 17.0005
R11861 VSS.t2627 VSS.n2183 17.0005
R11862 VSS.t2627 VSS.n2169 17.0005
R11863 VSS.t2627 VSS.n2186 17.0005
R11864 VSS.n3935 VSS.t2658 17.0005
R11865 VSS.n3936 VSS.t2658 17.0005
R11866 VSS.n3937 VSS.t2658 17.0005
R11867 VSS.n3940 VSS.t2658 17.0005
R11868 VSS.n3941 VSS.t2658 17.0005
R11869 VSS.n3942 VSS.t2658 17.0005
R11870 VSS.n3944 VSS.t2658 17.0005
R11871 VSS.n3945 VSS.t2658 17.0005
R11872 VSS.n3868 VSS.t1449 17.0005
R11873 VSS.n3869 VSS.t1449 17.0005
R11874 VSS.n3870 VSS.t1449 17.0005
R11875 VSS.n3873 VSS.t1449 17.0005
R11876 VSS.n3874 VSS.t1449 17.0005
R11877 VSS.n3875 VSS.t1449 17.0005
R11878 VSS.n3877 VSS.t1449 17.0005
R11879 VSS.n3878 VSS.t1449 17.0005
R11880 VSS.n3661 VSS.t1963 17.0005
R11881 VSS.n3662 VSS.t1963 17.0005
R11882 VSS.n3663 VSS.t1963 17.0005
R11883 VSS.n3666 VSS.t1963 17.0005
R11884 VSS.n3667 VSS.t1963 17.0005
R11885 VSS.n3668 VSS.t1963 17.0005
R11886 VSS.n3670 VSS.t1963 17.0005
R11887 VSS.n3671 VSS.t1963 17.0005
R11888 VSS.n3801 VSS.t1704 17.0005
R11889 VSS.n3802 VSS.t1704 17.0005
R11890 VSS.n3803 VSS.t1704 17.0005
R11891 VSS.n3806 VSS.t1704 17.0005
R11892 VSS.n3807 VSS.t1704 17.0005
R11893 VSS.n3808 VSS.t1704 17.0005
R11894 VSS.n3810 VSS.t1704 17.0005
R11895 VSS.n3811 VSS.t1704 17.0005
R11896 VSS.n3753 VSS.t1148 17.0005
R11897 VSS.n3754 VSS.t1148 17.0005
R11898 VSS.n3755 VSS.t1148 17.0005
R11899 VSS.n3758 VSS.t1148 17.0005
R11900 VSS.n3759 VSS.t1148 17.0005
R11901 VSS.n3760 VSS.t1148 17.0005
R11902 VSS.n3762 VSS.t1148 17.0005
R11903 VSS.n3763 VSS.t1148 17.0005
R11904 VSS.n3705 VSS.t3263 17.0005
R11905 VSS.n3706 VSS.t3263 17.0005
R11906 VSS.n3707 VSS.t3263 17.0005
R11907 VSS.n3710 VSS.t3263 17.0005
R11908 VSS.n3711 VSS.t3263 17.0005
R11909 VSS.n3712 VSS.t3263 17.0005
R11910 VSS.n3714 VSS.t3263 17.0005
R11911 VSS.n3715 VSS.t3263 17.0005
R11912 VSS.n1351 VSS.n1345 17.0005
R11913 VSS.n1351 VSS.n1346 17.0005
R11914 VSS.n1351 VSS.n1344 17.0005
R11915 VSS.n1351 VSS.n1309 17.0005
R11916 VSS.n1351 VSS.n1299 17.0005
R11917 VSS.n1351 VSS.n1310 17.0005
R11918 VSS.n1351 VSS.n1298 17.0005
R11919 VSS.n1351 VSS.n1311 17.0005
R11920 VSS.n1351 VSS.n1296 17.0005
R11921 VSS.n1351 VSS.n1312 17.0005
R11922 VSS.n1351 VSS.n1295 17.0005
R11923 VSS.n1351 VSS.n1316 17.0005
R11924 VSS.n1351 VSS.n1343 17.0005
R11925 VSS.n4145 VSS.n1351 17.0005
R11926 VSS.n1351 VSS.n1342 17.0005
R11927 VSS.n1351 VSS.n1326 17.0005
R11928 VSS.n3094 VSS.n1328 17.0005
R11929 VSS.n1328 VSS.n1305 17.0005
R11930 VSS.n3092 VSS.n1328 17.0005
R11931 VSS.n1328 VSS.n1303 17.0005
R11932 VSS.n2999 VSS.n1328 17.0005
R11933 VSS.n1328 VSS.n1308 17.0005
R11934 VSS.n1328 VSS.n1299 17.0005
R11935 VSS.n1328 VSS.n1310 17.0005
R11936 VSS.n1328 VSS.n1298 17.0005
R11937 VSS.n1328 VSS.n1311 17.0005
R11938 VSS.n1328 VSS.n1296 17.0005
R11939 VSS.n1328 VSS.n1312 17.0005
R11940 VSS.n1328 VSS.n1295 17.0005
R11941 VSS.n1328 VSS.n1315 17.0005
R11942 VSS.n1328 VSS.n1294 17.0005
R11943 VSS.n1328 VSS.n1316 17.0005
R11944 VSS.n1328 VSS.n1293 17.0005
R11945 VSS.n1328 VSS.n1322 17.0005
R11946 VSS.n1328 VSS.n1291 17.0005
R11947 VSS.n4165 VSS.n1328 17.0005
R11948 VSS.n1349 VSS.n1345 17.0005
R11949 VSS.n1349 VSS.n1346 17.0005
R11950 VSS.n1349 VSS.n1344 17.0005
R11951 VSS.n1349 VSS.n1309 17.0005
R11952 VSS.n1349 VSS.n1299 17.0005
R11953 VSS.n1349 VSS.n1310 17.0005
R11954 VSS.n1349 VSS.n1298 17.0005
R11955 VSS.n1349 VSS.n1311 17.0005
R11956 VSS.n1349 VSS.n1296 17.0005
R11957 VSS.n1349 VSS.n1312 17.0005
R11958 VSS.n1349 VSS.n1295 17.0005
R11959 VSS.n1349 VSS.n1315 17.0005
R11960 VSS.n1349 VSS.n1294 17.0005
R11961 VSS.n1349 VSS.n1316 17.0005
R11962 VSS.n1349 VSS.n1343 17.0005
R11963 VSS.n4145 VSS.n1349 17.0005
R11964 VSS.n1349 VSS.n1342 17.0005
R11965 VSS.n1349 VSS.n1326 17.0005
R11966 VSS.n3313 VSS.n1325 17.0005
R11967 VSS.n1325 VSS.n1305 17.0005
R11968 VSS.n3315 VSS.n1325 17.0005
R11969 VSS.n1325 VSS.n1303 17.0005
R11970 VSS.n2867 VSS.n1325 17.0005
R11971 VSS.n1325 VSS.n1308 17.0005
R11972 VSS.n1325 VSS.n1302 17.0005
R11973 VSS.n1325 VSS.n1309 17.0005
R11974 VSS.n1325 VSS.n1299 17.0005
R11975 VSS.n1325 VSS.n1310 17.0005
R11976 VSS.n1325 VSS.n1298 17.0005
R11977 VSS.n1325 VSS.n1311 17.0005
R11978 VSS.n1325 VSS.n1296 17.0005
R11979 VSS.n1325 VSS.n1312 17.0005
R11980 VSS.n1325 VSS.n1295 17.0005
R11981 VSS.n1325 VSS.n1315 17.0005
R11982 VSS.n1325 VSS.n1294 17.0005
R11983 VSS.n1325 VSS.n1316 17.0005
R11984 VSS.n1325 VSS.n1293 17.0005
R11985 VSS.n1325 VSS.n1322 17.0005
R11986 VSS.n1325 VSS.n1291 17.0005
R11987 VSS.n4165 VSS.n1325 17.0005
R11988 VSS.n1352 VSS.n1345 17.0005
R11989 VSS.n1352 VSS.n1346 17.0005
R11990 VSS.n1352 VSS.n1344 17.0005
R11991 VSS.n1352 VSS.n1309 17.0005
R11992 VSS.n1352 VSS.n1299 17.0005
R11993 VSS.n1352 VSS.n1310 17.0005
R11994 VSS.n1352 VSS.n1298 17.0005
R11995 VSS.n1352 VSS.n1311 17.0005
R11996 VSS.n1352 VSS.n1296 17.0005
R11997 VSS.n1352 VSS.n1312 17.0005
R11998 VSS.n1352 VSS.n1295 17.0005
R11999 VSS.n1352 VSS.n1315 17.0005
R12000 VSS.n1352 VSS.n1294 17.0005
R12001 VSS.n1352 VSS.n1316 17.0005
R12002 VSS.n1352 VSS.n1343 17.0005
R12003 VSS.n4145 VSS.n1352 17.0005
R12004 VSS.n1352 VSS.n1342 17.0005
R12005 VSS.n1352 VSS.n1326 17.0005
R12006 VSS.n3165 VSS.n1329 17.0005
R12007 VSS.n1329 VSS.n1305 17.0005
R12008 VSS.n3163 VSS.n1329 17.0005
R12009 VSS.n1329 VSS.n1303 17.0005
R12010 VSS.n3153 VSS.n1329 17.0005
R12011 VSS.n1329 VSS.n1308 17.0005
R12012 VSS.n1329 VSS.n1302 17.0005
R12013 VSS.n1329 VSS.n1309 17.0005
R12014 VSS.n1329 VSS.n1299 17.0005
R12015 VSS.n1329 VSS.n1310 17.0005
R12016 VSS.n1329 VSS.n1298 17.0005
R12017 VSS.n1329 VSS.n1311 17.0005
R12018 VSS.n1329 VSS.n1296 17.0005
R12019 VSS.n1329 VSS.n1312 17.0005
R12020 VSS.n1329 VSS.n1295 17.0005
R12021 VSS.n1329 VSS.n1315 17.0005
R12022 VSS.n1329 VSS.n1294 17.0005
R12023 VSS.n1329 VSS.n1316 17.0005
R12024 VSS.n1329 VSS.n1293 17.0005
R12025 VSS.n1329 VSS.n1322 17.0005
R12026 VSS.n1329 VSS.n1291 17.0005
R12027 VSS.n4165 VSS.n1329 17.0005
R12028 VSS.n1348 VSS.n1345 17.0005
R12029 VSS.n1348 VSS.n1346 17.0005
R12030 VSS.n1348 VSS.n1344 17.0005
R12031 VSS.n1348 VSS.n1309 17.0005
R12032 VSS.n1348 VSS.n1299 17.0005
R12033 VSS.n1348 VSS.n1310 17.0005
R12034 VSS.n1348 VSS.n1298 17.0005
R12035 VSS.n1348 VSS.n1311 17.0005
R12036 VSS.n1348 VSS.n1296 17.0005
R12037 VSS.n1348 VSS.n1312 17.0005
R12038 VSS.n1348 VSS.n1295 17.0005
R12039 VSS.n1348 VSS.n1315 17.0005
R12040 VSS.n1348 VSS.n1294 17.0005
R12041 VSS.n1348 VSS.n1316 17.0005
R12042 VSS.n1348 VSS.n1343 17.0005
R12043 VSS.n4145 VSS.n1348 17.0005
R12044 VSS.n1348 VSS.n1342 17.0005
R12045 VSS.n1348 VSS.n1326 17.0005
R12046 VSS.n2940 VSS.n1324 17.0005
R12047 VSS.n1324 VSS.n1305 17.0005
R12048 VSS.n2938 VSS.n1324 17.0005
R12049 VSS.n1324 VSS.n1303 17.0005
R12050 VSS.n2935 VSS.n1324 17.0005
R12051 VSS.n1324 VSS.n1308 17.0005
R12052 VSS.n1324 VSS.n1302 17.0005
R12053 VSS.n1324 VSS.n1309 17.0005
R12054 VSS.n1324 VSS.n1299 17.0005
R12055 VSS.n1324 VSS.n1310 17.0005
R12056 VSS.n1324 VSS.n1298 17.0005
R12057 VSS.n1324 VSS.n1311 17.0005
R12058 VSS.n1324 VSS.n1296 17.0005
R12059 VSS.n1324 VSS.n1312 17.0005
R12060 VSS.n1324 VSS.n1295 17.0005
R12061 VSS.n1324 VSS.n1315 17.0005
R12062 VSS.n1324 VSS.n1294 17.0005
R12063 VSS.n1324 VSS.n1316 17.0005
R12064 VSS.n1324 VSS.n1293 17.0005
R12065 VSS.n1324 VSS.n1322 17.0005
R12066 VSS.n1324 VSS.n1291 17.0005
R12067 VSS.n4165 VSS.n1324 17.0005
R12068 VSS.n4144 VSS.n1345 17.0005
R12069 VSS.n4144 VSS.n1346 17.0005
R12070 VSS.n4144 VSS.n1344 17.0005
R12071 VSS.n4144 VSS.n1309 17.0005
R12072 VSS.n4144 VSS.n1299 17.0005
R12073 VSS.n4144 VSS.n1310 17.0005
R12074 VSS.n4144 VSS.n1298 17.0005
R12075 VSS.n4144 VSS.n1311 17.0005
R12076 VSS.n4144 VSS.n1296 17.0005
R12077 VSS.n4144 VSS.n1312 17.0005
R12078 VSS.n4144 VSS.n1295 17.0005
R12079 VSS.n4144 VSS.n1315 17.0005
R12080 VSS.n4144 VSS.n1294 17.0005
R12081 VSS.n4144 VSS.n1316 17.0005
R12082 VSS.n4144 VSS.n1343 17.0005
R12083 VSS.n4145 VSS.n4144 17.0005
R12084 VSS.n4144 VSS.n1342 17.0005
R12085 VSS.n4144 VSS.n1326 17.0005
R12086 VSS.n3229 VSS.n1330 17.0005
R12087 VSS.n1330 VSS.n1305 17.0005
R12088 VSS.n3226 VSS.n1330 17.0005
R12089 VSS.n1330 VSS.n1303 17.0005
R12090 VSS.n3224 VSS.n1330 17.0005
R12091 VSS.n1330 VSS.n1308 17.0005
R12092 VSS.n1330 VSS.n1302 17.0005
R12093 VSS.n1330 VSS.n1309 17.0005
R12094 VSS.n1330 VSS.n1299 17.0005
R12095 VSS.n1330 VSS.n1310 17.0005
R12096 VSS.n1330 VSS.n1298 17.0005
R12097 VSS.n1330 VSS.n1311 17.0005
R12098 VSS.n1330 VSS.n1296 17.0005
R12099 VSS.n1330 VSS.n1312 17.0005
R12100 VSS.n1330 VSS.n1295 17.0005
R12101 VSS.n1330 VSS.n1315 17.0005
R12102 VSS.n1330 VSS.n1294 17.0005
R12103 VSS.n1330 VSS.n1316 17.0005
R12104 VSS.n1330 VSS.n1293 17.0005
R12105 VSS.n1330 VSS.n1322 17.0005
R12106 VSS.n1330 VSS.n1291 17.0005
R12107 VSS.n4165 VSS.n1330 17.0005
R12108 VSS.n1347 VSS.n1345 17.0005
R12109 VSS.n1347 VSS.n1346 17.0005
R12110 VSS.n1347 VSS.n1344 17.0005
R12111 VSS.n1347 VSS.n1309 17.0005
R12112 VSS.n1347 VSS.n1299 17.0005
R12113 VSS.n1347 VSS.n1310 17.0005
R12114 VSS.n1347 VSS.n1298 17.0005
R12115 VSS.n1347 VSS.n1311 17.0005
R12116 VSS.n1347 VSS.n1296 17.0005
R12117 VSS.n1347 VSS.n1312 17.0005
R12118 VSS.n1347 VSS.n1295 17.0005
R12119 VSS.n1347 VSS.n1315 17.0005
R12120 VSS.n1347 VSS.n1294 17.0005
R12121 VSS.n1347 VSS.n1316 17.0005
R12122 VSS.n1347 VSS.n1343 17.0005
R12123 VSS.n4145 VSS.n1347 17.0005
R12124 VSS.n1347 VSS.n1342 17.0005
R12125 VSS.n1347 VSS.n1326 17.0005
R12126 VSS.n4167 VSS.n4166 17.0005
R12127 VSS.n4166 VSS.n1305 17.0005
R12128 VSS.n4166 VSS.n1304 17.0005
R12129 VSS.n4166 VSS.n1303 17.0005
R12130 VSS.n4166 VSS.n1307 17.0005
R12131 VSS.n4166 VSS.n1308 17.0005
R12132 VSS.n4166 VSS.n1302 17.0005
R12133 VSS.n4166 VSS.n1309 17.0005
R12134 VSS.n4166 VSS.n1299 17.0005
R12135 VSS.n4166 VSS.n1310 17.0005
R12136 VSS.n4166 VSS.n1298 17.0005
R12137 VSS.n4166 VSS.n1311 17.0005
R12138 VSS.n4166 VSS.n1296 17.0005
R12139 VSS.n4166 VSS.n1312 17.0005
R12140 VSS.n4166 VSS.n1295 17.0005
R12141 VSS.n4166 VSS.n1315 17.0005
R12142 VSS.n4166 VSS.n1294 17.0005
R12143 VSS.n4166 VSS.n1316 17.0005
R12144 VSS.n4166 VSS.n1293 17.0005
R12145 VSS.n4166 VSS.n1322 17.0005
R12146 VSS.n4166 VSS.n1291 17.0005
R12147 VSS.n4166 VSS.n4165 17.0005
R12148 VSS.n4146 VSS.n1345 17.0005
R12149 VSS.n4146 VSS.n1346 17.0005
R12150 VSS.n4146 VSS.n1344 17.0005
R12151 VSS.n4146 VSS.n1309 17.0005
R12152 VSS.n4146 VSS.n1299 17.0005
R12153 VSS.n4146 VSS.n1310 17.0005
R12154 VSS.n4146 VSS.n1298 17.0005
R12155 VSS.n4146 VSS.n1311 17.0005
R12156 VSS.n4146 VSS.n1296 17.0005
R12157 VSS.n4146 VSS.n1312 17.0005
R12158 VSS.n4146 VSS.n1295 17.0005
R12159 VSS.n4146 VSS.n1315 17.0005
R12160 VSS.n4146 VSS.n1294 17.0005
R12161 VSS.n4146 VSS.n1316 17.0005
R12162 VSS.n4146 VSS.n1343 17.0005
R12163 VSS.n4146 VSS.n4145 17.0005
R12164 VSS.n4146 VSS.n1342 17.0005
R12165 VSS.n4146 VSS.n1326 17.0005
R12166 VSS.n4164 VSS.n1338 17.0005
R12167 VSS.n4164 VSS.n1305 17.0005
R12168 VSS.n4164 VSS.n1335 17.0005
R12169 VSS.n4164 VSS.n1303 17.0005
R12170 VSS.n4164 VSS.n4156 17.0005
R12171 VSS.n4164 VSS.n1308 17.0005
R12172 VSS.n4164 VSS.n1302 17.0005
R12173 VSS.n4164 VSS.n1309 17.0005
R12174 VSS.n4164 VSS.n1299 17.0005
R12175 VSS.n4164 VSS.n1310 17.0005
R12176 VSS.n4164 VSS.n1298 17.0005
R12177 VSS.n4164 VSS.n1311 17.0005
R12178 VSS.n4164 VSS.n1296 17.0005
R12179 VSS.n4164 VSS.n1312 17.0005
R12180 VSS.n4164 VSS.n1295 17.0005
R12181 VSS.n4164 VSS.n1315 17.0005
R12182 VSS.n4164 VSS.n1294 17.0005
R12183 VSS.n4164 VSS.n1316 17.0005
R12184 VSS.n4164 VSS.n1293 17.0005
R12185 VSS.n4164 VSS.n1322 17.0005
R12186 VSS.n4164 VSS.n1291 17.0005
R12187 VSS.n4165 VSS.n4164 17.0005
R12188 VSS.n3513 VSS.n2219 17.0005
R12189 VSS.n3514 VSS.n2219 17.0005
R12190 VSS.n3515 VSS.n2219 17.0005
R12191 VSS.n3516 VSS.n2219 17.0005
R12192 VSS.n3517 VSS.n2219 17.0005
R12193 VSS.n3518 VSS.n2219 17.0005
R12194 VSS.n3520 VSS.n2219 17.0005
R12195 VSS.n3522 VSS.n2219 17.0005
R12196 VSS.n4196 VSS.n1189 17.0005
R12197 VSS.n4196 VSS.n1191 17.0005
R12198 VSS.n4196 VSS.n1188 17.0005
R12199 VSS.n4196 VSS.n1192 17.0005
R12200 VSS.n4196 VSS.n1187 17.0005
R12201 VSS.n4196 VSS.n4193 17.0005
R12202 VSS.n4196 VSS.n1186 17.0005
R12203 VSS.n4196 VSS.n4195 17.0005
R12204 VSS.n5401 VSS.n1169 17.0005
R12205 VSS.n5401 VSS.n5393 17.0005
R12206 VSS.n5401 VSS.n1168 17.0005
R12207 VSS.n5401 VSS.n5394 17.0005
R12208 VSS.n5401 VSS.n1167 17.0005
R12209 VSS.n5402 VSS.n5401 17.0005
R12210 VSS.n5401 VSS.n1166 17.0005
R12211 VSS.n5401 VSS.n5400 17.0005
R12212 VSS.n5380 VSS.n1175 17.0005
R12213 VSS.n5381 VSS.n1175 17.0005
R12214 VSS.n5382 VSS.n1175 17.0005
R12215 VSS.n5383 VSS.n1175 17.0005
R12216 VSS.n5384 VSS.n1175 17.0005
R12217 VSS.n5385 VSS.n1175 17.0005
R12218 VSS.n5387 VSS.n1175 17.0005
R12219 VSS.n5389 VSS.n1175 17.0005
R12220 VSS.n4755 VSS.n4754 17.0005
R12221 VSS.n4756 VSS.n4754 17.0005
R12222 VSS.n4757 VSS.n4754 17.0005
R12223 VSS.n4758 VSS.n4754 17.0005
R12224 VSS.n4759 VSS.n4754 17.0005
R12225 VSS.n4760 VSS.n4754 17.0005
R12226 VSS.n5375 VSS.n4754 17.0005
R12227 VSS.n5377 VSS.n4754 17.0005
R12228 VSS.n4239 VSS.n3 17.0005
R12229 VSS.n4238 VSS.n3 17.0005
R12230 VSS.n4237 VSS.n3 17.0005
R12231 VSS.n4236 VSS.n3 17.0005
R12232 VSS.n4235 VSS.n3 17.0005
R12233 VSS.n4234 VSS.n3 17.0005
R12234 VSS.n4233 VSS.n3 17.0005
R12235 VSS.n7 VSS.n3 17.0005
R12236 VSS.n6236 VSS.n3 17.0005
R12237 VSS.n6237 VSS.n3 17.0005
R12238 VSS.n133 VSS.n16 17.0005
R12239 VSS.n55 VSS.n16 17.0005
R12240 VSS.n51 VSS.n16 17.0005
R12241 VSS.n49 VSS.n16 17.0005
R12242 VSS.n46 VSS.n16 17.0005
R12243 VSS.n45 VSS.n16 17.0005
R12244 VSS.n44 VSS.n16 17.0005
R12245 VSS.n43 VSS.n16 17.0005
R12246 VSS.n40 VSS.n16 17.0005
R12247 VSS.n39 VSS.n16 17.0005
R12248 VSS.n38 VSS.n16 17.0005
R12249 VSS.n6234 VSS.n16 17.0005
R12250 VSS.n16 VSS.n8 17.0005
R12251 VSS.n31 VSS.n16 17.0005
R12252 VSS.n29 VSS.n16 17.0005
R12253 VSS.n27 VSS.n16 17.0005
R12254 VSS.n26 VSS.n16 17.0005
R12255 VSS.n24 VSS.n16 17.0005
R12256 VSS.n54 VSS.n15 17.0005
R12257 VSS.n49 VSS.n15 17.0005
R12258 VSS.n46 VSS.n15 17.0005
R12259 VSS.n45 VSS.n15 17.0005
R12260 VSS.n44 VSS.n15 17.0005
R12261 VSS.n43 VSS.n15 17.0005
R12262 VSS.n40 VSS.n15 17.0005
R12263 VSS.n39 VSS.n15 17.0005
R12264 VSS.n38 VSS.n15 17.0005
R12265 VSS.n6234 VSS.n15 17.0005
R12266 VSS.n15 VSS.n8 17.0005
R12267 VSS.n31 VSS.n15 17.0005
R12268 VSS.n30 VSS.n15 17.0005
R12269 VSS.n28 VSS.n15 17.0005
R12270 VSS.n321 VSS.n310 17.0005
R12271 VSS.n6155 VSS.n321 17.0005
R12272 VSS.n251 VSS.n17 17.0005
R12273 VSS.n55 VSS.n17 17.0005
R12274 VSS.n51 VSS.n17 17.0005
R12275 VSS.n49 VSS.n17 17.0005
R12276 VSS.n46 VSS.n17 17.0005
R12277 VSS.n45 VSS.n17 17.0005
R12278 VSS.n44 VSS.n17 17.0005
R12279 VSS.n43 VSS.n17 17.0005
R12280 VSS.n40 VSS.n17 17.0005
R12281 VSS.n39 VSS.n17 17.0005
R12282 VSS.n38 VSS.n17 17.0005
R12283 VSS.n6234 VSS.n17 17.0005
R12284 VSS.n17 VSS.n8 17.0005
R12285 VSS.n31 VSS.n17 17.0005
R12286 VSS.n29 VSS.n17 17.0005
R12287 VSS.n27 VSS.n17 17.0005
R12288 VSS.n26 VSS.n17 17.0005
R12289 VSS.n24 VSS.n17 17.0005
R12290 VSS.n54 VSS.n14 17.0005
R12291 VSS.n49 VSS.n14 17.0005
R12292 VSS.n46 VSS.n14 17.0005
R12293 VSS.n45 VSS.n14 17.0005
R12294 VSS.n44 VSS.n14 17.0005
R12295 VSS.n43 VSS.n14 17.0005
R12296 VSS.n40 VSS.n14 17.0005
R12297 VSS.n39 VSS.n14 17.0005
R12298 VSS.n38 VSS.n14 17.0005
R12299 VSS.n6234 VSS.n14 17.0005
R12300 VSS.n14 VSS.n8 17.0005
R12301 VSS.n31 VSS.n14 17.0005
R12302 VSS.n30 VSS.n14 17.0005
R12303 VSS.n28 VSS.n14 17.0005
R12304 VSS.n6156 VSS.n310 17.0005
R12305 VSS.n6156 VSS.n6155 17.0005
R12306 VSS.n237 VSS.n18 17.0005
R12307 VSS.n55 VSS.n18 17.0005
R12308 VSS.n51 VSS.n18 17.0005
R12309 VSS.n49 VSS.n18 17.0005
R12310 VSS.n46 VSS.n18 17.0005
R12311 VSS.n45 VSS.n18 17.0005
R12312 VSS.n44 VSS.n18 17.0005
R12313 VSS.n43 VSS.n18 17.0005
R12314 VSS.n40 VSS.n18 17.0005
R12315 VSS.n39 VSS.n18 17.0005
R12316 VSS.n38 VSS.n18 17.0005
R12317 VSS.n6234 VSS.n18 17.0005
R12318 VSS.n18 VSS.n8 17.0005
R12319 VSS.n31 VSS.n18 17.0005
R12320 VSS.n29 VSS.n18 17.0005
R12321 VSS.n27 VSS.n18 17.0005
R12322 VSS.n26 VSS.n18 17.0005
R12323 VSS.n24 VSS.n18 17.0005
R12324 VSS.n54 VSS.n13 17.0005
R12325 VSS.n49 VSS.n13 17.0005
R12326 VSS.n46 VSS.n13 17.0005
R12327 VSS.n45 VSS.n13 17.0005
R12328 VSS.n44 VSS.n13 17.0005
R12329 VSS.n43 VSS.n13 17.0005
R12330 VSS.n40 VSS.n13 17.0005
R12331 VSS.n39 VSS.n13 17.0005
R12332 VSS.n38 VSS.n13 17.0005
R12333 VSS.n6234 VSS.n13 17.0005
R12334 VSS.n13 VSS.n8 17.0005
R12335 VSS.n31 VSS.n13 17.0005
R12336 VSS.n30 VSS.n13 17.0005
R12337 VSS.n28 VSS.n13 17.0005
R12338 VSS.n322 VSS.n310 17.0005
R12339 VSS.n6155 VSS.n322 17.0005
R12340 VSS.n4475 VSS.n19 17.0005
R12341 VSS.n55 VSS.n19 17.0005
R12342 VSS.n51 VSS.n19 17.0005
R12343 VSS.n49 VSS.n19 17.0005
R12344 VSS.n46 VSS.n19 17.0005
R12345 VSS.n45 VSS.n19 17.0005
R12346 VSS.n44 VSS.n19 17.0005
R12347 VSS.n43 VSS.n19 17.0005
R12348 VSS.n40 VSS.n19 17.0005
R12349 VSS.n39 VSS.n19 17.0005
R12350 VSS.n38 VSS.n19 17.0005
R12351 VSS.n6234 VSS.n19 17.0005
R12352 VSS.n19 VSS.n8 17.0005
R12353 VSS.n31 VSS.n19 17.0005
R12354 VSS.n29 VSS.n19 17.0005
R12355 VSS.n27 VSS.n19 17.0005
R12356 VSS.n26 VSS.n19 17.0005
R12357 VSS.n24 VSS.n19 17.0005
R12358 VSS.n54 VSS.n12 17.0005
R12359 VSS.n49 VSS.n12 17.0005
R12360 VSS.n46 VSS.n12 17.0005
R12361 VSS.n45 VSS.n12 17.0005
R12362 VSS.n44 VSS.n12 17.0005
R12363 VSS.n43 VSS.n12 17.0005
R12364 VSS.n40 VSS.n12 17.0005
R12365 VSS.n39 VSS.n12 17.0005
R12366 VSS.n38 VSS.n12 17.0005
R12367 VSS.n6234 VSS.n12 17.0005
R12368 VSS.n12 VSS.n8 17.0005
R12369 VSS.n31 VSS.n12 17.0005
R12370 VSS.n30 VSS.n12 17.0005
R12371 VSS.n28 VSS.n12 17.0005
R12372 VSS.n312 VSS.n310 17.0005
R12373 VSS.n6155 VSS.n312 17.0005
R12374 VSS.n4377 VSS.n20 17.0005
R12375 VSS.n55 VSS.n20 17.0005
R12376 VSS.n51 VSS.n20 17.0005
R12377 VSS.n49 VSS.n20 17.0005
R12378 VSS.n46 VSS.n20 17.0005
R12379 VSS.n45 VSS.n20 17.0005
R12380 VSS.n44 VSS.n20 17.0005
R12381 VSS.n43 VSS.n20 17.0005
R12382 VSS.n40 VSS.n20 17.0005
R12383 VSS.n39 VSS.n20 17.0005
R12384 VSS.n38 VSS.n20 17.0005
R12385 VSS.n6234 VSS.n20 17.0005
R12386 VSS.n20 VSS.n8 17.0005
R12387 VSS.n31 VSS.n20 17.0005
R12388 VSS.n29 VSS.n20 17.0005
R12389 VSS.n27 VSS.n20 17.0005
R12390 VSS.n26 VSS.n20 17.0005
R12391 VSS.n24 VSS.n20 17.0005
R12392 VSS.n54 VSS.n11 17.0005
R12393 VSS.n49 VSS.n11 17.0005
R12394 VSS.n46 VSS.n11 17.0005
R12395 VSS.n45 VSS.n11 17.0005
R12396 VSS.n44 VSS.n11 17.0005
R12397 VSS.n43 VSS.n11 17.0005
R12398 VSS.n40 VSS.n11 17.0005
R12399 VSS.n39 VSS.n11 17.0005
R12400 VSS.n38 VSS.n11 17.0005
R12401 VSS.n6234 VSS.n11 17.0005
R12402 VSS.n11 VSS.n8 17.0005
R12403 VSS.n31 VSS.n11 17.0005
R12404 VSS.n30 VSS.n11 17.0005
R12405 VSS.n28 VSS.n11 17.0005
R12406 VSS.n323 VSS.n310 17.0005
R12407 VSS.n6155 VSS.n323 17.0005
R12408 VSS.n4348 VSS.n21 17.0005
R12409 VSS.n55 VSS.n21 17.0005
R12410 VSS.n51 VSS.n21 17.0005
R12411 VSS.n49 VSS.n21 17.0005
R12412 VSS.n46 VSS.n21 17.0005
R12413 VSS.n45 VSS.n21 17.0005
R12414 VSS.n44 VSS.n21 17.0005
R12415 VSS.n43 VSS.n21 17.0005
R12416 VSS.n40 VSS.n21 17.0005
R12417 VSS.n39 VSS.n21 17.0005
R12418 VSS.n38 VSS.n21 17.0005
R12419 VSS.n6234 VSS.n21 17.0005
R12420 VSS.n21 VSS.n8 17.0005
R12421 VSS.n31 VSS.n21 17.0005
R12422 VSS.n29 VSS.n21 17.0005
R12423 VSS.n27 VSS.n21 17.0005
R12424 VSS.n26 VSS.n21 17.0005
R12425 VSS.n24 VSS.n21 17.0005
R12426 VSS.n54 VSS.n10 17.0005
R12427 VSS.n49 VSS.n10 17.0005
R12428 VSS.n46 VSS.n10 17.0005
R12429 VSS.n45 VSS.n10 17.0005
R12430 VSS.n44 VSS.n10 17.0005
R12431 VSS.n43 VSS.n10 17.0005
R12432 VSS.n40 VSS.n10 17.0005
R12433 VSS.n39 VSS.n10 17.0005
R12434 VSS.n38 VSS.n10 17.0005
R12435 VSS.n6234 VSS.n10 17.0005
R12436 VSS.n10 VSS.n8 17.0005
R12437 VSS.n31 VSS.n10 17.0005
R12438 VSS.n30 VSS.n10 17.0005
R12439 VSS.n28 VSS.n10 17.0005
R12440 VSS.n311 VSS.n310 17.0005
R12441 VSS.n6155 VSS.n311 17.0005
R12442 VSS.n4599 VSS.n22 17.0005
R12443 VSS.n55 VSS.n22 17.0005
R12444 VSS.n46 VSS.n22 17.0005
R12445 VSS.n45 VSS.n22 17.0005
R12446 VSS.n44 VSS.n22 17.0005
R12447 VSS.n43 VSS.n22 17.0005
R12448 VSS.n40 VSS.n22 17.0005
R12449 VSS.n39 VSS.n22 17.0005
R12450 VSS.n38 VSS.n22 17.0005
R12451 VSS.n6234 VSS.n22 17.0005
R12452 VSS.n22 VSS.n8 17.0005
R12453 VSS.n31 VSS.n22 17.0005
R12454 VSS.n29 VSS.n22 17.0005
R12455 VSS.n27 VSS.n22 17.0005
R12456 VSS.n26 VSS.n22 17.0005
R12457 VSS.n24 VSS.n22 17.0005
R12458 VSS.n54 VSS.n9 17.0005
R12459 VSS.n49 VSS.n9 17.0005
R12460 VSS.n46 VSS.n9 17.0005
R12461 VSS.n45 VSS.n9 17.0005
R12462 VSS.n44 VSS.n9 17.0005
R12463 VSS.n43 VSS.n9 17.0005
R12464 VSS.n40 VSS.n9 17.0005
R12465 VSS.n39 VSS.n9 17.0005
R12466 VSS.n38 VSS.n9 17.0005
R12467 VSS.n6234 VSS.n9 17.0005
R12468 VSS.n9 VSS.n8 17.0005
R12469 VSS.n31 VSS.n9 17.0005
R12470 VSS.n30 VSS.n9 17.0005
R12471 VSS.n28 VSS.n9 17.0005
R12472 VSS.n6154 VSS.n310 17.0005
R12473 VSS.n6155 VSS.n6154 17.0005
R12474 VSS.n6233 VSS.n53 17.0005
R12475 VSS.n6233 VSS.n55 17.0005
R12476 VSS.n6233 VSS.n51 17.0005
R12477 VSS.n6233 VSS.n49 17.0005
R12478 VSS.n6233 VSS.n46 17.0005
R12479 VSS.n6233 VSS.n45 17.0005
R12480 VSS.n6233 VSS.n44 17.0005
R12481 VSS.n6233 VSS.n43 17.0005
R12482 VSS.n6233 VSS.n40 17.0005
R12483 VSS.n6233 VSS.n39 17.0005
R12484 VSS.n6233 VSS.n38 17.0005
R12485 VSS.n6234 VSS.n6233 17.0005
R12486 VSS.n6233 VSS.n8 17.0005
R12487 VSS.n6233 VSS.n31 17.0005
R12488 VSS.n6233 VSS.n29 17.0005
R12489 VSS.n6233 VSS.n27 17.0005
R12490 VSS.n6233 VSS.n26 17.0005
R12491 VSS.n6233 VSS.n24 17.0005
R12492 VSS.n6226 VSS.n16 17.0005
R12493 VSS.n6224 VSS.n16 17.0005
R12494 VSS.t2042 VSS.n6228 17.0005
R12495 VSS.n98 VSS.n15 17.0005
R12496 VSS.n95 VSS.n15 17.0005
R12497 VSS.n302 VSS.n17 17.0005
R12498 VSS.n99 VSS.n17 17.0005
R12499 VSS.n304 VSS.n17 17.0005
R12500 VSS.n97 VSS.n17 17.0005
R12501 VSS.t1798 VSS.n175 17.0005
R12502 VSS.t1798 VSS.n280 17.0005
R12503 VSS.t1798 VSS.n277 17.0005
R12504 VSS.t1798 VSS.n275 17.0005
R12505 VSS.t1798 VSS.n286 17.0005
R12506 VSS.t1798 VSS.n274 17.0005
R12507 VSS.t1798 VSS.n288 17.0005
R12508 VSS.t1798 VSS.n271 17.0005
R12509 VSS.t1798 VSS.n290 17.0005
R12510 VSS.t1798 VSS.n264 17.0005
R12511 VSS.t1798 VSS.n263 17.0005
R12512 VSS.t1798 VSS.n298 17.0005
R12513 VSS.t1798 VSS.n254 17.0005
R12514 VSS.n301 VSS.t1798 17.0005
R12515 VSS.t1798 VSS.n300 17.0005
R12516 VSS.n92 VSS.n14 17.0005
R12517 VSS.n89 VSS.n14 17.0005
R12518 VSS.n6168 VSS.n18 17.0005
R12519 VSS.n93 VSS.n18 17.0005
R12520 VSS.n6166 VSS.n18 17.0005
R12521 VSS.n91 VSS.n18 17.0005
R12522 VSS.n6173 VSS.t1538 17.0005
R12523 VSS.t1538 VSS.n204 17.0005
R12524 VSS.t1538 VSS.n201 17.0005
R12525 VSS.t1538 VSS.n199 17.0005
R12526 VSS.t1538 VSS.n210 17.0005
R12527 VSS.t1538 VSS.n198 17.0005
R12528 VSS.t1538 VSS.n212 17.0005
R12529 VSS.t1538 VSS.n195 17.0005
R12530 VSS.t1538 VSS.n215 17.0005
R12531 VSS.t1538 VSS.n188 17.0005
R12532 VSS.t1538 VSS.n187 17.0005
R12533 VSS.t1538 VSS.n223 17.0005
R12534 VSS.t1538 VSS.n178 17.0005
R12535 VSS.t1538 VSS.n6170 17.0005
R12536 VSS.t1538 VSS.n6172 17.0005
R12537 VSS.n86 VSS.n13 17.0005
R12538 VSS.n83 VSS.n13 17.0005
R12539 VSS.n4488 VSS.n19 17.0005
R12540 VSS.n87 VSS.n19 17.0005
R12541 VSS.n4486 VSS.n19 17.0005
R12542 VSS.n85 VSS.n19 17.0005
R12543 VSS.t1280 VSS.n4443 17.0005
R12544 VSS.t1280 VSS.n4444 17.0005
R12545 VSS.t1280 VSS.n4440 17.0005
R12546 VSS.t1280 VSS.n4438 17.0005
R12547 VSS.t1280 VSS.n4450 17.0005
R12548 VSS.t1280 VSS.n4437 17.0005
R12549 VSS.t1280 VSS.n4452 17.0005
R12550 VSS.t1280 VSS.n4434 17.0005
R12551 VSS.t1280 VSS.n4453 17.0005
R12552 VSS.t1280 VSS.n4430 17.0005
R12553 VSS.t1280 VSS.n4429 17.0005
R12554 VSS.t1280 VSS.n4461 17.0005
R12555 VSS.t1280 VSS.n4420 17.0005
R12556 VSS.t1280 VSS.n4490 17.0005
R12557 VSS.t1280 VSS.n4492 17.0005
R12558 VSS.n80 VSS.n12 17.0005
R12559 VSS.n77 VSS.n12 17.0005
R12560 VSS.n4513 VSS.n20 17.0005
R12561 VSS.n81 VSS.n20 17.0005
R12562 VSS.n4515 VSS.n20 17.0005
R12563 VSS.n79 VSS.n20 17.0005
R12564 VSS.t3387 VSS.n4407 17.0005
R12565 VSS.t3387 VSS.n4408 17.0005
R12566 VSS.t3387 VSS.n4404 17.0005
R12567 VSS.t3387 VSS.n4402 17.0005
R12568 VSS.t3387 VSS.n4414 17.0005
R12569 VSS.t3387 VSS.n4401 17.0005
R12570 VSS.t3387 VSS.n4416 17.0005
R12571 VSS.t3387 VSS.n4398 17.0005
R12572 VSS.t3387 VSS.n4501 17.0005
R12573 VSS.t3387 VSS.n4391 17.0005
R12574 VSS.t3387 VSS.n4390 17.0005
R12575 VSS.t3387 VSS.n4509 17.0005
R12576 VSS.t3387 VSS.n4381 17.0005
R12577 VSS.n4512 VSS.t3387 17.0005
R12578 VSS.t3387 VSS.n4511 17.0005
R12579 VSS.n74 VSS.n11 17.0005
R12580 VSS.n71 VSS.n11 17.0005
R12581 VSS.n4532 VSS.n21 17.0005
R12582 VSS.n75 VSS.n21 17.0005
R12583 VSS.n4530 VSS.n21 17.0005
R12584 VSS.n73 VSS.n21 17.0005
R12585 VSS.t2858 VSS.n4316 17.0005
R12586 VSS.t2858 VSS.n4317 17.0005
R12587 VSS.t2858 VSS.n4313 17.0005
R12588 VSS.t2858 VSS.n4311 17.0005
R12589 VSS.t2858 VSS.n4323 17.0005
R12590 VSS.t2858 VSS.n4310 17.0005
R12591 VSS.t2858 VSS.n4325 17.0005
R12592 VSS.t2858 VSS.n4307 17.0005
R12593 VSS.t2858 VSS.n4326 17.0005
R12594 VSS.t2858 VSS.n4303 17.0005
R12595 VSS.t2858 VSS.n4302 17.0005
R12596 VSS.t2858 VSS.n4334 17.0005
R12597 VSS.t2858 VSS.n4293 17.0005
R12598 VSS.t2858 VSS.n4534 17.0005
R12599 VSS.t2858 VSS.n4536 17.0005
R12600 VSS.n68 VSS.n10 17.0005
R12601 VSS.n65 VSS.n10 17.0005
R12602 VSS.n4604 VSS.n22 17.0005
R12603 VSS.n69 VSS.n22 17.0005
R12604 VSS.n4602 VSS.n22 17.0005
R12605 VSS.n67 VSS.n22 17.0005
R12606 VSS.t2981 VSS.n4567 17.0005
R12607 VSS.t2981 VSS.n4568 17.0005
R12608 VSS.t2981 VSS.n4564 17.0005
R12609 VSS.t2981 VSS.n4562 17.0005
R12610 VSS.t2981 VSS.n4574 17.0005
R12611 VSS.t2981 VSS.n4561 17.0005
R12612 VSS.t2981 VSS.n4576 17.0005
R12613 VSS.t2981 VSS.n4558 17.0005
R12614 VSS.t2981 VSS.n4577 17.0005
R12615 VSS.t2981 VSS.n4554 17.0005
R12616 VSS.t2981 VSS.n4553 17.0005
R12617 VSS.t2981 VSS.n4585 17.0005
R12618 VSS.t2981 VSS.n4544 17.0005
R12619 VSS.t2981 VSS.n4606 17.0005
R12620 VSS.t2981 VSS.n4608 17.0005
R12621 VSS.n6233 VSS.n23 17.0005
R12622 VSS.n6233 VSS.n60 17.0005
R12623 VSS.n4727 VSS.n4718 17.0005
R12624 VSS.n4725 VSS.n4713 17.0005
R12625 VSS.n4723 VSS.t2532 17.0005
R12626 VSS.n2224 VSS.t2219 16.8886
R12627 VSS.n3019 VSS.t2191 16.8886
R12628 VSS.n1141 VSS.t2163 16.8886
R12629 VSS.n4799 VSS.t2135 16.8886
R12630 VSS.n4765 VSS.t2107 16.8886
R12631 VSS.n402 VSS.t2079 16.8886
R12632 VSS.n5997 VSS.n415 16.8886
R12633 VSS.n2258 VSS.t2247 16.8585
R12634 VSS.n2298 VSS.t2239 16.8237
R12635 VSS.n2250 VSS.t2211 16.8237
R12636 VSS.n3058 VSS.t2183 16.8237
R12637 VSS.n5420 VSS.t2155 16.8237
R12638 VSS.n4837 VSS.t2127 16.8237
R12639 VSS.n4791 VSS.t2099 16.8237
R12640 VSS.n6003 VSS.t2071 16.8237
R12641 VSS.n4240 VSS.t206 16.5885
R12642 VSS.t2016 VSS.n6201 16.2821
R12643 VSS.n285 VSS.t1758 16.2786
R12644 VSS.n209 VSS.t1496 16.2786
R12645 VSS.n4449 VSS.t1232 16.2786
R12646 VSS.n4413 VSS.t2690 16.2786
R12647 VSS.n4322 VSS.t2851 16.2786
R12648 VSS.n4573 VSS.t3355 16.2786
R12649 VSS.t3189 VSS.n4249 16.2518
R12650 VSS.n546 VSS.t3211 16.2518
R12651 VSS.n5960 VSS.t4208 16.2518
R12652 VSS.n5890 VSS.t4003 16.2518
R12653 VSS.n643 VSS.t2466 16.2518
R12654 VSS.n5681 VSS.t1304 16.2518
R12655 VSS.n5775 VSS.t1555 16.2518
R12656 VSS.n472 VSS.t1814 16.2518
R12657 VSS.t2783 VSS.n3253 16.2518
R12658 VSS.t4192 VSS.n3189 16.2518
R12659 VSS.t1409 VSS.n3118 16.2518
R12660 VSS.t1922 VSS.n2964 16.2518
R12661 VSS.t1665 VSS.n2874 16.2518
R12662 VSS.t94 VSS.n2900 16.2518
R12663 VSS.t3204 VSS.n1266 16.2518
R12664 VSS.t3360 VSS.n1441 16.2518
R12665 VSS.t2772 VSS.n4084 16.2518
R12666 VSS.t1381 VSS.n1584 16.2518
R12667 VSS.t1898 VSS.n1659 16.2518
R12668 VSS.t1636 VSS.n1511 16.2518
R12669 VSS.t64 VSS.n1418 16.2518
R12670 VSS.t4314 VSS.n1726 16.2518
R12671 VSS.t3331 VSS.n885 16.2518
R12672 VSS.t2728 VSS.n952 16.2518
R12673 VSS.t1355 VSS.n1019 16.2518
R12674 VSS.t1869 VSS.n1087 16.2518
R12675 VSS.t1608 VSS.n5489 16.2518
R12676 VSS.t36 VSS.n862 16.2518
R12677 VSS.t3078 VSS.n5537 16.2518
R12678 VSS.t3111 VSS.n4961 16.2518
R12679 VSS.t2760 VSS.n5285 16.2518
R12680 VSS.t1327 VSS.n5029 16.2518
R12681 VSS.t1841 VSS.n4938 16.2518
R12682 VSS.t1584 VSS.n5096 16.2518
R12683 VSS.t3388 VSS.n5163 16.2518
R12684 VSS.t2591 VSS.n5211 16.2518
R12685 VSS.t4320 VSS.n3423 16.2518
R12686 VSS.t1173 VSS.n2333 16.2518
R12687 VSS.t1719 VSS.n2564 16.2518
R12688 VSS.t1980 VSS.n2492 16.2518
R12689 VSS.t1465 VSS.n3378 16.2518
R12690 VSS.t2450 VSS.n2418 16.2518
R12691 VSS.t2628 VSS.n2172 16.2518
R12692 VSS.t4191 VSS.n3939 16.2518
R12693 VSS.t1437 VSS.n3872 16.2518
R12694 VSS.t1951 VSS.n3665 16.2518
R12695 VSS.t1690 VSS.n3805 16.2518
R12696 VSS.t1139 VSS.n3757 16.2518
R12697 VSS.t4137 VSS.n3709 16.2518
R12698 VSS.t4118 VSS.n3517 16.1703
R12699 VSS.t2886 VSS.n1187 16.1703
R12700 VSS.n1167 VSS.t3465 16.1703
R12701 VSS.t2882 VSS.n5384 16.1703
R12702 VSS.t2561 VSS.n4759 16.1703
R12703 VSS.n4235 VSS.t4133 16.1703
R12704 VSS.n6179 VSS.t2012 15.7034
R12705 VSS.n156 VSS.t1742 15.7034
R12706 VSS.n172 VSS.t1747 15.7034
R12707 VSS.t4166 VSS.n4232 15.7034
R12708 VSS.n1973 VSS.t156 15.4168
R12709 VSS.n1978 VSS.t159 15.3971
R12710 VSS.n325 VSS.t344 15.3937
R12711 VSS.n4349 VSS.t495 15.3937
R12712 VSS.n4519 VSS.t586 15.3937
R12713 VSS.n4357 VSS.t674 15.3937
R12714 VSS.n4476 VSS.t764 15.3937
R12715 VSS.n308 VSS.t908 15.3937
R12716 VSS.n314 VSS.t1005 15.3937
R12717 VSS.n4 VSS.t205 15.3937
R12718 VSS.n4750 VSS.t208 15.3937
R12719 VSS.n1171 VSS.t217 15.3937
R12720 VSS.n5396 VSS.t220 15.3937
R12721 VSS.n4197 VSS.t223 15.3937
R12722 VSS.n2215 VSS.t229 15.3937
R12723 VSS.n4147 VSS.t329 15.3937
R12724 VSS.n1356 VSS.t509 15.3937
R12725 VSS.n4140 VSS.t604 15.3937
R12726 VSS.n3155 VSS.t698 15.3937
R12727 VSS.n2843 VSS.t791 15.3937
R12728 VSS.n2849 VSS.t936 15.3937
R12729 VSS.n3084 VSS.t1023 15.3937
R12730 VSS.n3543 VSS.t239 15.3937
R12731 VSS.n2152 VSS.t367 15.3937
R12732 VSS.n4005 VSS.t513 15.3937
R12733 VSS.n3972 VSS.t610 15.3937
R12734 VSS.n4012 VSS.t700 15.3937
R12735 VSS.n3321 VSS.t797 15.3937
R12736 VSS.n3999 VSS.t940 15.3937
R12737 VSS.n3618 VSS.t1029 15.3937
R12738 VSS.n1904 VSS.t376 15.3937
R12739 VSS.n2371 VSS.t521 15.3937
R12740 VSS.n2444 VSS.t614 15.3937
R12741 VSS.n3404 VSS.t702 15.3937
R12742 VSS.n3331 VSS.t799 15.3937
R12743 VSS.n2518 VSS.t944 15.3937
R12744 VSS.n1888 VSS.t1031 15.3937
R12745 VSS.n5982 VSS.t347 15.3937
R12746 VSS.n5909 VSS.t497 15.3937
R12747 VSS.n5839 VSS.t594 15.3937
R12748 VSS.n5629 VSS.t682 15.3937
R12749 VSS.n5698 VSS.t766 15.3937
R12750 VSS.n5724 VSS.t914 15.3937
R12751 VSS.n584 VSS.t997 15.3937
R12752 VSS.n5813 VSS.t335 15.3937
R12753 VSS.n5312 VSS.t503 15.3937
R12754 VSS.n5806 VSS.t596 15.3937
R12755 VSS.n726 VSS.t686 15.3937
R12756 VSS.n5800 VSS.t776 15.3937
R12757 VSS.n4891 VSS.t916 15.3937
R12758 VSS.n5336 VSS.t1009 15.3937
R12759 VSS.n5604 VSS.t353 15.3937
R12760 VSS.n5571 VSS.t505 15.3937
R12761 VSS.n5597 VSS.t598 15.3937
R12762 VSS.n815 VSS.t690 15.3937
R12763 VSS.n809 VSS.t778 15.3937
R12764 VSS.n801 VSS.t924 15.3937
R12765 VSS.n5449 VSS.t1015 15.3937
R12766 VSS.n1760 VSS.t356 15.3937
R12767 VSS.n4110 VSS.t507 15.3937
R12768 VSS.n1365 VSS.t602 15.3937
R12769 VSS.n1371 VSS.t692 15.3937
R12770 VSS.n1611 VSS.t789 15.3937
R12771 VSS.n1685 VSS.t930 15.3937
R12772 VSS.n1201 VSS.t1021 15.3937
R12773 VSS.n1958 VSS.t172 15.3903
R12774 VSS.n1909 VSS.t198 15.3903
R12775 VSS.n324 VSS.t341 15.3882
R12776 VSS.n4350 VSS.t501 15.3882
R12777 VSS.n4520 VSS.t592 15.3882
R12778 VSS.n4358 VSS.t676 15.3882
R12779 VSS.n4477 VSS.t770 15.3882
R12780 VSS.n309 VSS.t912 15.3882
R12781 VSS.n313 VSS.t999 15.3882
R12782 VSS.n5 VSS.t195 15.3882
R12783 VSS.n1173 VSS.t214 15.3882
R12784 VSS.n5398 VSS.t211 15.3882
R12785 VSS.n4198 VSS.t226 15.3882
R12786 VSS.n2217 VSS.t151 15.3882
R12787 VSS.n4148 VSS.t362 15.3882
R12788 VSS.n1357 VSS.t511 15.3882
R12789 VSS.n4142 VSS.t600 15.3882
R12790 VSS.n3156 VSS.t694 15.3882
R12791 VSS.n2844 VSS.t787 15.3882
R12792 VSS.n2850 VSS.t932 15.3882
R12793 VSS.n3085 VSS.t1019 15.3882
R12794 VSS.n3544 VSS.t242 15.3882
R12795 VSS.n2154 VSS.t365 15.3882
R12796 VSS.n4007 VSS.t516 15.3882
R12797 VSS.n3973 VSS.t612 15.3882
R12798 VSS.n4013 VSS.t696 15.3882
R12799 VSS.n3322 VSS.t793 15.3882
R12800 VSS.n4001 VSS.t934 15.3882
R12801 VSS.n3619 VSS.t1025 15.3882
R12802 VSS.n1906 VSS.t373 15.3882
R12803 VSS.n2372 VSS.t519 15.3882
R12804 VSS.n2445 VSS.t616 15.3882
R12805 VSS.n3405 VSS.t704 15.3882
R12806 VSS.n3332 VSS.t795 15.3882
R12807 VSS.n2519 VSS.t942 15.3882
R12808 VSS.n1890 VSS.t1033 15.3882
R12809 VSS.n4752 VSS.t192 15.3882
R12810 VSS.n5984 VSS.t338 15.3882
R12811 VSS.n5910 VSS.t499 15.3882
R12812 VSS.n5840 VSS.t590 15.3882
R12813 VSS.n5630 VSS.t688 15.3882
R12814 VSS.n5699 VSS.t772 15.3882
R12815 VSS.n5725 VSS.t910 15.3882
R12816 VSS.n586 VSS.t1003 15.3882
R12817 VSS.n5814 VSS.t350 15.3882
R12818 VSS.n5313 VSS.t490 15.3882
R12819 VSS.n5808 VSS.t584 15.3882
R12820 VSS.n728 VSS.t684 15.3882
R12821 VSS.n5802 VSS.t774 15.3882
R12822 VSS.n4892 VSS.t918 15.3882
R12823 VSS.n5337 VSS.t1001 15.3882
R12824 VSS.n5605 VSS.t332 15.3882
R12825 VSS.n5572 VSS.t470 15.3882
R12826 VSS.n5599 VSS.t588 15.3882
R12827 VSS.n816 VSS.t680 15.3882
R12828 VSS.n811 VSS.t768 15.3882
R12829 VSS.n803 VSS.t926 15.3882
R12830 VSS.n5450 VSS.t1007 15.3882
R12831 VSS.n1761 VSS.t359 15.3882
R12832 VSS.n4111 VSS.t472 15.3882
R12833 VSS.n1366 VSS.t582 15.3882
R12834 VSS.n1372 VSS.t678 15.3882
R12835 VSS.n1612 VSS.t785 15.3882
R12836 VSS.n1686 VSS.t928 15.3882
R12837 VSS.n1203 VSS.t1017 15.3882
R12838 VSS.n1913 VSS.t189 15.3868
R12839 VSS.n3580 VSS.t174 15.3868
R12840 VSS.n1959 VSS.t167 15.3056
R12841 VSS.n3579 VSS.t177 15.3056
R12842 VSS.n2108 VSS.t108 15.2247
R12843 VSS.n2111 VSS.t143 15.2205
R12844 VSS.n1934 VSS.t186 15.1993
R12845 VSS.n1948 VSS.t132 15.1993
R12846 VSS.n4589 VSS.t379 15.1845
R12847 VSS.n4338 VSS.t429 15.1845
R12848 VSS.n4367 VSS.t444 15.1845
R12849 VSS.n4465 VSS.t662 15.1845
R12850 VSS.n227 VSS.t780 15.1845
R12851 VSS.n241 VSS.t874 15.1845
R12852 VSS.n123 VSS.t1011 15.1845
R12853 VSS.n33 VSS.t115 15.1845
R12854 VSS.n3961 VSS.t478 15.1845
R12855 VSS.n3894 VSS.t745 15.1845
R12856 VSS.n3626 VSS.t979 15.1845
R12857 VSS.n3827 VSS.t856 15.1845
R12858 VSS.n4026 VSS.t129 15.1845
R12859 VSS.n1799 VSS.t480 15.1845
R12860 VSS.n2355 VSS.t670 15.1845
R12861 VSS.n2526 VSS.t657 15.1845
R12862 VSS.n1865 VSS.t1092 15.1845
R12863 VSS.n5355 VSS.t1052 15.1845
R12864 VSS.n4868 VSS.t1059 15.1845
R12865 VSS.n5437 VSS.t901 15.1845
R12866 VSS.n3075 VSS.t1067 15.1845
R12867 VSS.n3493 VSS.t1077 15.1845
R12868 VSS.n5917 VSS.t309 15.1845
R12869 VSS.n5847 VSS.t529 15.1845
R12870 VSS.n600 VSS.t623 15.1845
R12871 VSS.n5637 VSS.t652 15.1845
R12872 VSS.n5732 VSS.t809 15.1845
R12873 VSS.n5706 VSS.t951 15.1845
R12874 VSS.n6018 VSS.t1041 15.1845
R12875 VSS.n574 VSS.t245 15.1845
R12876 VSS.n5233 VSS.t298 15.1845
R12877 VSS.n696 VSS.t606 15.1845
R12878 VSS.n5118 VSS.t818 15.1845
R12879 VSS.n4899 VSS.t958 15.1845
R12880 VSS.n5051 VSS.t712 15.1845
R12881 VSS.n5247 VSS.t536 15.1845
R12882 VSS.n5559 VSS.t387 15.1845
R12883 VSS.n823 VSS.t452 15.1845
R12884 VSS.n769 VSS.t837 15.1845
R12885 VSS.n1109 VSS.t879 15.1845
R12886 VSS.n1041 VSS.t726 15.1845
R12887 VSS.n974 VSS.t547 15.1845
R12888 VSS.n1748 VSS.t399 15.1845
R12889 VSS.n1379 VSS.t457 15.1845
R12890 VSS.n1533 VSS.t827 15.1845
R12891 VSS.n1620 VSS.t884 15.1845
R12892 VSS.n1546 VSS.t724 15.1845
R12893 VSS.n4045 VSS.t556 15.1845
R12894 VSS.n1319 VSS.t408 15.1845
R12895 VSS.n2925 VSS.t462 15.1845
R12896 VSS.n2857 VSS.t832 15.1845
R12897 VSS.n2989 VSS.t972 15.1845
R12898 VSS.n3143 VSS.t747 15.1845
R12899 VSS.n3214 VSS.t554 15.1845
R12900 VSS.n4161 VSS.t300 15.1845
R12901 VSS.n1250 VSS.t277 15.1845
R12902 VSS.n5617 VSS.t126 15.1845
R12903 VSS.n5827 VSS.t146 15.1845
R12904 VSS.n2453 VSS.t985 15.1845
R12905 VSS.n3339 VSS.t666 15.1845
R12906 VSS.n2379 VSS.t576 15.1845
R12907 VSS.n3567 VSS.t135 15.1845
R12908 VSS.n2107 VSS.t164 15.1845
R12909 VSS.n3605 VSS.t422 15.1845
R12910 VSS.n3535 VSS.t289 15.1845
R12911 VSS.n4601 VSS.t369 15.1777
R12912 VSS.n4529 VSS.t425 15.1777
R12913 VSS.n4378 VSS.t440 15.1777
R12914 VSS.n4485 VSS.t645 15.1777
R12915 VSS.n6165 VSS.t782 15.1777
R12916 VSS.n305 VSS.t870 15.1777
R12917 VSS.n6223 VSS.t889 15.1777
R12918 VSS.n57 VSS.t111 15.1777
R12919 VSS.n3980 VSS.t434 15.1777
R12920 VSS.n3905 VSS.t742 15.1777
R12921 VSS.n3637 VSS.t976 15.1777
R12922 VSS.n3839 VSS.t834 15.1777
R12923 VSS.n4020 VSS.t635 15.1777
R12924 VSS.n4033 VSS.t414 15.1777
R12925 VSS.n2366 VSS.t642 15.1777
R12926 VSS.n2588 VSS.t860 15.1777
R12927 VSS.n1835 VSS.t1084 15.1777
R12928 VSS.n5346 VSS.t1048 15.1777
R12929 VSS.n4859 VSS.t893 15.1777
R12930 VSS.n1125 VSS.t897 15.1777
R12931 VSS.n3003 VSS.t904 15.1777
R12932 VSS.n3483 VSS.t1073 15.1777
R12933 VSS.n5976 VSS.t292 15.1777
R12934 VSS.n5906 VSS.t431 15.1777
R12935 VSS.n659 VSS.t618 15.1777
R12936 VSS.n5648 VSS.t649 15.1777
R12937 VSS.n5791 VSS.t806 15.1777
R12938 VSS.n5721 VSS.t946 15.1777
R12939 VSS.n6024 VSS.t1037 15.1777
R12940 VSS.n595 VSS.t248 15.1777
R12941 VSS.n5244 VSS.t295 15.1777
R12942 VSS.n665 VSS.t446 15.1777
R12943 VSS.n5129 VSS.t815 15.1777
R12944 VSS.n4910 VSS.t955 15.1777
R12945 VSS.n5062 VSS.t714 15.1777
R12946 VSS.n5309 VSS.t533 15.1777
R12947 VSS.n5570 VSS.t389 15.1777
R12948 VSS.n834 VSS.t449 15.1777
R12949 VSS.n5624 VSS.t824 15.1777
R12950 VSS.n1120 VSS.t876 15.1777
R12951 VSS.n1052 VSS.t721 15.1777
R12952 VSS.n985 VSS.t542 15.1777
R12953 VSS.n1759 VSS.t396 15.1777
R12954 VSS.n1390 VSS.t454 15.1777
R12955 VSS.n1693 VSS.t845 15.1777
R12956 VSS.n1631 VSS.t881 15.1777
R12957 VSS.n1608 VSS.t732 15.1777
R12958 VSS.n4056 VSS.t551 15.1777
R12959 VSS.n1353 VSS.t405 15.1777
R12960 VSS.n2936 VSS.t459 15.1777
R12961 VSS.n3316 VSS.t829 15.1777
R12962 VSS.n3000 VSS.t886 15.1777
R12963 VSS.n3154 VSS.t739 15.1777
R12964 VSS.n3225 VSS.t564 15.1777
R12965 VSS.n4155 VSS.t285 15.1777
R12966 VSS.n1233 VSS.t274 15.1777
R12967 VSS.n790 VSS.t122 15.1777
R12968 VSS.n5821 VSS.t118 15.1777
R12969 VSS.n2464 VSS.t987 15.1777
R12970 VSS.n3350 VSS.t654 15.1777
R12971 VSS.n2390 VSS.t437 15.1777
R12972 VSS.n2368 VSS.t418 15.1777
R12973 VSS.n3528 VSS.t318 15.1777
R12974 VSS.n1949 VSS.t179 15.1634
R12975 VSS.n1935 VSS.t140 15.1613
R12976 VSS.t2408 VSS.n1776 15.1012
R12977 VSS.t4117 VSS.n3516 14.9726
R12978 VSS.n1192 VSS.t2885 14.9726
R12979 VSS.n5394 VSS.t3464 14.9726
R12980 VSS.t2881 VSS.n5383 14.9726
R12981 VSS.t2560 VSS.n4758 14.9726
R12982 VSS.n4236 VSS.t4132 14.9726
R12983 VSS.t4058 VSS.t2598 14.8566
R12984 VSS.n3471 VSS.t3607 14.722
R12985 VSS.n3498 VSS.t1074 14.722
R12986 VSS.n3009 VSS.t4107 14.722
R12987 VSS.t905 VSS.n3065 14.722
R12988 VSS.n1131 VSS.t3503 14.722
R12989 VSS.t898 VSS.n5427 14.722
R12990 VSS.n4846 VSS.t3133 14.722
R12991 VSS.n4873 VSS.t894 14.722
R12992 VSS.n4879 VSS.t2643 14.722
R12993 VSS.n5360 VSS.t1049 14.722
R12994 VSS.n391 VSS.t3069 14.722
R12995 VSS.t1038 VSS.n6010 14.722
R12996 VSS.n297 VSS.t1802 14.6823
R12997 VSS.n222 VSS.t1542 14.6823
R12998 VSS.n4460 VSS.t1282 14.6823
R12999 VSS.n4508 VSS.t2429 14.6823
R13000 VSS.n4333 VSS.t4016 14.6823
R13001 VSS.n4584 VSS.t2383 14.6823
R13002 VSS.n2293 VSS.t3989 14.6571
R13003 VSS.t3983 VSS.n3509 14.6571
R13004 VSS.n3053 VSS.t3977 14.6571
R13005 VSS.n5415 VSS.t3971 14.6571
R13006 VSS.n4832 VSS.t3965 14.6571
R13007 VSS.t3959 VSS.n5371 14.6571
R13008 VSS.t3159 VSS.n2135 14.6404
R13009 VSS.t2230 VSS.n2269 14.3757
R13010 VSS.t2202 VSS.n2221 14.3757
R13011 VSS.t2174 VSS.n3030 14.3757
R13012 VSS.t2146 VSS.n1152 14.3757
R13013 VSS.t2120 VSS.n4810 14.3757
R13014 VSS.t2092 VSS.n4762 14.3757
R13015 VSS.t2062 VSS.n413 14.3757
R13016 VSS.n298 VSS.t1806 14.3733
R13017 VSS.n223 VSS.t1546 14.3733
R13018 VSS.n4461 VSS.t1286 14.3733
R13019 VSS.n4509 VSS.t2433 14.3733
R13020 VSS.n4334 VSS.t4020 14.3733
R13021 VSS.n4585 VSS.t2387 14.3733
R13022 VSS.t2224 VSS.n2285 14.3609
R13023 VSS.t2196 VSS.n3501 14.3609
R13024 VSS.t2168 VSS.n3045 14.3609
R13025 VSS.t2140 VSS.n5407 14.3609
R13026 VSS.t2112 VSS.n4824 14.3609
R13027 VSS.t2084 VSS.n5363 14.3609
R13028 VSS.t2056 VSS.n428 14.3609
R13029 VSS.n3591 VSS.n1923 14.1626
R13030 VSS.n1954 VSS.n1926 14.1626
R13031 VSS.n3578 VSS.n1946 14.1626
R13032 VSS.n1955 VSS.n1927 14.1626
R13033 VSS.n1965 VSS.n1943 14.1626
R13034 VSS.n1956 VSS.n1929 14.1626
R13035 VSS.n1964 VSS.n1942 14.1626
R13036 VSS.n1957 VSS.n1930 14.1626
R13037 VSS.t187 VSS.n1938 14.1626
R13038 VSS.n1963 VSS.n1932 14.1626
R13039 VSS.t1130 VSS.n1777 14.0597
R13040 VSS.t4116 VSS.n3515 13.7748
R13041 VSS.t2884 VSS.n1188 13.7748
R13042 VSS.t3463 VSS.n1168 13.7748
R13043 VSS.t2880 VSS.n5382 13.7748
R13044 VSS.t2559 VSS.n4757 13.7748
R13045 VSS.n4237 VSS.t4131 13.7748
R13046 VSS.t2861 VSS.n2136 13.6307
R13047 VSS.t3988 VSS.n2272 13.3611
R13048 VSS.n3508 VSS.t3982 13.3611
R13049 VSS.t3976 VSS.n3033 13.3611
R13050 VSS.t3970 VSS.n1155 13.3611
R13051 VSS.t3964 VSS.n4813 13.3611
R13052 VSS.n5370 VSS.t3958 13.3611
R13053 VSS.t3952 VSS.n417 13.3611
R13054 VSS.n2080 VSS.t160 13.3091
R13055 VSS.t102 VSS.t3038 13.2996
R13056 VSS.n2299 VSS.t2241 13.2776
R13057 VSS.n2251 VSS.t2213 13.2776
R13058 VSS.n3059 VSS.t2185 13.2776
R13059 VSS.n5421 VSS.t2157 13.2776
R13060 VSS.n4838 VSS.t2129 13.2776
R13061 VSS.n4792 VSS.t2101 13.2776
R13062 VSS.n6004 VSS.t2073 13.2776
R13063 VSS.t4059 VSS.n1968 12.9996
R13064 VSS.t2278 VSS.n1216 12.9959
R13065 VSS.t3124 VSS.n746 12.9959
R13066 VSS.t2262 VSS.n672 12.9959
R13067 VSS.t2353 VSS.n503 12.9959
R13068 VSS.t2337 VSS.n1295 12.9959
R13069 VSS.n2294 VSS.t2237 12.8517
R13070 VSS.n2246 VSS.t2209 12.8517
R13071 VSS.n3054 VSS.t2181 12.8517
R13072 VSS.n5416 VSS.t2153 12.8517
R13073 VSS.n4833 VSS.t2125 12.8517
R13074 VSS.n4787 VSS.t2097 12.8517
R13075 VSS.n5999 VSS.t2069 12.8517
R13076 VSS.n1822 VSS.t517 12.6712
R13077 VSS.t2571 VSS.n3514 12.577
R13078 VSS.n1191 VSS.t3460 12.577
R13079 VSS.n5393 VSS.t2567 12.577
R13080 VSS.t2877 VSS.n5381 12.577
R13081 VSS.t4128 VSS.n4756 12.577
R13082 VSS.n4238 VSS.t4124 12.577
R13083 VSS.n2298 VSS.t2235 12.4914
R13084 VSS.n2250 VSS.t2207 12.4914
R13085 VSS.n3058 VSS.t2179 12.4914
R13086 VSS.n5420 VSS.t2151 12.4914
R13087 VSS.n4837 VSS.t2123 12.4914
R13088 VSS.n4791 VSS.t2095 12.4914
R13089 VSS.n6003 VSS.t2067 12.4914
R13090 VSS.n2098 VSS.t157 12.3806
R13091 VSS.t168 VSS.n1981 12.3806
R13092 VSS.t4277 VSS.n2024 12.3211
R13093 VSS.t243 VSS.n2133 12.2845
R13094 VSS.n1217 VSS.t1114 12.0997
R13095 VSS.t1135 VSS.n747 12.0997
R13096 VSS.t1226 VSS.n673 12.0997
R13097 VSS.t1218 VSS.n504 12.0997
R13098 VSS.t1202 VSS.n1296 12.0997
R13099 VSS.n1977 VSS.t3440 12.0711
R13100 VSS.t1128 VSS.n1779 11.9769
R13101 VSS.n3489 VSS.t3608 11.8332
R13102 VSS.n3071 VSS.t4108 11.8332
R13103 VSS.n5433 VSS.t3504 11.8332
R13104 VSS.n4864 VSS.t3134 11.8332
R13105 VSS.n5351 VSS.t2644 11.8332
R13106 VSS.n6014 VSS.t3070 11.8332
R13107 VSS.n415 VSS.t3953 11.8332
R13108 VSS.n1952 VSS.t133 11.8022
R13109 VSS.t4075 VSS.t4064 11.8022
R13110 VSS.n2289 VSS.t2226 11.7684
R13111 VSS.t2200 VSS.n3502 11.7684
R13112 VSS.n3049 VSS.t2172 11.7684
R13113 VSS.n5411 VSS.t2142 11.7684
R13114 VSS.n4828 VSS.t2116 11.7684
R13115 VSS.t2088 VSS.n5364 11.7684
R13116 VSS.n432 VSS.t2058 11.7684
R13117 VSS.t2859 VSS.n2137 11.6114
R13118 VSS.t2570 VSS.n3513 11.3793
R13119 VSS.t3459 VSS.n1189 11.3793
R13120 VSS.t2566 VSS.n1169 11.3793
R13121 VSS.t2876 VSS.n5380 11.3793
R13122 VSS.t4127 VSS.n4755 11.3793
R13123 VSS.n4239 VSS.t4123 11.3793
R13124 VSS.n1790 VSS.t1165 10.9355
R13125 VSS.t360 VSS.n1246 10.9047
R13126 VSS.n794 VSS.t333 10.9047
R13127 VSS.n720 VSS.t351 10.9047
R13128 VSS.n592 VSS.t339 10.9047
R13129 VSS.n1343 VSS.t363 10.9047
R13130 VSS.t1078 VSS.n3468 10.8032
R13131 VSS.t1071 VSS.n3006 10.8032
R13132 VSS.t902 VSS.n1128 10.8032
R13133 VSS.t1061 VSS.n4843 10.8032
R13134 VSS.t1053 VSS.n4876 10.8032
R13135 VSS.t1042 VSS.n388 10.8032
R13136 VSS.t175 VSS.n1952 10.6221
R13137 VSS.n3585 VSS.t2595 10.6221
R13138 VSS.n3578 VSS.t2599 10.6221
R13139 VSS.n2143 VSS.t2889 10.6018
R13140 VSS.n6235 VSS.n7 10.5807
R13141 VSS.t2221 VSS.n2222 10.4723
R13142 VSS.n3017 VSS.t2193 10.4723
R13143 VSS.n1139 VSS.t2165 10.4723
R13144 VSS.t2137 VSS.n4797 10.4723
R13145 VSS.t2109 VSS.n4763 10.4723
R13146 VSS.n400 VSS.t2081 10.4723
R13147 VSS.t2249 VSS.n2256 10.4472
R13148 VSS.t2244 VSS.n2300 10.3889
R13149 VSS.t2216 VSS.n2252 10.3889
R13150 VSS.t2188 VSS.n3060 10.3889
R13151 VSS.t2160 VSS.n5422 10.3889
R13152 VSS.t2132 VSS.n4839 10.3889
R13153 VSS.t2104 VSS.n4793 10.3889
R13154 VSS.t2076 VSS.n6005 10.3889
R13155 VSS.t1112 VSS.n1219 10.3072
R13156 VSS.t1133 VSS.n749 10.3072
R13157 VSS.t1224 VSS.n675 10.3072
R13158 VSS.t1216 VSS.n506 10.3072
R13159 VSS.t1200 VSS.n1298 10.3072
R13160 VSS.n2098 VSS.n1976 10.2141
R13161 VSS.t2409 VSS.t1167 10.0676
R13162 VSS.n2285 VSS.t2223 10.0278
R13163 VSS.n3501 VSS.t2195 10.0278
R13164 VSS.n3045 VSS.t2167 10.0278
R13165 VSS.n5407 VSS.t2139 10.0278
R13166 VSS.n4824 VSS.t2111 10.0278
R13167 VSS.n5363 VSS.t2083 10.0278
R13168 VSS.n428 VSS.t2055 10.0278
R13169 VSS.n3519 VSS.n3518 9.98187
R13170 VSS.n4193 VSS.n4192 9.98187
R13171 VSS.n5403 VSS.n5402 9.98187
R13172 VSS.n5386 VSS.n5385 9.98187
R13173 VSS.n5374 VSS.n4760 9.98187
R13174 VSS.n2089 VSS.n1972 9.90455
R13175 VSS.t1164 VSS.n1780 9.89404
R13176 VSS.t3160 VSS.t2891 9.76043
R13177 VSS.n168 VSS.n167 9.7397
R13178 VSS.n1969 VSS.t4058 9.59505
R13179 VSS.t2597 VSS.t4059 9.59505
R13180 VSS.t2888 VSS.n2138 9.59215
R13181 VSS.n1823 VSS.n1788 9.5469
R13182 VSS.n1824 VSS.n1787 9.5469
R13183 VSS.n1240 VSS.t1117 9.41098
R13184 VSS.n760 VSS.t1221 9.41098
R13185 VSS.n687 VSS.t1213 9.41098
R13186 VSS.n565 VSS.t1205 9.41098
R13187 VSS.n1310 VSS.t1170 9.41098
R13188 VSS.n4587 VSS.t380 9.33333
R13189 VSS.n4586 VSS.t382 9.33333
R13190 VSS.n4336 VSS.t524 9.33333
R13191 VSS.n4335 VSS.t526 9.33333
R13192 VSS.n4365 VSS.t467 9.33333
R13193 VSS.n4379 VSS.t469 9.33333
R13194 VSS.n4463 VSS.t663 9.33333
R13195 VSS.n4462 VSS.t665 9.33333
R13196 VSS.n225 VSS.t781 9.33333
R13197 VSS.n224 VSS.t784 9.33333
R13198 VSS.n239 VSS.t921 9.33333
R13199 VSS.n252 VSS.t923 9.33333
R13200 VSS.n121 VSS.t1012 9.33333
R13201 VSS.n120 VSS.t1014 9.33333
R13202 VSS.n32 VSS.t233 9.33333
R13203 VSS.n58 VSS.t235 9.33333
R13204 VSS.n3959 VSS.t479 9.33333
R13205 VSS.n3958 VSS.t570 9.33333
R13206 VSS.n3892 VSS.t754 9.33333
R13207 VSS.n3891 VSS.t756 9.33333
R13208 VSS.n3624 VSS.t982 9.33333
R13209 VSS.n3638 VSS.t984 9.33333
R13210 VSS.n3825 VSS.t857 9.33333
R13211 VSS.n3824 VSS.t855 9.33333
R13212 VSS.n4025 VSS.t639 9.33333
R13213 VSS.n1815 VSS.t641 9.33333
R13214 VSS.n1798 VSS.t481 9.33333
R13215 VSS.n1770 VSS.t483 9.33333
R13216 VSS.n2353 VSS.t671 9.33333
R13217 VSS.n2352 VSS.t669 9.33333
R13218 VSS.n2524 VSS.t864 9.33333
R13219 VSS.n2537 VSS.t866 9.33333
R13220 VSS.n1864 VSS.t1093 9.33333
R13221 VSS.n1836 VSS.t1085 9.33333
R13222 VSS.n5354 VSS.t1056 9.33333
R13223 VSS.n4887 VSS.t1058 9.33333
R13224 VSS.n4867 VSS.t1060 9.33333
R13225 VSS.n4854 VSS.t1028 9.33333
R13226 VSS.n5436 VSS.t1064 9.33333
R13227 VSS.n1126 VSS.t1066 9.33333
R13228 VSS.n3074 VSS.t1068 9.33333
R13229 VSS.n3004 VSS.t1070 9.33333
R13230 VSS.n3492 VSS.t1081 9.33333
R13231 VSS.n3479 VSS.t1083 9.33333
R13232 VSS.n5915 VSS.t310 9.33333
R13233 VSS.n5928 VSS.t312 9.33333
R13234 VSS.n5845 VSS.t530 9.33333
R13235 VSS.n5858 VSS.t528 9.33333
R13236 VSS.n598 VSS.t624 9.33333
R13237 VSS.n611 VSS.t619 9.33333
R13238 VSS.n5635 VSS.t709 9.33333
R13239 VSS.n5649 VSS.t711 9.33333
R13240 VSS.n5730 VSS.t810 9.33333
R13241 VSS.n5743 VSS.t812 9.33333
R13242 VSS.n5704 VSS.t952 9.33333
R13243 VSS.n5717 VSS.t947 9.33333
R13244 VSS.n6017 VSS.t1047 9.33333
R13245 VSS.n386 VSS.t1045 9.33333
R13246 VSS.n573 VSS.t247 9.33333
R13247 VSS.n513 VSS.t250 9.33333
R13248 VSS.n5231 VSS.t306 9.33333
R13249 VSS.n5230 VSS.t308 9.33333
R13250 VSS.n695 VSS.t607 9.33333
R13251 VSS.n666 VSS.t609 9.33333
R13252 VSS.n5116 VSS.t819 9.33333
R13253 VSS.n5115 VSS.t821 9.33333
R13254 VSS.n4897 VSS.t959 9.33333
R13255 VSS.n4911 VSS.t961 9.33333
R13256 VSS.n5049 VSS.t713 9.33333
R13257 VSS.n5048 VSS.t715 9.33333
R13258 VSS.n5245 VSS.t539 9.33333
R13259 VSS.n5258 VSS.t541 9.33333
R13260 VSS.n5557 VSS.t388 9.33333
R13261 VSS.n5556 VSS.t390 9.33333
R13262 VSS.n821 VSS.t630 9.33333
R13263 VSS.n835 VSS.t475 9.33333
R13264 VSS.n768 VSS.t838 9.33333
R13265 VSS.n740 VSS.t840 9.33333
R13266 VSS.n1107 VSS.t965 9.33333
R13267 VSS.n1106 VSS.t939 9.33333
R13268 VSS.n1039 VSS.t727 9.33333
R13269 VSS.n1038 VSS.t729 9.33333
R13270 VSS.n972 VSS.t548 9.33333
R13271 VSS.n971 VSS.t543 9.33333
R13272 VSS.n1746 VSS.t400 9.33333
R13273 VSS.n1745 VSS.t402 9.33333
R13274 VSS.n1377 VSS.t477 9.33333
R13275 VSS.n1391 VSS.t632 9.33333
R13276 VSS.n1531 VSS.t844 9.33333
R13277 VSS.n1530 VSS.t846 9.33333
R13278 VSS.n1618 VSS.t967 9.33333
R13279 VSS.n1632 VSS.t969 9.33333
R13280 VSS.n1544 VSS.t736 9.33333
R13281 VSS.n1557 VSS.t738 9.33333
R13282 VSS.n4043 VSS.t557 9.33333
R13283 VSS.n4057 VSS.t559 9.33333
R13284 VSS.n1318 VSS.t409 9.33333
R13285 VSS.n1289 VSS.t411 9.33333
R13286 VSS.n2923 VSS.t463 9.33333
R13287 VSS.n2922 VSS.t465 9.33333
R13288 VSS.n2855 VSS.t851 9.33333
R13289 VSS.n2868 VSS.t853 9.33333
R13290 VSS.n2987 VSS.t973 9.33333
R13291 VSS.n2986 VSS.t971 9.33333
R13292 VSS.n3141 VSS.t748 9.33333
R13293 VSS.n3140 VSS.t750 9.33333
R13294 VSS.n3212 VSS.t563 9.33333
R13295 VSS.n3211 VSS.t565 9.33333
R13296 VSS.n4160 VSS.t302 9.33333
R13297 VSS.n1336 VSS.t304 9.33333
R13298 VSS.n1249 VSS.t279 9.33333
R13299 VSS.n1226 VSS.t276 9.33333
R13300 VSS.n5616 VSS.t268 9.33333
R13301 VSS.n786 VSS.t270 9.33333
R13302 VSS.n5826 VSS.t148 9.33333
R13303 VSS.n713 VSS.t150 9.33333
R13304 VSS.n2451 VSS.t986 9.33333
R13305 VSS.n2465 VSS.t988 9.33333
R13306 VSS.n3337 VSS.t667 9.33333
R13307 VSS.n3351 VSS.t758 9.33333
R13308 VSS.n2377 VSS.t577 9.33333
R13309 VSS.n2391 VSS.t579 9.33333
R13310 VSS.n3604 VSS.t487 9.33333
R13311 VSS.n1882 VSS.t489 9.33333
R13312 VSS.n3534 VSS.t323 9.33333
R13313 VSS.n2165 VSS.t325 9.33333
R13314 VSS.n3530 VSS.n2139 9.2556
R13315 VSS.n3525 VSS.n2140 9.2556
R13316 VSS.n38 VSS.t2905 9.18676
R13317 VSS.n1370 VSS.n1369 9.16037
R13318 VSS.n4590 VSS.t384 9.15836
R13319 VSS.n4592 VSS.t2913 9.15836
R13320 VSS.n4594 VSS.t2911 9.15836
R13321 VSS.n4596 VSS.t2909 9.15836
R13322 VSS.n4598 VSS.t371 9.15836
R13323 VSS.n4339 VSS.t430 9.15836
R13324 VSS.n4341 VSS.t3014 9.15836
R13325 VSS.n4343 VSS.t3013 9.15836
R13326 VSS.n4345 VSS.t3011 9.15836
R13327 VSS.n4347 VSS.t427 9.15836
R13328 VSS.n4368 VSS.t445 9.15836
R13329 VSS.n4370 VSS.t3526 9.15836
R13330 VSS.n4372 VSS.t3524 9.15836
R13331 VSS.n4374 VSS.t3522 9.15836
R13332 VSS.n4376 VSS.t442 9.15836
R13333 VSS.n4466 VSS.t707 9.15836
R13334 VSS.n4468 VSS.t4087 9.15836
R13335 VSS.n4470 VSS.t4085 9.15836
R13336 VSS.n4472 VSS.t4083 9.15836
R13337 VSS.n4474 VSS.t647 9.15836
R13338 VSS.n228 VSS.t805 9.15836
R13339 VSS.n230 VSS.t4216 9.15836
R13340 VSS.n232 VSS.t4214 9.15836
R13341 VSS.n234 VSS.t4212 9.15836
R13342 VSS.n236 VSS.t802 9.15836
R13343 VSS.n242 VSS.t875 9.15836
R13344 VSS.n244 VSS.t4237 9.15836
R13345 VSS.n246 VSS.t4236 9.15836
R13346 VSS.n248 VSS.t4234 9.15836
R13347 VSS.n250 VSS.t872 9.15836
R13348 VSS.n124 VSS.t1036 9.15836
R13349 VSS.n126 VSS.t3598 9.15836
R13350 VSS.n128 VSS.t3596 9.15836
R13351 VSS.n130 VSS.t3594 9.15836
R13352 VSS.n132 VSS.t891 9.15836
R13353 VSS.n34 VSS.t117 9.15836
R13354 VSS.n36 VSS.t3138 9.15836
R13355 VSS.n41 VSS.t3142 9.15836
R13356 VSS.n47 VSS.t3140 9.15836
R13357 VSS.n52 VSS.t113 9.15836
R13358 VSS.n3962 VSS.t572 9.15836
R13359 VSS.n3964 VSS.t2411 9.15836
R13360 VSS.n3966 VSS.t2415 9.15836
R13361 VSS.n3968 VSS.t2413 9.15836
R13362 VSS.n3970 VSS.t435 9.15836
R13363 VSS.n3895 VSS.t746 9.15836
R13364 VSS.n3897 VSS.t4285 9.15836
R13365 VSS.n3899 VSS.t4283 9.15836
R13366 VSS.n3901 VSS.t4281 9.15836
R13367 VSS.n3903 VSS.t743 9.15836
R13368 VSS.n3627 VSS.t980 9.15836
R13369 VSS.n3629 VSS.t3308 9.15836
R13370 VSS.n3631 VSS.t3307 9.15836
R13371 VSS.n3633 VSS.t3305 9.15836
R13372 VSS.n3635 VSS.t977 9.15836
R13373 VSS.n3828 VSS.t859 9.15836
R13374 VSS.n3830 VSS.t4047 9.15836
R13375 VSS.n3832 VSS.t4045 9.15836
R13376 VSS.n3834 VSS.t4043 9.15836
R13377 VSS.n3836 VSS.t835 9.15836
R13378 VSS.n4027 VSS.t131 9.15836
R13379 VSS.n4024 VSS.t3046 9.15836
R13380 VSS.n4022 VSS.t3044 9.15836
R13381 VSS.n1812 VSS.t3042 9.15836
R13382 VSS.n1818 VSS.t636 9.15836
R13383 VSS.n1800 VSS.t485 9.15836
R13384 VSS.n1797 VSS.t2497 9.15836
R13385 VSS.n1793 VSS.t2495 9.15836
R13386 VSS.n1782 VSS.t2493 9.15836
R13387 VSS.n1781 VSS.t416 9.15836
R13388 VSS.n2356 VSS.t673 9.15836
R13389 VSS.n2358 VSS.t3449 9.15836
R13390 VSS.n2360 VSS.t3447 9.15836
R13391 VSS.n2362 VSS.t3445 9.15836
R13392 VSS.n2364 VSS.t643 9.15836
R13393 VSS.n2527 VSS.t658 9.15836
R13394 VSS.n2529 VSS.t2799 9.15836
R13395 VSS.n2531 VSS.t2798 9.15836
R13396 VSS.n2533 VSS.t2796 9.15836
R13397 VSS.n2535 VSS.t861 9.15836
R13398 VSS.n1866 VSS.t1095 9.15836
R13399 VSS.n1863 VSS.t3997 9.15836
R13400 VSS.n1859 VSS.t3995 9.15836
R13401 VSS.n1847 VSS.t3993 9.15836
R13402 VSS.n1853 VSS.t1090 9.15836
R13403 VSS.n5356 VSS.t1054 9.15836
R13404 VSS.n5353 VSS.t2641 9.15836
R13405 VSS.n5349 VSS.t2639 9.15836
R13406 VSS.n4883 VSS.t2636 9.15836
R13407 VSS.n4890 VSS.t1050 9.15836
R13408 VSS.n4869 VSS.t1062 9.15836
R13409 VSS.n4866 VSS.t3135 9.15836
R13410 VSS.n4862 VSS.t3132 9.15836
R13411 VSS.n4850 VSS.t3129 9.15836
R13412 VSS.n4857 VSS.t895 9.15836
R13413 VSS.n5438 VSS.t903 9.15836
R13414 VSS.n5435 VSS.t3501 9.15836
R13415 VSS.n5431 VSS.t3499 9.15836
R13416 VSS.n1135 VSS.t3496 9.15836
R13417 VSS.n5428 VSS.t899 9.15836
R13418 VSS.n3076 VSS.t1072 9.15836
R13419 VSS.n3073 VSS.t4109 9.15836
R13420 VSS.n3069 VSS.t4105 9.15836
R13421 VSS.n3013 VSS.t4102 9.15836
R13422 VSS.n3066 VSS.t906 9.15836
R13423 VSS.n3494 VSS.t1079 9.15836
R13424 VSS.n3491 VSS.t3609 9.15836
R13425 VSS.n3487 VSS.t3606 9.15836
R13426 VSS.n3475 VSS.t3603 9.15836
R13427 VSS.n3482 VSS.t1075 9.15836
R13428 VSS.n5918 VSS.t386 9.15836
R13429 VSS.n5920 VSS.t2358 9.15836
R13430 VSS.n5922 VSS.t2360 9.15836
R13431 VSS.n5924 VSS.t2357 9.15836
R13432 VSS.n5926 VSS.t293 9.15836
R13433 VSS.n5848 VSS.t532 9.15836
R13434 VSS.n5850 VSS.t3030 9.15836
R13435 VSS.n5852 VSS.t3029 9.15836
R13436 VSS.n5854 VSS.t3027 9.15836
R13437 VSS.n5856 VSS.t432 9.15836
R13438 VSS.n601 VSS.t626 9.15836
R13439 VSS.n603 VSS.t3484 9.15836
R13440 VSS.n605 VSS.t3481 9.15836
R13441 VSS.n607 VSS.t3479 9.15836
R13442 VSS.n609 VSS.t621 9.15836
R13443 VSS.n5638 VSS.t653 9.15836
R13444 VSS.n5640 VSS.t4271 9.15836
R13445 VSS.n5642 VSS.t4269 9.15836
R13446 VSS.n5644 VSS.t4267 9.15836
R13447 VSS.n5646 VSS.t650 9.15836
R13448 VSS.n5733 VSS.t814 9.15836
R13449 VSS.n5735 VSS.t3102 9.15836
R13450 VSS.n5737 VSS.t3100 9.15836
R13451 VSS.n5739 VSS.t3098 9.15836
R13452 VSS.n5741 VSS.t807 9.15836
R13453 VSS.n5707 VSS.t954 9.15836
R13454 VSS.n5709 VSS.t3022 9.15836
R13455 VSS.n5711 VSS.t3021 9.15836
R13456 VSS.n5713 VSS.t3019 9.15836
R13457 VSS.n5715 VSS.t949 9.15836
R13458 VSS.n6019 VSS.t1043 9.15836
R13459 VSS.n6016 VSS.t3071 9.15836
R13460 VSS.n6012 VSS.t3068 9.15836
R13461 VSS.n396 VSS.t3065 9.15836
R13462 VSS.n395 VSS.t1039 9.15836
R13463 VSS.n575 VSS.t258 9.15836
R13464 VSS.n572 VSS.t2669 9.15836
R13465 VSS.n568 VSS.t2667 9.15836
R13466 VSS.n508 VSS.t2665 9.15836
R13467 VSS.n560 VSS.t255 9.15836
R13468 VSS.n5234 VSS.t299 9.15836
R13469 VSS.n5236 VSS.t2964 9.15836
R13470 VSS.n5238 VSS.t2962 9.15836
R13471 VSS.n5240 VSS.t2960 9.15836
R13472 VSS.n5242 VSS.t296 9.15836
R13473 VSS.n697 VSS.t628 9.15836
R13474 VSS.n694 VSS.t3567 9.15836
R13475 VSS.n690 VSS.t3566 9.15836
R13476 VSS.n677 VSS.t3564 9.15836
R13477 VSS.n683 VSS.t447 9.15836
R13478 VSS.n5119 VSS.t823 9.15836
R13479 VSS.n5121 VSS.t2269 9.15836
R13480 VSS.n5123 VSS.t2268 9.15836
R13481 VSS.n5125 VSS.t2266 9.15836
R13482 VSS.n5127 VSS.t816 9.15836
R13483 VSS.n4900 VSS.t963 9.15836
R13484 VSS.n4902 VSS.t2397 9.15836
R13485 VSS.n4904 VSS.t2395 9.15836
R13486 VSS.n4906 VSS.t2393 9.15836
R13487 VSS.n4908 VSS.t956 9.15836
R13488 VSS.n5052 VSS.t720 9.15836
R13489 VSS.n5054 VSS.t3510 9.15836
R13490 VSS.n5056 VSS.t3508 9.15836
R13491 VSS.n5058 VSS.t3506 9.15836
R13492 VSS.n5060 VSS.t717 9.15836
R13493 VSS.n5248 VSS.t537 9.15836
R13494 VSS.n5250 VSS.t3052 9.15836
R13495 VSS.n5252 VSS.t3051 9.15836
R13496 VSS.n5254 VSS.t3054 9.15836
R13497 VSS.n5256 VSS.t534 9.15836
R13498 VSS.n5560 VSS.t395 9.15836
R13499 VSS.n5562 VSS.t3301 9.15836
R13500 VSS.n5564 VSS.t3299 9.15836
R13501 VSS.n5566 VSS.t3296 9.15836
R13502 VSS.n5568 VSS.t392 9.15836
R13503 VSS.n824 VSS.t453 9.15836
R13504 VSS.n826 VSS.t3558 9.15836
R13505 VSS.n828 VSS.t3555 9.15836
R13506 VSS.n830 VSS.t3553 9.15836
R13507 VSS.n832 VSS.t450 9.15836
R13508 VSS.n770 VSS.t842 9.15836
R13509 VSS.n767 VSS.t4144 9.15836
R13510 VSS.n763 VSS.t4143 9.15836
R13511 VSS.n752 VSS.t4141 9.15836
R13512 VSS.n751 VSS.t825 9.15836
R13513 VSS.n1110 VSS.t880 9.15836
R13514 VSS.n1112 VSS.t4039 9.15836
R13515 VSS.n1114 VSS.t4037 9.15836
R13516 VSS.n1116 VSS.t4035 9.15836
R13517 VSS.n1118 VSS.t877 9.15836
R13518 VSS.n1042 VSS.t731 9.15836
R13519 VSS.n1044 VSS.t4178 9.15836
R13520 VSS.n1046 VSS.t4176 9.15836
R13521 VSS.n1048 VSS.t4174 9.15836
R13522 VSS.n1050 VSS.t722 9.15836
R13523 VSS.n975 VSS.t550 9.15836
R13524 VSS.n977 VSS.t4159 9.15836
R13525 VSS.n979 VSS.t4158 9.15836
R13526 VSS.n981 VSS.t4156 9.15836
R13527 VSS.n983 VSS.t545 9.15836
R13528 VSS.n1749 VSS.t404 9.15836
R13529 VSS.n1751 VSS.t2792 9.15836
R13530 VSS.n1753 VSS.t2790 9.15836
R13531 VSS.n1755 VSS.t2788 9.15836
R13532 VSS.n1757 VSS.t397 9.15836
R13533 VSS.n1380 VSS.t458 9.15836
R13534 VSS.n1382 VSS.t3581 9.15836
R13535 VSS.n1384 VSS.t3579 9.15836
R13536 VSS.n1386 VSS.t3577 9.15836
R13537 VSS.n1388 VSS.t455 9.15836
R13538 VSS.n1534 VSS.t828 9.15836
R13539 VSS.n1536 VSS.t2285 9.15836
R13540 VSS.n1538 VSS.t2284 9.15836
R13541 VSS.n1540 VSS.t2282 9.15836
R13542 VSS.n1542 VSS.t848 9.15836
R13543 VSS.n1621 VSS.t885 9.15836
R13544 VSS.n1623 VSS.t4259 9.15836
R13545 VSS.n1625 VSS.t4257 9.15836
R13546 VSS.n1627 VSS.t4255 9.15836
R13547 VSS.n1629 VSS.t882 9.15836
R13548 VSS.n1547 VSS.t725 9.15836
R13549 VSS.n1549 VSS.t2507 9.15836
R13550 VSS.n1551 VSS.t2505 9.15836
R13551 VSS.n1553 VSS.t2503 9.15836
R13552 VSS.n1555 VSS.t733 9.15836
R13553 VSS.n4046 VSS.t561 9.15836
R13554 VSS.n4048 VSS.t4030 9.15836
R13555 VSS.n4050 VSS.t4029 9.15836
R13556 VSS.n4052 VSS.t4027 9.15836
R13557 VSS.n4054 VSS.t552 9.15836
R13558 VSS.n1320 VSS.t413 9.15836
R13559 VSS.n1317 VSS.t4055 9.15836
R13560 VSS.n1313 VSS.t4053 9.15836
R13561 VSS.n1300 VSS.t4051 9.15836
R13562 VSS.n1306 VSS.t406 9.15836
R13563 VSS.n2926 VSS.t634 9.15836
R13564 VSS.n2928 VSS.t3618 9.15836
R13565 VSS.n2930 VSS.t3615 9.15836
R13566 VSS.n2932 VSS.t3613 9.15836
R13567 VSS.n2934 VSS.t460 9.15836
R13568 VSS.n2858 VSS.t833 9.15836
R13569 VSS.n2860 VSS.t2780 9.15836
R13570 VSS.n2862 VSS.t2778 9.15836
R13571 VSS.n2864 VSS.t2776 9.15836
R13572 VSS.n2866 VSS.t830 9.15836
R13573 VSS.n2990 VSS.t975 9.15836
R13574 VSS.n2992 VSS.t3284 9.15836
R13575 VSS.n2994 VSS.t3283 9.15836
R13576 VSS.n2996 VSS.t3281 9.15836
R13577 VSS.n2998 VSS.t887 9.15836
R13578 VSS.n3144 VSS.t752 9.15836
R13579 VSS.n3146 VSS.t3590 9.15836
R13580 VSS.n3148 VSS.t3588 9.15836
R13581 VSS.n3150 VSS.t3586 9.15836
R13582 VSS.n3152 VSS.t740 9.15836
R13583 VSS.n3215 VSS.t555 9.15836
R13584 VSS.n3217 VSS.t4250 9.15836
R13585 VSS.n3219 VSS.t4249 9.15836
R13586 VSS.n3221 VSS.t4247 9.15836
R13587 VSS.n3223 VSS.t567 9.15836
R13588 VSS.n4162 VSS.t317 9.15836
R13589 VSS.n4159 VSS.t2346 9.15836
R13590 VSS.n4157 VSS.t2341 9.15836
R13591 VSS.n1333 VSS.t2343 9.15836
R13592 VSS.n1339 VSS.t287 9.15836
R13593 VSS.n1251 VSS.t284 9.15836
R13594 VSS.n1248 VSS.t4219 9.15836
R13595 VSS.n1242 VSS.t4223 9.15836
R13596 VSS.n1221 VSS.t4220 9.15836
R13597 VSS.n1231 VSS.t281 9.15836
R13598 VSS.n5618 VSS.t128 9.15836
R13599 VSS.n5615 VSS.t3150 9.15836
R13600 VSS.n5613 VSS.t3149 9.15836
R13601 VSS.n783 VSS.t3147 9.15836
R13602 VSS.n789 VSS.t124 9.15836
R13603 VSS.n5828 VSS.t263 9.15836
R13604 VSS.n5825 VSS.t2841 9.15836
R13605 VSS.n5823 VSS.t2839 9.15836
R13606 VSS.n710 VSS.t2837 9.15836
R13607 VSS.n716 VSS.t120 9.15836
R13608 VSS.n2454 VSS.t996 9.15836
R13609 VSS.n2456 VSS.t3491 9.15836
R13610 VSS.n2458 VSS.t3489 9.15836
R13611 VSS.n2460 VSS.t3487 9.15836
R13612 VSS.n2462 VSS.t993 9.15836
R13613 VSS.n3340 VSS.t763 9.15836
R13614 VSS.n3342 VSS.t2897 9.15836
R13615 VSS.n3344 VSS.t2895 9.15836
R13616 VSS.n3346 VSS.t2893 9.15836
R13617 VSS.n3348 VSS.t655 9.15836
R13618 VSS.n2380 VSS.t581 9.15836
R13619 VSS.n2382 VSS.t3293 9.15836
R13620 VSS.n2384 VSS.t3291 9.15836
R13621 VSS.n2386 VSS.t3288 9.15836
R13622 VSS.n2388 VSS.t438 9.15836
R13623 VSS.n3606 VSS.t424 9.15836
R13624 VSS.n3603 VSS.t2377 9.15836
R13625 VSS.n3601 VSS.t2375 9.15836
R13626 VSS.n1878 VSS.t2373 9.15836
R13627 VSS.n1885 VSS.t420 9.15836
R13628 VSS.n3536 VSS.t291 9.15836
R13629 VSS.n3533 VSS.t3167 9.15836
R13630 VSS.n3531 VSS.t3166 9.15836
R13631 VSS.n2160 VSS.t3164 9.15836
R13632 VSS.n3526 VSS.t320 9.15836
R13633 VSS.t1756 VSS.n275 9.14684
R13634 VSS.t1494 VSS.n199 9.14684
R13635 VSS.t1234 VSS.n4438 9.14684
R13636 VSS.t2692 VSS.n4402 9.14684
R13637 VSS.t2853 VSS.n4311 9.14684
R13638 VSS.t3357 VSS.n4562 9.14684
R13639 VSS.n5609 VSS.n5608 9.14656
R13640 VSS.n5596 VSS.n5595 9.14563
R13641 VSS.n1170 VSS.n717 9.14471
R13642 VSS.n725 VSS.n664 9.14379
R13643 VSS.n1887 VSS.n1833 9.14287
R13644 VSS.n5805 VSS.n663 9.14287
R13645 VSS.n2523 VSS.n2522 9.14194
R13646 VSS.n800 VSS.n738 9.14194
R13647 VSS.n2214 VSS.n1340 9.14102
R13648 VSS.n3409 VSS.n3408 9.14102
R13649 VSS.n4896 VSS.n4895 9.14102
R13650 VSS.n1765 VSS.n1764 9.14102
R13651 VSS.n5392 VSS.n791 9.1401
R13652 VSS.n4202 VSS.n4201 9.13918
R13653 VSS.n5576 VSS.n5575 9.13918
R13654 VSS.n3160 VSS.n3159 9.13825
R13655 VSS.n3548 VSS.n3547 9.13825
R13656 VSS.n1376 VSS.n1375 9.13825
R13657 VSS.n2376 VSS.n2375 9.13733
R13658 VSS.n1690 VSS.n1689 9.13733
R13659 VSS.n3623 VSS.n3622 9.13641
R13660 VSS.n2854 VSS.n2853 9.13548
R13661 VSS.n2121 VSS.n1903 9.13548
R13662 VSS.n3336 VSS.n3335 9.13548
R13663 VSS.n5818 VSS.n5817 9.13548
R13664 VSS.n820 VSS.n819 9.13548
R13665 VSS.n4526 VSS.n4525 9.13472
R13666 VSS.n5799 VSS.n5798 9.13456
R13667 VSS.n2449 VSS.n2448 9.13364
R13668 VSS.n5341 VSS.n5340 9.13364
R13669 VSS.n5454 VSS.n5453 9.13364
R13670 VSS.n5317 VSS.n5316 9.13271
R13671 VSS.n808 VSS.n737 9.13271
R13672 VSS.n4115 VSS.n4114 9.13271
R13673 VSS.n1200 VSS.n1123 9.13271
R13674 VSS.n4139 VSS.n4138 9.13179
R13675 VSS.n3089 VSS.n3088 9.13086
R13676 VSS.n2848 VSS.n2847 9.12994
R13677 VSS.n4004 VSS.n1768 9.12994
R13678 VSS.n3977 VSS.n3976 9.12902
R13679 VSS.n4152 VSS.n4151 9.12809
R13680 VSS.n5844 VSS.n5843 9.12809
R13681 VSS.n1361 VSS.n1360 9.12717
R13682 VSS.n5729 VSS.n5728 9.12624
R13683 VSS.n4364 VSS.n4363 9.12548
R13684 VSS.n2151 VSS.n1767 9.12531
R13685 VSS.n5914 VSS.n5913 9.12531
R13686 VSS.n1616 VSS.n1615 9.12531
R13687 VSS.n3998 VSS.n3997 9.12439
R13688 VSS.n583 VSS.n384 9.12347
R13689 VSS.n4356 VSS.n4355 9.12178
R13690 VSS.n316 VSS.n315 9.12085
R13691 VSS.n4749 VSS.n4748 9.12069
R13692 VSS.n5981 VSS.n5980 9.12069
R13693 VSS.n3326 VSS.n3325 9.11976
R13694 VSS.n6149 VSS.n6148 9.11807
R13695 VSS.n4483 VSS.n4482 9.11807
R13696 VSS.n6245 VSS.n6244 9.11807
R13697 VSS.n5634 VSS.n5633 9.11791
R13698 VSS.n5703 VSS.n5702 9.11791
R13699 VSS.n6162 VSS.n6161 9.11622
R13700 VSS.n4017 VSS.n4016 9.10122
R13701 VSS.n4258 VSS.t3187 9.06786
R13702 VSS.t3213 VSS.n536 9.06786
R13703 VSS.t4210 VSS.n5950 9.06786
R13704 VSS.t4005 VSS.n5880 9.06786
R13705 VSS.t2468 VSS.n633 9.06786
R13706 VSS.t1306 VSS.n5671 9.06786
R13707 VSS.t1557 VSS.n5765 9.06786
R13708 VSS.t1816 VSS.n462 9.06786
R13709 VSS.n3262 VSS.t2785 9.06786
R13710 VSS.n3198 VSS.t4194 9.06786
R13711 VSS.n3127 VSS.t1411 9.06786
R13712 VSS.n2973 VSS.t1924 9.06786
R13713 VSS.n2883 VSS.t1663 9.06786
R13714 VSS.n2909 VSS.t96 9.06786
R13715 VSS.n1275 VSS.t3206 9.06786
R13716 VSS.n1451 VSS.t3358 9.06786
R13717 VSS.t2774 VSS.n4085 9.06786
R13718 VSS.t1383 VSS.n1585 9.06786
R13719 VSS.t1896 VSS.n1660 9.06786
R13720 VSS.t1638 VSS.n1512 9.06786
R13721 VSS.t62 VSS.n1419 9.06786
R13722 VSS.t4312 VSS.n1727 9.06786
R13723 VSS.n895 VSS.t3333 9.06786
R13724 VSS.t2730 VSS.n953 9.06786
R13725 VSS.t1353 VSS.n1020 9.06786
R13726 VSS.t1871 VSS.n1088 9.06786
R13727 VSS.t1610 VSS.n5490 9.06786
R13728 VSS.t34 VSS.n863 9.06786
R13729 VSS.t3080 VSS.n5538 9.06786
R13730 VSS.n4971 VSS.t3113 9.06786
R13731 VSS.t2758 VSS.n5286 9.06786
R13732 VSS.t1329 VSS.n5030 9.06786
R13733 VSS.t1843 VSS.n4939 9.06786
R13734 VSS.t1582 VSS.n5097 9.06786
R13735 VSS.t3390 VSS.n5164 9.06786
R13736 VSS.t2589 VSS.n5212 9.06786
R13737 VSS.n3433 VSS.t4322 9.06786
R13738 VSS.t1175 VSS.n2334 9.06786
R13739 VSS.t1717 VSS.n2565 9.06786
R13740 VSS.t1982 VSS.n2493 9.06786
R13741 VSS.t1467 VSS.n3379 9.06786
R13742 VSS.t2448 VSS.n2419 9.06786
R13743 VSS.n2182 VSS.t2630 9.06786
R13744 VSS.t4189 VSS.n3940 9.06786
R13745 VSS.t1439 VSS.n3873 9.06786
R13746 VSS.t1949 VSS.n3666 9.06786
R13747 VSS.t1692 VSS.n3806 9.06786
R13748 VSS.t1137 VSS.n3758 9.06786
R13749 VSS.t4135 VSS.n3710 9.06786
R13750 VSS.n2292 VSS.t2229 9.02794
R13751 VSS.n3507 VSS.t2201 9.02794
R13752 VSS.n3052 VSS.t2173 9.02794
R13753 VSS.n5414 VSS.t2145 9.02794
R13754 VSS.n4831 VSS.t2117 9.02794
R13755 VSS.n5369 VSS.t2089 9.02794
R13756 VSS.n435 VSS.t2061 9.02794
R13757 VSS.n167 VSS.n166 9.0005
R13758 VSS.n6218 VSS.n6217 9.0005
R13759 VSS.n5978 VSS.n5977 9.0005
R13760 VSS.n5908 VSS.n5907 9.0005
R13761 VSS.n661 VSS.n660 9.0005
R13762 VSS.n5697 VSS.n5696 9.0005
R13763 VSS.n5793 VSS.n5792 9.0005
R13764 VSS.n5723 VSS.n5722 9.0005
R13765 VSS.n6026 VSS.n6025 9.0005
R13766 VSS.n597 VSS.n596 9.0005
R13767 VSS.n4722 VSS.n4211 9.0005
R13768 VSS.n4736 VSS.n4735 9.0005
R13769 VSS.n4703 VSS.n4702 9.0005
R13770 VSS.n6222 VSS.n6221 9.0005
R13771 VSS.n307 VSS.n306 9.0005
R13772 VSS.n6164 VSS.n6163 9.0005
R13773 VSS.n4485 VSS.n4484 9.0005
R13774 VSS.n4517 VSS.n4516 9.0005
R13775 VSS.n4528 VSS.n4527 9.0005
R13776 VSS.n4600 VSS.n326 9.0005
R13777 VSS.n56 VSS.n2 9.0005
R13778 VSS.n5346 VSS.n5345 9.0005
R13779 VSS.n5335 VSS.n5334 9.0005
R13780 VSS.n5130 VSS.n735 9.0005
R13781 VSS.n5063 VSS.n734 9.0005
R13782 VSS.n5834 VSS.n5833 9.0005
R13783 VSS.n5311 VSS.n5310 9.0005
R13784 VSS.n5319 VSS.n5318 9.0005
R13785 VSS.n5820 VSS.n5819 9.0005
R13786 VSS.n6072 VSS.n6048 9.0005
R13787 VSS.n6092 VSS.n6048 9.0005
R13788 VSS.n6048 VSS.n136 9.0005
R13789 VSS.n6091 VSS.n6074 9.0005
R13790 VSS.n6091 VSS.n6071 9.0005
R13791 VSS.n6091 VSS.n6076 9.0005
R13792 VSS.n6091 VSS.n6070 9.0005
R13793 VSS.n6091 VSS.n6078 9.0005
R13794 VSS.n6091 VSS.n6069 9.0005
R13795 VSS.n6091 VSS.n6080 9.0005
R13796 VSS.n6091 VSS.n6068 9.0005
R13797 VSS.n6091 VSS.n6082 9.0005
R13798 VSS.n6092 VSS.n6091 9.0005
R13799 VSS.n6091 VSS.n136 9.0005
R13800 VSS.n6094 VSS.n6054 9.0005
R13801 VSS.n6072 VSS.n6054 9.0005
R13802 VSS.n6074 VSS.n6054 9.0005
R13803 VSS.n6071 VSS.n6054 9.0005
R13804 VSS.n6076 VSS.n6054 9.0005
R13805 VSS.n6070 VSS.n6054 9.0005
R13806 VSS.n6078 VSS.n6054 9.0005
R13807 VSS.n6069 VSS.n6054 9.0005
R13808 VSS.n6080 VSS.n6054 9.0005
R13809 VSS.n6068 VSS.n6054 9.0005
R13810 VSS.n6082 VSS.n6054 9.0005
R13811 VSS.n6092 VSS.n6054 9.0005
R13812 VSS.n6054 VSS.n136 9.0005
R13813 VSS.n6094 VSS.n6056 9.0005
R13814 VSS.n6072 VSS.n6056 9.0005
R13815 VSS.n6074 VSS.n6056 9.0005
R13816 VSS.n6071 VSS.n6056 9.0005
R13817 VSS.n6076 VSS.n6056 9.0005
R13818 VSS.n6070 VSS.n6056 9.0005
R13819 VSS.n6078 VSS.n6056 9.0005
R13820 VSS.n6069 VSS.n6056 9.0005
R13821 VSS.n6080 VSS.n6056 9.0005
R13822 VSS.n6068 VSS.n6056 9.0005
R13823 VSS.n6082 VSS.n6056 9.0005
R13824 VSS.n6092 VSS.n6056 9.0005
R13825 VSS.n6056 VSS.n136 9.0005
R13826 VSS.n6094 VSS.n6053 9.0005
R13827 VSS.n6072 VSS.n6053 9.0005
R13828 VSS.n6074 VSS.n6053 9.0005
R13829 VSS.n6071 VSS.n6053 9.0005
R13830 VSS.n6076 VSS.n6053 9.0005
R13831 VSS.n6070 VSS.n6053 9.0005
R13832 VSS.n6078 VSS.n6053 9.0005
R13833 VSS.n6069 VSS.n6053 9.0005
R13834 VSS.n6080 VSS.n6053 9.0005
R13835 VSS.n6068 VSS.n6053 9.0005
R13836 VSS.n6082 VSS.n6053 9.0005
R13837 VSS.n6092 VSS.n6053 9.0005
R13838 VSS.n6053 VSS.n136 9.0005
R13839 VSS.n6094 VSS.n6057 9.0005
R13840 VSS.n6072 VSS.n6057 9.0005
R13841 VSS.n6074 VSS.n6057 9.0005
R13842 VSS.n6071 VSS.n6057 9.0005
R13843 VSS.n6076 VSS.n6057 9.0005
R13844 VSS.n6070 VSS.n6057 9.0005
R13845 VSS.n6078 VSS.n6057 9.0005
R13846 VSS.n6069 VSS.n6057 9.0005
R13847 VSS.n6080 VSS.n6057 9.0005
R13848 VSS.n6068 VSS.n6057 9.0005
R13849 VSS.n6082 VSS.n6057 9.0005
R13850 VSS.n6092 VSS.n6057 9.0005
R13851 VSS.n6057 VSS.n136 9.0005
R13852 VSS.n6094 VSS.n6052 9.0005
R13853 VSS.n6072 VSS.n6052 9.0005
R13854 VSS.n6074 VSS.n6052 9.0005
R13855 VSS.n6071 VSS.n6052 9.0005
R13856 VSS.n6076 VSS.n6052 9.0005
R13857 VSS.n6070 VSS.n6052 9.0005
R13858 VSS.n6078 VSS.n6052 9.0005
R13859 VSS.n6069 VSS.n6052 9.0005
R13860 VSS.n6080 VSS.n6052 9.0005
R13861 VSS.n6068 VSS.n6052 9.0005
R13862 VSS.n6082 VSS.n6052 9.0005
R13863 VSS.n6092 VSS.n6052 9.0005
R13864 VSS.n6052 VSS.n136 9.0005
R13865 VSS.n6094 VSS.n6058 9.0005
R13866 VSS.n6072 VSS.n6058 9.0005
R13867 VSS.n6074 VSS.n6058 9.0005
R13868 VSS.n6071 VSS.n6058 9.0005
R13869 VSS.n6076 VSS.n6058 9.0005
R13870 VSS.n6070 VSS.n6058 9.0005
R13871 VSS.n6078 VSS.n6058 9.0005
R13872 VSS.n6069 VSS.n6058 9.0005
R13873 VSS.n6080 VSS.n6058 9.0005
R13874 VSS.n6068 VSS.n6058 9.0005
R13875 VSS.n6082 VSS.n6058 9.0005
R13876 VSS.n6092 VSS.n6058 9.0005
R13877 VSS.n6058 VSS.n136 9.0005
R13878 VSS.n6094 VSS.n6051 9.0005
R13879 VSS.n6072 VSS.n6051 9.0005
R13880 VSS.n6074 VSS.n6051 9.0005
R13881 VSS.n6071 VSS.n6051 9.0005
R13882 VSS.n6076 VSS.n6051 9.0005
R13883 VSS.n6070 VSS.n6051 9.0005
R13884 VSS.n6078 VSS.n6051 9.0005
R13885 VSS.n6069 VSS.n6051 9.0005
R13886 VSS.n6080 VSS.n6051 9.0005
R13887 VSS.n6068 VSS.n6051 9.0005
R13888 VSS.n6082 VSS.n6051 9.0005
R13889 VSS.n6092 VSS.n6051 9.0005
R13890 VSS.n6051 VSS.n136 9.0005
R13891 VSS.n6094 VSS.n6059 9.0005
R13892 VSS.n6072 VSS.n6059 9.0005
R13893 VSS.n6074 VSS.n6059 9.0005
R13894 VSS.n6071 VSS.n6059 9.0005
R13895 VSS.n6076 VSS.n6059 9.0005
R13896 VSS.n6070 VSS.n6059 9.0005
R13897 VSS.n6078 VSS.n6059 9.0005
R13898 VSS.n6069 VSS.n6059 9.0005
R13899 VSS.n6080 VSS.n6059 9.0005
R13900 VSS.n6068 VSS.n6059 9.0005
R13901 VSS.n6082 VSS.n6059 9.0005
R13902 VSS.n6092 VSS.n6059 9.0005
R13903 VSS.n6059 VSS.n136 9.0005
R13904 VSS.n6094 VSS.n6050 9.0005
R13905 VSS.n6072 VSS.n6050 9.0005
R13906 VSS.n6074 VSS.n6050 9.0005
R13907 VSS.n6071 VSS.n6050 9.0005
R13908 VSS.n6076 VSS.n6050 9.0005
R13909 VSS.n6070 VSS.n6050 9.0005
R13910 VSS.n6078 VSS.n6050 9.0005
R13911 VSS.n6069 VSS.n6050 9.0005
R13912 VSS.n6080 VSS.n6050 9.0005
R13913 VSS.n6068 VSS.n6050 9.0005
R13914 VSS.n6082 VSS.n6050 9.0005
R13915 VSS.n6092 VSS.n6050 9.0005
R13916 VSS.n6050 VSS.n136 9.0005
R13917 VSS.n6094 VSS.n6060 9.0005
R13918 VSS.n6072 VSS.n6060 9.0005
R13919 VSS.n6074 VSS.n6060 9.0005
R13920 VSS.n6071 VSS.n6060 9.0005
R13921 VSS.n6076 VSS.n6060 9.0005
R13922 VSS.n6070 VSS.n6060 9.0005
R13923 VSS.n6078 VSS.n6060 9.0005
R13924 VSS.n6069 VSS.n6060 9.0005
R13925 VSS.n6080 VSS.n6060 9.0005
R13926 VSS.n6068 VSS.n6060 9.0005
R13927 VSS.n6082 VSS.n6060 9.0005
R13928 VSS.n6092 VSS.n6060 9.0005
R13929 VSS.n6060 VSS.n136 9.0005
R13930 VSS.n6094 VSS.n6049 9.0005
R13931 VSS.n6072 VSS.n6049 9.0005
R13932 VSS.n6074 VSS.n6049 9.0005
R13933 VSS.n6071 VSS.n6049 9.0005
R13934 VSS.n6076 VSS.n6049 9.0005
R13935 VSS.n6070 VSS.n6049 9.0005
R13936 VSS.n6078 VSS.n6049 9.0005
R13937 VSS.n6069 VSS.n6049 9.0005
R13938 VSS.n6080 VSS.n6049 9.0005
R13939 VSS.n6068 VSS.n6049 9.0005
R13940 VSS.n6082 VSS.n6049 9.0005
R13941 VSS.n6092 VSS.n6049 9.0005
R13942 VSS.n6049 VSS.n136 9.0005
R13943 VSS.n6094 VSS.n6093 9.0005
R13944 VSS.n6093 VSS.n6072 9.0005
R13945 VSS.n6093 VSS.n6074 9.0005
R13946 VSS.n6093 VSS.n6071 9.0005
R13947 VSS.n6093 VSS.n6076 9.0005
R13948 VSS.n6093 VSS.n6070 9.0005
R13949 VSS.n6093 VSS.n6078 9.0005
R13950 VSS.n6093 VSS.n6069 9.0005
R13951 VSS.n6093 VSS.n6080 9.0005
R13952 VSS.n6093 VSS.n6068 9.0005
R13953 VSS.n6093 VSS.n6082 9.0005
R13954 VSS.n6093 VSS.n6067 9.0005
R13955 VSS.n6093 VSS.n6092 9.0005
R13956 VSS.n6093 VSS.n136 9.0005
R13957 VSS.n4858 VSS.n1121 9.0005
R13958 VSS.n5456 VSS.n5455 9.0005
R13959 VSS.n5626 VSS.n5625 9.0005
R13960 VSS.n1054 VSS.n1053 9.0005
R13961 VSS.n5593 VSS.n5592 9.0005
R13962 VSS.n986 VSS.n814 9.0005
R13963 VSS.n5578 VSS.n5577 9.0005
R13964 VSS.n5611 VSS.n5610 9.0005
R13965 VSS.n6107 VSS.n381 9.0005
R13966 VSS.n6107 VSS.n382 9.0005
R13967 VSS.n6107 VSS.n6106 9.0005
R13968 VSS.n6033 VSS.n382 9.0005
R13969 VSS.n6106 VSS.n6033 9.0005
R13970 VSS.n6031 VSS.n381 9.0005
R13971 VSS.n6098 VSS.n6031 9.0005
R13972 VSS.n6040 VSS.n6031 9.0005
R13973 VSS.n6100 VSS.n6031 9.0005
R13974 VSS.n6039 VSS.n6031 9.0005
R13975 VSS.n6102 VSS.n6031 9.0005
R13976 VSS.n6038 VSS.n6031 9.0005
R13977 VSS.n6104 VSS.n6031 9.0005
R13978 VSS.n6031 VSS.n382 9.0005
R13979 VSS.n6106 VSS.n6031 9.0005
R13980 VSS.n6105 VSS.n381 9.0005
R13981 VSS.n6105 VSS.n6098 9.0005
R13982 VSS.n6105 VSS.n6040 9.0005
R13983 VSS.n6105 VSS.n6100 9.0005
R13984 VSS.n6105 VSS.n6039 9.0005
R13985 VSS.n6105 VSS.n6102 9.0005
R13986 VSS.n6105 VSS.n6038 9.0005
R13987 VSS.n6105 VSS.n6104 9.0005
R13988 VSS.n6106 VSS.n6105 9.0005
R13989 VSS.n5444 VSS.n5443 9.0005
R13990 VSS.n1684 VSS.n1683 9.0005
R13991 VSS.n1692 VSS.n1691 9.0005
R13992 VSS.n1610 VSS.n1609 9.0005
R13993 VSS.n4133 VSS.n4132 9.0005
R13994 VSS.n4109 VSS.n4108 9.0005
R13995 VSS.n4117 VSS.n4116 9.0005
R13996 VSS.n1232 VSS.n1184 9.0005
R13997 VSS.n6118 VSS.n363 9.0005
R13998 VSS.n6118 VSS.n364 9.0005
R13999 VSS.n6118 VSS.n6117 9.0005
R14000 VSS.n368 VSS.n364 9.0005
R14001 VSS.n6117 VSS.n368 9.0005
R14002 VSS.n366 VSS.n363 9.0005
R14003 VSS.n6109 VSS.n366 9.0005
R14004 VSS.n375 VSS.n366 9.0005
R14005 VSS.n6111 VSS.n366 9.0005
R14006 VSS.n374 VSS.n366 9.0005
R14007 VSS.n6113 VSS.n366 9.0005
R14008 VSS.n373 VSS.n366 9.0005
R14009 VSS.n6115 VSS.n366 9.0005
R14010 VSS.n366 VSS.n364 9.0005
R14011 VSS.n6117 VSS.n366 9.0005
R14012 VSS.n6116 VSS.n363 9.0005
R14013 VSS.n6116 VSS.n6109 9.0005
R14014 VSS.n6116 VSS.n375 9.0005
R14015 VSS.n6116 VSS.n6111 9.0005
R14016 VSS.n6116 VSS.n374 9.0005
R14017 VSS.n6116 VSS.n6113 9.0005
R14018 VSS.n6116 VSS.n373 9.0005
R14019 VSS.n6116 VSS.n6115 9.0005
R14020 VSS.n6117 VSS.n6116 9.0005
R14021 VSS.n3082 VSS.n3081 9.0005
R14022 VSS.n3091 VSS.n3090 9.0005
R14023 VSS.n3318 VSS.n3317 9.0005
R14024 VSS.n3162 VSS.n3161 9.0005
R14025 VSS.n2937 VSS.n1363 9.0005
R14026 VSS.n3227 VSS.n1362 9.0005
R14027 VSS.n1355 VSS.n1354 9.0005
R14028 VSS.n4154 VSS.n4153 9.0005
R14029 VSS.n6129 VSS.n345 9.0005
R14030 VSS.n6129 VSS.n346 9.0005
R14031 VSS.n6129 VSS.n6128 9.0005
R14032 VSS.n350 VSS.n346 9.0005
R14033 VSS.n6128 VSS.n350 9.0005
R14034 VSS.n348 VSS.n345 9.0005
R14035 VSS.n6120 VSS.n348 9.0005
R14036 VSS.n357 VSS.n348 9.0005
R14037 VSS.n6122 VSS.n348 9.0005
R14038 VSS.n356 VSS.n348 9.0005
R14039 VSS.n6124 VSS.n348 9.0005
R14040 VSS.n355 VSS.n348 9.0005
R14041 VSS.n6126 VSS.n348 9.0005
R14042 VSS.n348 VSS.n346 9.0005
R14043 VSS.n6128 VSS.n348 9.0005
R14044 VSS.n6127 VSS.n345 9.0005
R14045 VSS.n6127 VSS.n6120 9.0005
R14046 VSS.n6127 VSS.n357 9.0005
R14047 VSS.n6127 VSS.n6122 9.0005
R14048 VSS.n6127 VSS.n356 9.0005
R14049 VSS.n6127 VSS.n6124 9.0005
R14050 VSS.n6127 VSS.n355 9.0005
R14051 VSS.n6127 VSS.n6126 9.0005
R14052 VSS.n6128 VSS.n6127 9.0005
R14053 VSS.n3484 VSS.n1831 9.0005
R14054 VSS.n3996 VSS.n3995 9.0005
R14055 VSS.n3838 VSS.n1830 9.0005
R14056 VSS.n3906 VSS.n1820 9.0005
R14057 VSS.n4019 VSS.n4018 9.0005
R14058 VSS.n3979 VSS.n3978 9.0005
R14059 VSS.n4035 VSS.n4034 9.0005
R14060 VSS.n3527 VSS.n2131 9.0005
R14061 VSS.n339 VSS.n329 9.0005
R14062 VSS.n334 VSS.n329 9.0005
R14063 VSS.n6145 VSS.n329 9.0005
R14064 VSS.n334 VSS.n332 9.0005
R14065 VSS.n6145 VSS.n332 9.0005
R14066 VSS.n339 VSS.n328 9.0005
R14067 VSS.n6132 VSS.n328 9.0005
R14068 VSS.n338 VSS.n328 9.0005
R14069 VSS.n6135 VSS.n328 9.0005
R14070 VSS.n337 VSS.n328 9.0005
R14071 VSS.n6138 VSS.n328 9.0005
R14072 VSS.n336 VSS.n328 9.0005
R14073 VSS.n6143 VSS.n328 9.0005
R14074 VSS.n334 VSS.n328 9.0005
R14075 VSS.n6145 VSS.n328 9.0005
R14076 VSS.n6144 VSS.n339 9.0005
R14077 VSS.n6144 VSS.n6132 9.0005
R14078 VSS.n6144 VSS.n338 9.0005
R14079 VSS.n6144 VSS.n6135 9.0005
R14080 VSS.n6144 VSS.n337 9.0005
R14081 VSS.n6144 VSS.n6138 9.0005
R14082 VSS.n6144 VSS.n336 9.0005
R14083 VSS.n6144 VSS.n6143 9.0005
R14084 VSS.n6145 VSS.n6144 9.0005
R14085 VSS.n3613 VSS.n3612 9.0005
R14086 VSS.n2517 VSS.n2516 9.0005
R14087 VSS.n2589 VSS.n2588 9.0005
R14088 VSS.n3403 VSS.n3402 9.0005
R14089 VSS.n3411 VSS.n3410 9.0005
R14090 VSS.n2443 VSS.n2442 9.0005
R14091 VSS.n2370 VSS.n2369 9.0005
R14092 VSS.n4683 VSS.n4673 9.0005
R14093 VSS.n4678 VSS.n4673 9.0005
R14094 VSS.n4699 VSS.n4673 9.0005
R14095 VSS.n4678 VSS.n4676 9.0005
R14096 VSS.n4699 VSS.n4676 9.0005
R14097 VSS.n4683 VSS.n4627 9.0005
R14098 VSS.n4686 VSS.n4627 9.0005
R14099 VSS.n4682 VSS.n4627 9.0005
R14100 VSS.n4689 VSS.n4627 9.0005
R14101 VSS.n4681 VSS.n4627 9.0005
R14102 VSS.n4692 VSS.n4627 9.0005
R14103 VSS.n4680 VSS.n4627 9.0005
R14104 VSS.n4697 VSS.n4627 9.0005
R14105 VSS.n4678 VSS.n4627 9.0005
R14106 VSS.n4699 VSS.n4627 9.0005
R14107 VSS.n4698 VSS.n4683 9.0005
R14108 VSS.n4698 VSS.n4686 9.0005
R14109 VSS.n4698 VSS.n4682 9.0005
R14110 VSS.n4698 VSS.n4689 9.0005
R14111 VSS.n4698 VSS.n4681 9.0005
R14112 VSS.n4698 VSS.n4692 9.0005
R14113 VSS.n4698 VSS.n4680 9.0005
R14114 VSS.n4698 VSS.n4697 9.0005
R14115 VSS.n4699 VSS.n4698 9.0005
R14116 VSS.n2687 VSS.n2118 9.0005
R14117 VSS.n2687 VSS.n2624 9.0005
R14118 VSS.n2698 VSS.n2687 9.0005
R14119 VSS.n2697 VSS.n2696 9.0005
R14120 VSS.n2698 VSS.n2697 9.0005
R14121 VSS.n2696 VSS.n2625 9.0005
R14122 VSS.n2625 VSS.n2619 9.0005
R14123 VSS.n2625 VSS.n2621 9.0005
R14124 VSS.n2625 VSS.n2618 9.0005
R14125 VSS.n2625 VSS.n2622 9.0005
R14126 VSS.n2625 VSS.n2617 9.0005
R14127 VSS.n2625 VSS.n2623 9.0005
R14128 VSS.n2625 VSS.n2616 9.0005
R14129 VSS.n2625 VSS.n2624 9.0005
R14130 VSS.n2698 VSS.n2625 9.0005
R14131 VSS.n2699 VSS.n2619 9.0005
R14132 VSS.n2699 VSS.n2621 9.0005
R14133 VSS.n2699 VSS.n2618 9.0005
R14134 VSS.n2699 VSS.n2622 9.0005
R14135 VSS.n2699 VSS.n2617 9.0005
R14136 VSS.n2699 VSS.n2623 9.0005
R14137 VSS.n2699 VSS.n2616 9.0005
R14138 VSS.n2699 VSS.n2624 9.0005
R14139 VSS.n2699 VSS.n2698 9.0005
R14140 VSS.n2703 VSS.n2609 9.0005
R14141 VSS.n2713 VSS.n2703 9.0005
R14142 VSS.n2715 VSS.n2703 9.0005
R14143 VSS.n2714 VSS.n2713 9.0005
R14144 VSS.n2715 VSS.n2714 9.0005
R14145 VSS.n2614 VSS.n2609 9.0005
R14146 VSS.n2614 VSS.n2610 9.0005
R14147 VSS.n2614 VSS.n2608 9.0005
R14148 VSS.n2614 VSS.n2611 9.0005
R14149 VSS.n2614 VSS.n2607 9.0005
R14150 VSS.n2614 VSS.n2612 9.0005
R14151 VSS.n2614 VSS.n2606 9.0005
R14152 VSS.n2614 VSS.n2613 9.0005
R14153 VSS.n2713 VSS.n2614 9.0005
R14154 VSS.n2715 VSS.n2614 9.0005
R14155 VSS.n2716 VSS.n2609 9.0005
R14156 VSS.n2716 VSS.n2610 9.0005
R14157 VSS.n2716 VSS.n2608 9.0005
R14158 VSS.n2716 VSS.n2611 9.0005
R14159 VSS.n2716 VSS.n2607 9.0005
R14160 VSS.n2716 VSS.n2612 9.0005
R14161 VSS.n2716 VSS.n2606 9.0005
R14162 VSS.n2716 VSS.n2613 9.0005
R14163 VSS.n2716 VSS.n2715 9.0005
R14164 VSS.n2720 VSS.n2598 9.0005
R14165 VSS.n2730 VSS.n2720 9.0005
R14166 VSS.n2732 VSS.n2720 9.0005
R14167 VSS.n2731 VSS.n2730 9.0005
R14168 VSS.n2732 VSS.n2731 9.0005
R14169 VSS.n2603 VSS.n2598 9.0005
R14170 VSS.n2603 VSS.n2599 9.0005
R14171 VSS.n2603 VSS.n2596 9.0005
R14172 VSS.n2603 VSS.n2600 9.0005
R14173 VSS.n2603 VSS.n2595 9.0005
R14174 VSS.n2603 VSS.n2601 9.0005
R14175 VSS.n2603 VSS.n2594 9.0005
R14176 VSS.n2603 VSS.n2602 9.0005
R14177 VSS.n2730 VSS.n2603 9.0005
R14178 VSS.n2732 VSS.n2603 9.0005
R14179 VSS.n2733 VSS.n2598 9.0005
R14180 VSS.n2733 VSS.n2599 9.0005
R14181 VSS.n2733 VSS.n2596 9.0005
R14182 VSS.n2733 VSS.n2600 9.0005
R14183 VSS.n2733 VSS.n2595 9.0005
R14184 VSS.n2733 VSS.n2601 9.0005
R14185 VSS.n2733 VSS.n2594 9.0005
R14186 VSS.n2733 VSS.n2602 9.0005
R14187 VSS.n2733 VSS.n2732 9.0005
R14188 VSS.n2842 VSS.n2734 9.0005
R14189 VSS.n2838 VSS.n2734 9.0005
R14190 VSS.n2840 VSS.n2734 9.0005
R14191 VSS.n2839 VSS.n2838 9.0005
R14192 VSS.n2840 VSS.n2839 9.0005
R14193 VSS.n2842 VSS.n2591 9.0005
R14194 VSS.n2824 VSS.n2591 9.0005
R14195 VSS.n2739 VSS.n2591 9.0005
R14196 VSS.n2826 VSS.n2591 9.0005
R14197 VSS.n2738 VSS.n2591 9.0005
R14198 VSS.n2828 VSS.n2591 9.0005
R14199 VSS.n2737 VSS.n2591 9.0005
R14200 VSS.n2829 VSS.n2591 9.0005
R14201 VSS.n2838 VSS.n2591 9.0005
R14202 VSS.n2840 VSS.n2591 9.0005
R14203 VSS.n2842 VSS.n2841 9.0005
R14204 VSS.n2841 VSS.n2824 9.0005
R14205 VSS.n2841 VSS.n2739 9.0005
R14206 VSS.n2841 VSS.n2826 9.0005
R14207 VSS.n2841 VSS.n2738 9.0005
R14208 VSS.n2841 VSS.n2828 9.0005
R14209 VSS.n2841 VSS.n2737 9.0005
R14210 VSS.n2841 VSS.n2829 9.0005
R14211 VSS.n2841 VSS.n2840 9.0005
R14212 VSS.n2822 VSS.n1832 9.0005
R14213 VSS.n2822 VSS.n2745 9.0005
R14214 VSS.n2822 VSS.n2821 9.0005
R14215 VSS.n2748 VSS.n2745 9.0005
R14216 VSS.n2821 VSS.n2748 9.0005
R14217 VSS.n2746 VSS.n1832 9.0005
R14218 VSS.n2813 VSS.n2746 9.0005
R14219 VSS.n2755 VSS.n2746 9.0005
R14220 VSS.n2815 VSS.n2746 9.0005
R14221 VSS.n2754 VSS.n2746 9.0005
R14222 VSS.n2817 VSS.n2746 9.0005
R14223 VSS.n2753 VSS.n2746 9.0005
R14224 VSS.n2819 VSS.n2746 9.0005
R14225 VSS.n2746 VSS.n2745 9.0005
R14226 VSS.n2821 VSS.n2746 9.0005
R14227 VSS.n2820 VSS.n1832 9.0005
R14228 VSS.n2820 VSS.n2813 9.0005
R14229 VSS.n2820 VSS.n2755 9.0005
R14230 VSS.n2820 VSS.n2815 9.0005
R14231 VSS.n2820 VSS.n2754 9.0005
R14232 VSS.n2820 VSS.n2817 9.0005
R14233 VSS.n2820 VSS.n2753 9.0005
R14234 VSS.n2820 VSS.n2819 9.0005
R14235 VSS.n2821 VSS.n2820 9.0005
R14236 VSS.n2811 VSS.n2763 9.0005
R14237 VSS.n2811 VSS.n2810 9.0005
R14238 VSS.n2797 VSS.n2770 9.0005
R14239 VSS.n2770 VSS.n2763 9.0005
R14240 VSS.n2810 VSS.n2770 9.0005
R14241 VSS.n2797 VSS.n2773 9.0005
R14242 VSS.n2796 VSS.n2773 9.0005
R14243 VSS.n2799 VSS.n2773 9.0005
R14244 VSS.n2795 VSS.n2773 9.0005
R14245 VSS.n2801 VSS.n2773 9.0005
R14246 VSS.n2794 VSS.n2773 9.0005
R14247 VSS.n2803 VSS.n2773 9.0005
R14248 VSS.n2793 VSS.n2773 9.0005
R14249 VSS.n2805 VSS.n2773 9.0005
R14250 VSS.n2792 VSS.n2773 9.0005
R14251 VSS.n2807 VSS.n2773 9.0005
R14252 VSS.n2773 VSS.n2763 9.0005
R14253 VSS.n2810 VSS.n2773 9.0005
R14254 VSS.n2797 VSS.n2769 9.0005
R14255 VSS.n2796 VSS.n2769 9.0005
R14256 VSS.n2799 VSS.n2769 9.0005
R14257 VSS.n2795 VSS.n2769 9.0005
R14258 VSS.n2801 VSS.n2769 9.0005
R14259 VSS.n2794 VSS.n2769 9.0005
R14260 VSS.n2803 VSS.n2769 9.0005
R14261 VSS.n2793 VSS.n2769 9.0005
R14262 VSS.n2805 VSS.n2769 9.0005
R14263 VSS.n2792 VSS.n2769 9.0005
R14264 VSS.n2807 VSS.n2769 9.0005
R14265 VSS.n2769 VSS.n2763 9.0005
R14266 VSS.n2810 VSS.n2769 9.0005
R14267 VSS.n2797 VSS.n2775 9.0005
R14268 VSS.n2796 VSS.n2775 9.0005
R14269 VSS.n2799 VSS.n2775 9.0005
R14270 VSS.n2795 VSS.n2775 9.0005
R14271 VSS.n2801 VSS.n2775 9.0005
R14272 VSS.n2794 VSS.n2775 9.0005
R14273 VSS.n2803 VSS.n2775 9.0005
R14274 VSS.n2793 VSS.n2775 9.0005
R14275 VSS.n2805 VSS.n2775 9.0005
R14276 VSS.n2792 VSS.n2775 9.0005
R14277 VSS.n2807 VSS.n2775 9.0005
R14278 VSS.n2775 VSS.n2763 9.0005
R14279 VSS.n2810 VSS.n2775 9.0005
R14280 VSS.n2797 VSS.n2768 9.0005
R14281 VSS.n2796 VSS.n2768 9.0005
R14282 VSS.n2799 VSS.n2768 9.0005
R14283 VSS.n2795 VSS.n2768 9.0005
R14284 VSS.n2801 VSS.n2768 9.0005
R14285 VSS.n2794 VSS.n2768 9.0005
R14286 VSS.n2803 VSS.n2768 9.0005
R14287 VSS.n2793 VSS.n2768 9.0005
R14288 VSS.n2805 VSS.n2768 9.0005
R14289 VSS.n2792 VSS.n2768 9.0005
R14290 VSS.n2807 VSS.n2768 9.0005
R14291 VSS.n2768 VSS.n2763 9.0005
R14292 VSS.n2810 VSS.n2768 9.0005
R14293 VSS.n2797 VSS.n2777 9.0005
R14294 VSS.n2796 VSS.n2777 9.0005
R14295 VSS.n2799 VSS.n2777 9.0005
R14296 VSS.n2795 VSS.n2777 9.0005
R14297 VSS.n2801 VSS.n2777 9.0005
R14298 VSS.n2794 VSS.n2777 9.0005
R14299 VSS.n2803 VSS.n2777 9.0005
R14300 VSS.n2793 VSS.n2777 9.0005
R14301 VSS.n2805 VSS.n2777 9.0005
R14302 VSS.n2792 VSS.n2777 9.0005
R14303 VSS.n2807 VSS.n2777 9.0005
R14304 VSS.n2777 VSS.n2763 9.0005
R14305 VSS.n2810 VSS.n2777 9.0005
R14306 VSS.n2797 VSS.n2767 9.0005
R14307 VSS.n2796 VSS.n2767 9.0005
R14308 VSS.n2799 VSS.n2767 9.0005
R14309 VSS.n2795 VSS.n2767 9.0005
R14310 VSS.n2801 VSS.n2767 9.0005
R14311 VSS.n2794 VSS.n2767 9.0005
R14312 VSS.n2803 VSS.n2767 9.0005
R14313 VSS.n2793 VSS.n2767 9.0005
R14314 VSS.n2805 VSS.n2767 9.0005
R14315 VSS.n2792 VSS.n2767 9.0005
R14316 VSS.n2807 VSS.n2767 9.0005
R14317 VSS.n2767 VSS.n2763 9.0005
R14318 VSS.n2810 VSS.n2767 9.0005
R14319 VSS.n2797 VSS.n2779 9.0005
R14320 VSS.n2796 VSS.n2779 9.0005
R14321 VSS.n2799 VSS.n2779 9.0005
R14322 VSS.n2795 VSS.n2779 9.0005
R14323 VSS.n2801 VSS.n2779 9.0005
R14324 VSS.n2794 VSS.n2779 9.0005
R14325 VSS.n2803 VSS.n2779 9.0005
R14326 VSS.n2793 VSS.n2779 9.0005
R14327 VSS.n2805 VSS.n2779 9.0005
R14328 VSS.n2792 VSS.n2779 9.0005
R14329 VSS.n2807 VSS.n2779 9.0005
R14330 VSS.n2779 VSS.n2763 9.0005
R14331 VSS.n2810 VSS.n2779 9.0005
R14332 VSS.n2797 VSS.n2766 9.0005
R14333 VSS.n2796 VSS.n2766 9.0005
R14334 VSS.n2799 VSS.n2766 9.0005
R14335 VSS.n2795 VSS.n2766 9.0005
R14336 VSS.n2801 VSS.n2766 9.0005
R14337 VSS.n2794 VSS.n2766 9.0005
R14338 VSS.n2803 VSS.n2766 9.0005
R14339 VSS.n2793 VSS.n2766 9.0005
R14340 VSS.n2805 VSS.n2766 9.0005
R14341 VSS.n2792 VSS.n2766 9.0005
R14342 VSS.n2807 VSS.n2766 9.0005
R14343 VSS.n2766 VSS.n2763 9.0005
R14344 VSS.n2810 VSS.n2766 9.0005
R14345 VSS.n2797 VSS.n2781 9.0005
R14346 VSS.n2796 VSS.n2781 9.0005
R14347 VSS.n2799 VSS.n2781 9.0005
R14348 VSS.n2795 VSS.n2781 9.0005
R14349 VSS.n2801 VSS.n2781 9.0005
R14350 VSS.n2794 VSS.n2781 9.0005
R14351 VSS.n2803 VSS.n2781 9.0005
R14352 VSS.n2793 VSS.n2781 9.0005
R14353 VSS.n2805 VSS.n2781 9.0005
R14354 VSS.n2792 VSS.n2781 9.0005
R14355 VSS.n2807 VSS.n2781 9.0005
R14356 VSS.n2781 VSS.n2763 9.0005
R14357 VSS.n2810 VSS.n2781 9.0005
R14358 VSS.n2797 VSS.n2765 9.0005
R14359 VSS.n2796 VSS.n2765 9.0005
R14360 VSS.n2799 VSS.n2765 9.0005
R14361 VSS.n2795 VSS.n2765 9.0005
R14362 VSS.n2801 VSS.n2765 9.0005
R14363 VSS.n2794 VSS.n2765 9.0005
R14364 VSS.n2803 VSS.n2765 9.0005
R14365 VSS.n2793 VSS.n2765 9.0005
R14366 VSS.n2805 VSS.n2765 9.0005
R14367 VSS.n2792 VSS.n2765 9.0005
R14368 VSS.n2807 VSS.n2765 9.0005
R14369 VSS.n2765 VSS.n2763 9.0005
R14370 VSS.n2810 VSS.n2765 9.0005
R14371 VSS.n2797 VSS.n2783 9.0005
R14372 VSS.n2796 VSS.n2783 9.0005
R14373 VSS.n2799 VSS.n2783 9.0005
R14374 VSS.n2795 VSS.n2783 9.0005
R14375 VSS.n2801 VSS.n2783 9.0005
R14376 VSS.n2794 VSS.n2783 9.0005
R14377 VSS.n2803 VSS.n2783 9.0005
R14378 VSS.n2793 VSS.n2783 9.0005
R14379 VSS.n2805 VSS.n2783 9.0005
R14380 VSS.n2792 VSS.n2783 9.0005
R14381 VSS.n2807 VSS.n2783 9.0005
R14382 VSS.n2783 VSS.n2763 9.0005
R14383 VSS.n2810 VSS.n2783 9.0005
R14384 VSS.n2797 VSS.n2764 9.0005
R14385 VSS.n2796 VSS.n2764 9.0005
R14386 VSS.n2799 VSS.n2764 9.0005
R14387 VSS.n2795 VSS.n2764 9.0005
R14388 VSS.n2801 VSS.n2764 9.0005
R14389 VSS.n2794 VSS.n2764 9.0005
R14390 VSS.n2803 VSS.n2764 9.0005
R14391 VSS.n2793 VSS.n2764 9.0005
R14392 VSS.n2805 VSS.n2764 9.0005
R14393 VSS.n2792 VSS.n2764 9.0005
R14394 VSS.n2807 VSS.n2764 9.0005
R14395 VSS.n2764 VSS.n2763 9.0005
R14396 VSS.n2810 VSS.n2764 9.0005
R14397 VSS.n2809 VSS.n2797 9.0005
R14398 VSS.n2809 VSS.n2796 9.0005
R14399 VSS.n2809 VSS.n2799 9.0005
R14400 VSS.n2809 VSS.n2795 9.0005
R14401 VSS.n2809 VSS.n2801 9.0005
R14402 VSS.n2809 VSS.n2794 9.0005
R14403 VSS.n2809 VSS.n2803 9.0005
R14404 VSS.n2809 VSS.n2793 9.0005
R14405 VSS.n2809 VSS.n2805 9.0005
R14406 VSS.n2809 VSS.n2792 9.0005
R14407 VSS.n2809 VSS.n2807 9.0005
R14408 VSS.n2810 VSS.n2809 9.0005
R14409 VSS.n2652 VSS.n2632 9.0005
R14410 VSS.n2652 VSS.n2640 9.0005
R14411 VSS.n2682 VSS.n2652 9.0005
R14412 VSS.n2664 VSS.n2635 9.0005
R14413 VSS.n2664 VSS.n2631 9.0005
R14414 VSS.n2664 VSS.n2636 9.0005
R14415 VSS.n2664 VSS.n2630 9.0005
R14416 VSS.n2664 VSS.n2637 9.0005
R14417 VSS.n2664 VSS.n2629 9.0005
R14418 VSS.n2664 VSS.n2638 9.0005
R14419 VSS.n2664 VSS.n2628 9.0005
R14420 VSS.n2664 VSS.n2639 9.0005
R14421 VSS.n2664 VSS.n2640 9.0005
R14422 VSS.n2682 VSS.n2664 9.0005
R14423 VSS.n2646 VSS.n2634 9.0005
R14424 VSS.n2646 VSS.n2632 9.0005
R14425 VSS.n2646 VSS.n2635 9.0005
R14426 VSS.n2646 VSS.n2631 9.0005
R14427 VSS.n2646 VSS.n2636 9.0005
R14428 VSS.n2646 VSS.n2630 9.0005
R14429 VSS.n2646 VSS.n2637 9.0005
R14430 VSS.n2646 VSS.n2629 9.0005
R14431 VSS.n2646 VSS.n2638 9.0005
R14432 VSS.n2646 VSS.n2628 9.0005
R14433 VSS.n2646 VSS.n2639 9.0005
R14434 VSS.n2646 VSS.n2640 9.0005
R14435 VSS.n2682 VSS.n2646 9.0005
R14436 VSS.n2666 VSS.n2634 9.0005
R14437 VSS.n2666 VSS.n2632 9.0005
R14438 VSS.n2666 VSS.n2635 9.0005
R14439 VSS.n2666 VSS.n2631 9.0005
R14440 VSS.n2666 VSS.n2636 9.0005
R14441 VSS.n2666 VSS.n2630 9.0005
R14442 VSS.n2666 VSS.n2637 9.0005
R14443 VSS.n2666 VSS.n2629 9.0005
R14444 VSS.n2666 VSS.n2638 9.0005
R14445 VSS.n2666 VSS.n2628 9.0005
R14446 VSS.n2666 VSS.n2639 9.0005
R14447 VSS.n2666 VSS.n2640 9.0005
R14448 VSS.n2682 VSS.n2666 9.0005
R14449 VSS.n2645 VSS.n2634 9.0005
R14450 VSS.n2645 VSS.n2632 9.0005
R14451 VSS.n2645 VSS.n2635 9.0005
R14452 VSS.n2645 VSS.n2631 9.0005
R14453 VSS.n2645 VSS.n2636 9.0005
R14454 VSS.n2645 VSS.n2630 9.0005
R14455 VSS.n2645 VSS.n2637 9.0005
R14456 VSS.n2645 VSS.n2629 9.0005
R14457 VSS.n2645 VSS.n2638 9.0005
R14458 VSS.n2645 VSS.n2628 9.0005
R14459 VSS.n2645 VSS.n2639 9.0005
R14460 VSS.n2645 VSS.n2640 9.0005
R14461 VSS.n2682 VSS.n2645 9.0005
R14462 VSS.n2668 VSS.n2634 9.0005
R14463 VSS.n2668 VSS.n2632 9.0005
R14464 VSS.n2668 VSS.n2635 9.0005
R14465 VSS.n2668 VSS.n2631 9.0005
R14466 VSS.n2668 VSS.n2636 9.0005
R14467 VSS.n2668 VSS.n2630 9.0005
R14468 VSS.n2668 VSS.n2637 9.0005
R14469 VSS.n2668 VSS.n2629 9.0005
R14470 VSS.n2668 VSS.n2638 9.0005
R14471 VSS.n2668 VSS.n2628 9.0005
R14472 VSS.n2668 VSS.n2639 9.0005
R14473 VSS.n2668 VSS.n2640 9.0005
R14474 VSS.n2682 VSS.n2668 9.0005
R14475 VSS.n2644 VSS.n2634 9.0005
R14476 VSS.n2644 VSS.n2632 9.0005
R14477 VSS.n2644 VSS.n2635 9.0005
R14478 VSS.n2644 VSS.n2631 9.0005
R14479 VSS.n2644 VSS.n2636 9.0005
R14480 VSS.n2644 VSS.n2630 9.0005
R14481 VSS.n2644 VSS.n2637 9.0005
R14482 VSS.n2644 VSS.n2629 9.0005
R14483 VSS.n2644 VSS.n2638 9.0005
R14484 VSS.n2644 VSS.n2628 9.0005
R14485 VSS.n2644 VSS.n2639 9.0005
R14486 VSS.n2644 VSS.n2640 9.0005
R14487 VSS.n2682 VSS.n2644 9.0005
R14488 VSS.n2670 VSS.n2634 9.0005
R14489 VSS.n2670 VSS.n2632 9.0005
R14490 VSS.n2670 VSS.n2635 9.0005
R14491 VSS.n2670 VSS.n2631 9.0005
R14492 VSS.n2670 VSS.n2636 9.0005
R14493 VSS.n2670 VSS.n2630 9.0005
R14494 VSS.n2670 VSS.n2637 9.0005
R14495 VSS.n2670 VSS.n2629 9.0005
R14496 VSS.n2670 VSS.n2638 9.0005
R14497 VSS.n2670 VSS.n2628 9.0005
R14498 VSS.n2670 VSS.n2639 9.0005
R14499 VSS.n2670 VSS.n2640 9.0005
R14500 VSS.n2682 VSS.n2670 9.0005
R14501 VSS.n2643 VSS.n2634 9.0005
R14502 VSS.n2643 VSS.n2632 9.0005
R14503 VSS.n2643 VSS.n2635 9.0005
R14504 VSS.n2643 VSS.n2631 9.0005
R14505 VSS.n2643 VSS.n2636 9.0005
R14506 VSS.n2643 VSS.n2630 9.0005
R14507 VSS.n2643 VSS.n2637 9.0005
R14508 VSS.n2643 VSS.n2629 9.0005
R14509 VSS.n2643 VSS.n2638 9.0005
R14510 VSS.n2643 VSS.n2628 9.0005
R14511 VSS.n2643 VSS.n2639 9.0005
R14512 VSS.n2643 VSS.n2640 9.0005
R14513 VSS.n2682 VSS.n2643 9.0005
R14514 VSS.n2672 VSS.n2634 9.0005
R14515 VSS.n2672 VSS.n2632 9.0005
R14516 VSS.n2672 VSS.n2635 9.0005
R14517 VSS.n2672 VSS.n2631 9.0005
R14518 VSS.n2672 VSS.n2636 9.0005
R14519 VSS.n2672 VSS.n2630 9.0005
R14520 VSS.n2672 VSS.n2637 9.0005
R14521 VSS.n2672 VSS.n2629 9.0005
R14522 VSS.n2672 VSS.n2638 9.0005
R14523 VSS.n2672 VSS.n2628 9.0005
R14524 VSS.n2672 VSS.n2639 9.0005
R14525 VSS.n2672 VSS.n2640 9.0005
R14526 VSS.n2682 VSS.n2672 9.0005
R14527 VSS.n2642 VSS.n2634 9.0005
R14528 VSS.n2642 VSS.n2632 9.0005
R14529 VSS.n2642 VSS.n2635 9.0005
R14530 VSS.n2642 VSS.n2631 9.0005
R14531 VSS.n2642 VSS.n2636 9.0005
R14532 VSS.n2642 VSS.n2630 9.0005
R14533 VSS.n2642 VSS.n2637 9.0005
R14534 VSS.n2642 VSS.n2629 9.0005
R14535 VSS.n2642 VSS.n2638 9.0005
R14536 VSS.n2642 VSS.n2628 9.0005
R14537 VSS.n2642 VSS.n2639 9.0005
R14538 VSS.n2642 VSS.n2640 9.0005
R14539 VSS.n2682 VSS.n2642 9.0005
R14540 VSS.n2681 VSS.n2634 9.0005
R14541 VSS.n2681 VSS.n2632 9.0005
R14542 VSS.n2681 VSS.n2635 9.0005
R14543 VSS.n2681 VSS.n2631 9.0005
R14544 VSS.n2681 VSS.n2636 9.0005
R14545 VSS.n2681 VSS.n2630 9.0005
R14546 VSS.n2681 VSS.n2637 9.0005
R14547 VSS.n2681 VSS.n2629 9.0005
R14548 VSS.n2681 VSS.n2638 9.0005
R14549 VSS.n2681 VSS.n2628 9.0005
R14550 VSS.n2681 VSS.n2639 9.0005
R14551 VSS.n2681 VSS.n2640 9.0005
R14552 VSS.n2682 VSS.n2681 9.0005
R14553 VSS.n2641 VSS.n2634 9.0005
R14554 VSS.n2641 VSS.n2632 9.0005
R14555 VSS.n2641 VSS.n2635 9.0005
R14556 VSS.n2641 VSS.n2631 9.0005
R14557 VSS.n2641 VSS.n2636 9.0005
R14558 VSS.n2641 VSS.n2630 9.0005
R14559 VSS.n2641 VSS.n2637 9.0005
R14560 VSS.n2641 VSS.n2629 9.0005
R14561 VSS.n2641 VSS.n2638 9.0005
R14562 VSS.n2641 VSS.n2628 9.0005
R14563 VSS.n2641 VSS.n2639 9.0005
R14564 VSS.n2641 VSS.n2640 9.0005
R14565 VSS.n2682 VSS.n2641 9.0005
R14566 VSS.n2683 VSS.n2634 9.0005
R14567 VSS.n2683 VSS.n2632 9.0005
R14568 VSS.n2683 VSS.n2635 9.0005
R14569 VSS.n2683 VSS.n2631 9.0005
R14570 VSS.n2683 VSS.n2636 9.0005
R14571 VSS.n2683 VSS.n2630 9.0005
R14572 VSS.n2683 VSS.n2637 9.0005
R14573 VSS.n2683 VSS.n2629 9.0005
R14574 VSS.n2683 VSS.n2638 9.0005
R14575 VSS.n2683 VSS.n2628 9.0005
R14576 VSS.n2683 VSS.n2639 9.0005
R14577 VSS.n2683 VSS.n2627 9.0005
R14578 VSS.n2683 VSS.n2640 9.0005
R14579 VSS.n2683 VSS.n2682 9.0005
R14580 VSS.n4647 VSS.n4633 9.0005
R14581 VSS.n4669 VSS.n4647 9.0005
R14582 VSS.n4671 VSS.n4647 9.0005
R14583 VSS.n4669 VSS.n4654 9.0005
R14584 VSS.n4671 VSS.n4654 9.0005
R14585 VSS.n4643 VSS.n4633 9.0005
R14586 VSS.n4643 VSS.n4634 9.0005
R14587 VSS.n4643 VSS.n4632 9.0005
R14588 VSS.n4643 VSS.n4635 9.0005
R14589 VSS.n4643 VSS.n4631 9.0005
R14590 VSS.n4643 VSS.n4636 9.0005
R14591 VSS.n4643 VSS.n4630 9.0005
R14592 VSS.n4643 VSS.n4637 9.0005
R14593 VSS.n4669 VSS.n4643 9.0005
R14594 VSS.n4671 VSS.n4643 9.0005
R14595 VSS.n4656 VSS.n4633 9.0005
R14596 VSS.n4656 VSS.n4634 9.0005
R14597 VSS.n4656 VSS.n4632 9.0005
R14598 VSS.n4656 VSS.n4635 9.0005
R14599 VSS.n4656 VSS.n4631 9.0005
R14600 VSS.n4656 VSS.n4636 9.0005
R14601 VSS.n4656 VSS.n4630 9.0005
R14602 VSS.n4656 VSS.n4637 9.0005
R14603 VSS.n4669 VSS.n4656 9.0005
R14604 VSS.n4671 VSS.n4656 9.0005
R14605 VSS.n4642 VSS.n4633 9.0005
R14606 VSS.n4642 VSS.n4634 9.0005
R14607 VSS.n4642 VSS.n4632 9.0005
R14608 VSS.n4642 VSS.n4635 9.0005
R14609 VSS.n4642 VSS.n4631 9.0005
R14610 VSS.n4642 VSS.n4636 9.0005
R14611 VSS.n4642 VSS.n4630 9.0005
R14612 VSS.n4642 VSS.n4637 9.0005
R14613 VSS.n4669 VSS.n4642 9.0005
R14614 VSS.n4671 VSS.n4642 9.0005
R14615 VSS.n4658 VSS.n4633 9.0005
R14616 VSS.n4658 VSS.n4634 9.0005
R14617 VSS.n4658 VSS.n4632 9.0005
R14618 VSS.n4658 VSS.n4635 9.0005
R14619 VSS.n4658 VSS.n4631 9.0005
R14620 VSS.n4658 VSS.n4636 9.0005
R14621 VSS.n4658 VSS.n4630 9.0005
R14622 VSS.n4658 VSS.n4637 9.0005
R14623 VSS.n4669 VSS.n4658 9.0005
R14624 VSS.n4671 VSS.n4658 9.0005
R14625 VSS.n4641 VSS.n4633 9.0005
R14626 VSS.n4641 VSS.n4634 9.0005
R14627 VSS.n4641 VSS.n4632 9.0005
R14628 VSS.n4641 VSS.n4635 9.0005
R14629 VSS.n4641 VSS.n4631 9.0005
R14630 VSS.n4641 VSS.n4636 9.0005
R14631 VSS.n4641 VSS.n4630 9.0005
R14632 VSS.n4641 VSS.n4637 9.0005
R14633 VSS.n4669 VSS.n4641 9.0005
R14634 VSS.n4671 VSS.n4641 9.0005
R14635 VSS.n4660 VSS.n4633 9.0005
R14636 VSS.n4660 VSS.n4634 9.0005
R14637 VSS.n4660 VSS.n4632 9.0005
R14638 VSS.n4660 VSS.n4635 9.0005
R14639 VSS.n4660 VSS.n4631 9.0005
R14640 VSS.n4660 VSS.n4636 9.0005
R14641 VSS.n4660 VSS.n4630 9.0005
R14642 VSS.n4660 VSS.n4637 9.0005
R14643 VSS.n4669 VSS.n4660 9.0005
R14644 VSS.n4671 VSS.n4660 9.0005
R14645 VSS.n4640 VSS.n4633 9.0005
R14646 VSS.n4640 VSS.n4634 9.0005
R14647 VSS.n4640 VSS.n4632 9.0005
R14648 VSS.n4640 VSS.n4635 9.0005
R14649 VSS.n4640 VSS.n4631 9.0005
R14650 VSS.n4640 VSS.n4636 9.0005
R14651 VSS.n4640 VSS.n4630 9.0005
R14652 VSS.n4640 VSS.n4637 9.0005
R14653 VSS.n4669 VSS.n4640 9.0005
R14654 VSS.n4671 VSS.n4640 9.0005
R14655 VSS.n4670 VSS.n4633 9.0005
R14656 VSS.n4670 VSS.n4634 9.0005
R14657 VSS.n4670 VSS.n4632 9.0005
R14658 VSS.n4670 VSS.n4635 9.0005
R14659 VSS.n4670 VSS.n4631 9.0005
R14660 VSS.n4670 VSS.n4636 9.0005
R14661 VSS.n4670 VSS.n4630 9.0005
R14662 VSS.n4670 VSS.n4637 9.0005
R14663 VSS.n4670 VSS.n4669 9.0005
R14664 VSS.n4671 VSS.n4670 9.0005
R14665 VSS.n4639 VSS.n4633 9.0005
R14666 VSS.n4639 VSS.n4634 9.0005
R14667 VSS.n4639 VSS.n4632 9.0005
R14668 VSS.n4639 VSS.n4635 9.0005
R14669 VSS.n4639 VSS.n4631 9.0005
R14670 VSS.n4639 VSS.n4636 9.0005
R14671 VSS.n4639 VSS.n4630 9.0005
R14672 VSS.n4639 VSS.n4637 9.0005
R14673 VSS.n4669 VSS.n4639 9.0005
R14674 VSS.n4671 VSS.n4639 9.0005
R14675 VSS.n4672 VSS.n4633 9.0005
R14676 VSS.n4672 VSS.n4634 9.0005
R14677 VSS.n4672 VSS.n4632 9.0005
R14678 VSS.n4672 VSS.n4635 9.0005
R14679 VSS.n4672 VSS.n4631 9.0005
R14680 VSS.n4672 VSS.n4636 9.0005
R14681 VSS.n4672 VSS.n4630 9.0005
R14682 VSS.n4672 VSS.n4637 9.0005
R14683 VSS.n4672 VSS.n4671 9.0005
R14684 VSS.n3513 VSS.t230 8.98373
R14685 VSS.t224 VSS.n1189 8.98373
R14686 VSS.t221 VSS.n1169 8.98373
R14687 VSS.n5380 VSS.t218 8.98373
R14688 VSS.n4755 VSS.t209 8.98373
R14689 VSS.t206 VSS.n4239 8.98373
R14690 VSS.n2300 VSS.t2242 8.94446
R14691 VSS.t3602 VSS.n3474 8.94446
R14692 VSS.n2252 VSS.t2214 8.94446
R14693 VSS.t4101 VSS.n3012 8.94446
R14694 VSS.n3060 VSS.t2186 8.94446
R14695 VSS.t3495 VSS.n1134 8.94446
R14696 VSS.n5422 VSS.t2158 8.94446
R14697 VSS.t3128 VSS.n4849 8.94446
R14698 VSS.n4839 VSS.t2130 8.94446
R14699 VSS.t2635 VSS.n4882 8.94446
R14700 VSS.n4793 VSS.t2102 8.94446
R14701 VSS.t3064 VSS.n394 8.94446
R14702 VSS.n6005 VSS.t2074 8.94446
R14703 VSS.n1908 VSS.t3330 8.94138
R14704 VSS.n152 VSS.t1748 8.88616
R14705 VSS.t3442 VSS.n1951 8.85745
R14706 VSS.n1789 VSS.t514 8.85262
R14707 VSS.n138 VSS.t2022 8.81286
R14708 VSS.n4621 VSS.t2602 8.80385
R14709 VSS.n4720 VSS.t2533 8.80385
R14710 VSS.n4717 VSS.t3345 8.80385
R14711 VSS.n162 VSS.t1743 8.80285
R14712 VSS.n162 VSS.t1750 8.80285
R14713 VSS.n6177 VSS.t2013 8.80285
R14714 VSS.n6211 VSS.t2017 8.80285
R14715 VSS VSS.t4167 8.80285
R14716 VSS.n4717 VSS.t3342 8.80285
R14717 VSS.n6209 VSS.t2030 8.76678
R14718 VSS.n4620 VSS.t3050 8.76678
R14719 VSS.n4733 VSS.t3088 8.75144
R14720 VSS.n2019 VSS.t2936 8.74885
R14721 VSS.n1986 VSS.t2580 8.74885
R14722 VSS.n4547 VSS.t2389 8.74785
R14723 VSS.n4296 VSS.t4023 8.74785
R14724 VSS.n4384 VSS.t2435 8.74785
R14725 VSS.n4423 VSS.t1290 8.74785
R14726 VSS.n181 VSS.t1548 8.74785
R14727 VSS.n257 VSS.t1808 8.74785
R14728 VSS.n102 VSS.t2052 8.74785
R14729 VSS.n4276 VSS.t3265 8.74785
R14730 VSS.n3917 VSS.t2646 8.74785
R14731 VSS.n3850 VSS.t1458 8.74785
R14732 VSS.n3643 VSS.t1970 8.74785
R14733 VSS.n3783 VSS.t1711 8.74785
R14734 VSS.n3735 VSS.t1157 8.74785
R14735 VSS.n3687 VSS.t4289 8.74785
R14736 VSS.n2311 VSS.t1193 8.74785
R14737 VSS.n2542 VSS.t1737 8.74785
R14738 VSS.n2259 VSS.t2248 8.74785
R14739 VSS.n4766 VSS.t2108 8.74785
R14740 VSS.n4800 VSS.t2136 8.74785
R14741 VSS.n1142 VSS.t2164 8.74785
R14742 VSS.n3020 VSS.t2192 8.74785
R14743 VSS.n2225 VSS.t2220 8.74785
R14744 VSS.n5933 VSS.t2324 8.74785
R14745 VSS.n5863 VSS.t2751 8.74785
R14746 VSS.n616 VSS.t14 8.74785
R14747 VSS.n5654 VSS.t1308 8.74785
R14748 VSS.n5748 VSS.t1576 8.74785
R14749 VSS.n445 VSS.t1835 8.74785
R14750 VSS.n403 VSS.t2080 8.74785
R14751 VSS.n519 VSS.t4305 8.74785
R14752 VSS.n5189 VSS.t2869 8.74785
R14753 VSS.n5141 VSS.t27 8.74785
R14754 VSS.n5074 VSS.t1602 8.74785
R14755 VSS.n4916 VSS.t1862 8.74785
R14756 VSS.n5007 VSS.t1331 8.74785
R14757 VSS.n5263 VSS.t3171 8.74785
R14758 VSS.n5515 VSS.t3409 8.74785
R14759 VSS.n840 VSS.t55 8.74785
R14760 VSS.n5467 VSS.t1629 8.74785
R14761 VSS.n1065 VSS.t1890 8.74785
R14762 VSS.n997 VSS.t1374 8.74785
R14763 VSS.n930 VSS.t2703 8.74785
R14764 VSS.n1704 VSS.t3194 8.74785
R14765 VSS.n1396 VSS.t83 8.74785
R14766 VSS.n1489 VSS.t1657 8.74785
R14767 VSS.n1637 VSS.t1916 8.74785
R14768 VSS.n1562 VSS.t1402 8.74785
R14769 VSS.n4062 VSS.t3316 8.74785
R14770 VSS.n4173 VSS.t2725 8.74785
R14771 VSS.n2946 VSS.t1121 8.74785
R14772 VSS.n3299 VSS.t1683 8.74785
R14773 VSS.n3100 VSS.t1943 8.74785
R14774 VSS.n3171 VSS.t1430 8.74785
R14775 VSS.n3235 VSS.t2620 8.74785
R14776 VSS.n3280 VSS.t2482 8.74785
R14777 VSS.n1469 VSS.t4097 8.74785
R14778 VSS.n913 VSS.t2985 8.74785
R14779 VSS.n4989 VSS.t2926 8.74785
R14780 VSS.n2470 VSS.t2001 8.74785
R14781 VSS.n3356 VSS.t1486 8.74785
R14782 VSS.n2396 VSS.t2463 8.74785
R14783 VSS.n2019 VSS.t2683 8.74785
R14784 VSS.n1986 VSS.t2 8.74785
R14785 VSS.n3451 VSS.t2741 8.74785
R14786 VSS.n2200 VSS.t2673 8.74785
R14787 VSS.n4228 VSS.t3471 8.71077
R14788 VSS.n4625 VSS.t3040 8.71077
R14789 VSS.n4570 VSS.t3337 8.70977
R14790 VSS.n4319 VSS.t2850 8.70977
R14791 VSS.n4410 VSS.t2689 8.70977
R14792 VSS.n4446 VSS.t1243 8.70977
R14793 VSS.n206 VSS.t1491 8.70977
R14794 VSS.n282 VSS.t1753 8.70977
R14795 VSS.n114 VSS.t2026 8.70977
R14796 VSS.n4256 VSS.t2565 8.70977
R14797 VSS.n6178 VSS.t2006 8.70977
R14798 VSS.n6190 VSS.t1979 8.70977
R14799 VSS.n6190 VSS.t2008 8.70977
R14800 VSS.n4228 VSS.t3473 8.70977
R14801 VSS.n3922 VSS.t4187 8.70977
R14802 VSS.n3855 VSS.t1436 8.70977
R14803 VSS.n3648 VSS.t1948 8.70977
R14804 VSS.n3788 VSS.t1688 8.70977
R14805 VSS.n3740 VSS.t1127 8.70977
R14806 VSS.n3692 VSS.t4122 8.70977
R14807 VSS.n2316 VSS.t1163 8.70977
R14808 VSS.n2547 VSS.t1716 8.70977
R14809 VSS.n2286 VSS.t2225 8.70977
R14810 VSS.n4784 VSS.t2085 8.70977
R14811 VSS.n4825 VSS.t2113 8.70977
R14812 VSS.n5408 VSS.t2141 8.70977
R14813 VSS.n3046 VSS.t2169 8.70977
R14814 VSS.n2243 VSS.t2197 8.70977
R14815 VSS.n5957 VSS.t2970 8.70977
R14816 VSS.n5887 VSS.t4002 8.70977
R14817 VSS.n640 VSS.t2441 8.70977
R14818 VSS.n5678 VSS.t1296 8.70977
R14819 VSS.n5772 VSS.t1553 8.70977
R14820 VSS.n469 VSS.t1813 8.70977
R14821 VSS.n429 VSS.t2057 8.70977
R14822 VSS.n543 VSS.t3270 8.70977
R14823 VSS.n5194 VSS.t2330 8.70977
R14824 VSS.n5146 VSS.t20 8.70977
R14825 VSS.n5079 VSS.t1581 8.70977
R14826 VSS.n4921 VSS.t1840 8.70977
R14827 VSS.n5012 VSS.t1300 8.70977
R14828 VSS.n5268 VSS.t2757 8.70977
R14829 VSS.n5520 VSS.t2875 8.70977
R14830 VSS.n845 VSS.t33 8.70977
R14831 VSS.n5472 VSS.t1607 8.70977
R14832 VSS.n1070 VSS.t1867 8.70977
R14833 VSS.n1002 VSS.t1352 8.70977
R14834 VSS.n935 VSS.t3177 8.70977
R14835 VSS.n1709 VSS.t3415 8.70977
R14836 VSS.n1401 VSS.t61 8.70977
R14837 VSS.n1494 VSS.t1634 8.70977
R14838 VSS.n1642 VSS.t1895 8.70977
R14839 VSS.n1567 VSS.t1380 8.70977
R14840 VSS.n4067 VSS.t2709 8.70977
R14841 VSS.n1273 VSS.t3200 8.70977
R14842 VSS.n2907 VSS.t89 8.70977
R14843 VSS.n2881 VSS.t1662 8.70977
R14844 VSS.n2971 VSS.t1921 8.70977
R14845 VSS.n3125 VSS.t1408 8.70977
R14846 VSS.n3196 VSS.t3322 8.70977
R14847 VSS.n3260 VSS.t4079 8.70977
R14848 VSS.n1449 VSS.t2548 8.70977
R14849 VSS.n893 VSS.t2846 8.70977
R14850 VSS.n4969 VSS.t4297 8.70977
R14851 VSS.n2475 VSS.t1975 8.70977
R14852 VSS.n3361 VSS.t1464 8.70977
R14853 VSS.n2401 VSS.t2651 8.70977
R14854 VSS.n3431 VSS.t4294 8.70977
R14855 VSS.n2180 VSS.t3192 8.70977
R14856 VSS.t136 VSS.n1967 8.66655
R14857 VSS.t2279 VSS.t1119 8.66411
R14858 VSS.t3125 VSS.t1223 8.66411
R14859 VSS.t2263 VSS.t1215 8.66411
R14860 VSS.t2354 VSS.t1207 8.66411
R14861 VSS.t2338 VSS.t1172 8.66411
R14862 VSS.n6236 VSS.n6235 8.58448
R14863 VSS.n2142 VSS.t240 8.58251
R14864 VSS.t2011 VSS.t2004 8.57193
R14865 VSS.t3086 VSS.t4165 8.57193
R14866 VSS.n40 VSS.t1210 8.55322
R14867 VSS.n1975 VSS.n1974 8.55218
R14868 VSS.t1116 VSS.n1220 8.51474
R14869 VSS.t1220 VSS.n750 8.51474
R14870 VSS.t1212 VSS.n676 8.51474
R14871 VSS.t1204 VSS.n507 8.51474
R14872 VSS.t1169 VSS.n1299 8.51474
R14873 VSS.n4010 VSS.n1802 8.50548
R14874 VSS.n4729 VSS.n4243 8.501
R14875 VSS.n4729 VSS.n4244 8.501
R14876 VSS.n2050 VSS.n2033 8.501
R14877 VSS.n2051 VSS.n2050 8.501
R14878 VSS.n2067 VSS.n1996 8.501
R14879 VSS.n2067 VSS.n1995 8.501
R14880 VSS.n2067 VSS.n1994 8.501
R14881 VSS.n2067 VSS.n1993 8.501
R14882 VSS.n2067 VSS.n1992 8.501
R14883 VSS.n4729 VSS.n4712 8.501
R14884 VSS.t2977 VSS.n2038 8.5005
R14885 VSS.t2977 VSS.n2039 8.5005
R14886 VSS.t2977 VSS.n2043 8.5005
R14887 VSS.n2056 VSS.n2055 8.5005
R14888 VSS.n2056 VSS.n2018 8.5005
R14889 VSS.n2056 VSS.n2015 8.5005
R14890 VSS.t2977 VSS.n2037 8.5005
R14891 VSS.t2977 VSS.n2028 8.5005
R14892 VSS.n2045 VSS.n2028 8.5005
R14893 VSS.n2032 VSS.n2028 8.5005
R14894 VSS.n2052 VSS.n2028 8.5005
R14895 VSS.n2056 VSS.n2054 8.5005
R14896 VSS.n2056 VSS.n2028 8.5005
R14897 VSS.n2057 VSS.n2056 8.5005
R14898 VSS.t2940 VSS.n2065 8.5005
R14899 VSS.n63 VSS.n9 8.5005
R14900 VSS.n6233 VSS.n6232 8.5005
R14901 VSS.n4241 VSS.n3 8.5005
R14902 VSS.n2085 VSS.n2084 8.49415
R14903 VSS.n2094 VSS.n2093 8.49103
R14904 VSS.n3590 VSS.n1931 8.48105
R14905 VSS.n3590 VSS.n1950 8.48105
R14906 VSS.n4588 VSS.n22 8.47981
R14907 VSS.n4337 VSS.n21 8.47981
R14908 VSS.n4366 VSS.n20 8.47981
R14909 VSS.n4464 VSS.n19 8.47981
R14910 VSS.n226 VSS.n18 8.47981
R14911 VSS.n240 VSS.n17 8.47981
R14912 VSS.n122 VSS.n16 8.47981
R14913 VSS.n6233 VSS.n25 8.47981
R14914 VSS.n1619 VSS.n1206 8.47981
R14915 VSS.n1532 VSS.n1207 8.47981
R14916 VSS.n1545 VSS.n1208 8.47981
R14917 VSS.n1378 VSS.n1209 8.47981
R14918 VSS.n4044 VSS.n1210 8.47981
R14919 VSS.n1747 VSS.n1211 8.47981
R14920 VSS.n4190 VSS.n1213 8.47981
R14921 VSS.n1108 VSS.n778 8.47981
R14922 VSS.n5622 VSS.n743 8.47981
R14923 VSS.n1040 VSS.n779 8.47981
R14924 VSS.n822 VSS.n775 8.47981
R14925 VSS.n973 VSS.n780 8.47981
R14926 VSS.n5558 VSS.n774 8.47981
R14927 VSS.n5620 VSS.n781 8.47981
R14928 VSS.n4898 VSS.n705 8.47981
R14929 VSS.n5117 VSS.n702 8.47981
R14930 VSS.n5050 VSS.n706 8.47981
R14931 VSS.n5832 VSS.n669 8.47981
R14932 VSS.n5246 VSS.n707 8.47981
R14933 VSS.n5232 VSS.n701 8.47981
R14934 VSS.n5830 VSS.n708 8.47981
R14935 VSS.n5705 VSS.n496 8.47981
R14936 VSS.n5731 VSS.n495 8.47981
R14937 VSS.n5636 VSS.n497 8.47981
R14938 VSS.n599 VSS.n494 8.47981
R14939 VSS.n5846 VSS.n498 8.47981
R14940 VSS.n5916 VSS.n493 8.47981
R14941 VSS.n5990 VSS.n500 8.47981
R14942 VSS.n3497 VSS.n3469 8.47981
R14943 VSS.n3079 VSS.n3007 8.47981
R14944 VSS.n5441 VSS.n1129 8.47981
R14945 VSS.n4872 VSS.n4844 8.47981
R14946 VSS.n5359 VSS.n4877 8.47981
R14947 VSS.n6022 VSS.n389 8.47981
R14948 VSS.n3610 VSS.n1839 8.47981
R14949 VSS.n2452 VSS.n1872 8.47981
R14950 VSS.n2525 VSS.n1874 8.47981
R14951 VSS.n3338 VSS.n1871 8.47981
R14952 VSS.n2354 VSS.n1875 8.47981
R14953 VSS.n2378 VSS.n1870 8.47981
R14954 VSS.n3608 VSS.n1876 8.47981
R14955 VSS.n3625 VSS.n1807 8.47981
R14956 VSS.n3826 VSS.n1809 8.47981
R14957 VSS.n3893 VSS.n1805 8.47981
R14958 VSS.n4029 VSS.n1810 8.47981
R14959 VSS.n3960 VSS.n1804 8.47981
R14960 VSS.n4031 VSS.n1773 8.47981
R14961 VSS.n3539 VSS.n2157 8.47981
R14962 VSS.n2988 VSS.n1328 8.47981
R14963 VSS.n2856 VSS.n1325 8.47981
R14964 VSS.n3142 VSS.n1329 8.47981
R14965 VSS.n2924 VSS.n1324 8.47981
R14966 VSS.n3213 VSS.n1330 8.47981
R14967 VSS.n4166 VSS.n1292 8.47981
R14968 VSS.n4164 VSS.n1331 8.47981
R14969 VSS.t3635 VSS.n4273 8.47111
R14970 VSS.t3635 VSS.n4270 8.47111
R14971 VSS.t3635 VSS.n4278 8.47111
R14972 VSS.t3635 VSS.n4257 8.47111
R14973 VSS.t3635 VSS.n4264 8.47111
R14974 VSS.n6204 VSS.n6203 8.47111
R14975 VSS.n6215 VSS.n6203 8.47111
R14976 VSS.n6194 VSS.n6187 8.47111
R14977 VSS.n6194 VSS.n6191 8.47111
R14978 VSS.n6194 VSS.n149 8.47111
R14979 VSS.n6194 VSS.n148 8.47111
R14980 VSS.n171 VSS.n163 8.47111
R14981 VSS.n4732 VSS.n4220 8.47111
R14982 VSS.n4732 VSS.n4217 8.47111
R14983 VSS.n4705 VSS.n4615 8.47111
R14984 VSS.n4626 VSS.n4623 8.47111
R14985 VSS.t2658 VSS.n3929 8.47111
R14986 VSS.t1449 VSS.n3862 8.47111
R14987 VSS.t1963 VSS.n3655 8.47111
R14988 VSS.t1704 VSS.n3795 8.47111
R14989 VSS.t1148 VSS.n3747 8.47111
R14990 VSS.t3263 VSS.n3699 8.47111
R14991 VSS.n3730 VSS.n3688 8.47111
R14992 VSS.n3730 VSS.n3685 8.47111
R14993 VSS.n3778 VSS.n3736 8.47111
R14994 VSS.n3778 VSS.n3733 8.47111
R14995 VSS.n3845 VSS.n3784 8.47111
R14996 VSS.n3845 VSS.n3781 8.47111
R14997 VSS.n3990 VSS.n3644 8.47111
R14998 VSS.n3990 VSS.n3641 8.47111
R14999 VSS.n3912 VSS.n3851 8.47111
R15000 VSS.n3912 VSS.n3848 8.47111
R15001 VSS.n3986 VSS.n3918 8.47111
R15002 VSS.n3986 VSS.n3915 8.47111
R15003 VSS.t1184 VSS.n2323 8.47111
R15004 VSS.t1730 VSS.n2554 8.47111
R15005 VSS.t3249 VSS.n5951 8.47111
R15006 VSS.t3249 VSS.n5945 8.47111
R15007 VSS.t3249 VSS.n5936 8.47111
R15008 VSS.t3649 VSS.n5881 8.47111
R15009 VSS.t3649 VSS.n5875 8.47111
R15010 VSS.t3649 VSS.n5866 8.47111
R15011 VSS.t2447 VSS.n634 8.47111
R15012 VSS.t2447 VSS.n628 8.47111
R15013 VSS.t2447 VSS.n619 8.47111
R15014 VSS.t1318 VSS.n5672 8.47111
R15015 VSS.t1318 VSS.n5666 8.47111
R15016 VSS.t1318 VSS.n5657 8.47111
R15017 VSS.t1567 VSS.n5766 8.47111
R15018 VSS.t1567 VSS.n5760 8.47111
R15019 VSS.t1567 VSS.n5751 8.47111
R15020 VSS.t1828 VSS.n463 8.47111
R15021 VSS.t1828 VSS.n457 8.47111
R15022 VSS.t1828 VSS.n448 8.47111
R15023 VSS.t2423 VSS.n537 8.47111
R15024 VSS.t2423 VSS.n531 8.47111
R15025 VSS.t2423 VSS.n522 8.47111
R15026 VSS.t2423 VSS.n520 8.47111
R15027 VSS.t2423 VSS.n517 8.47111
R15028 VSS.t3649 VSS.n5864 8.47111
R15029 VSS.t3649 VSS.n5861 8.47111
R15030 VSS.t1318 VSS.n5655 8.47111
R15031 VSS.t1318 VSS.n5652 8.47111
R15032 VSS.t1828 VSS.n446 8.47111
R15033 VSS.t1828 VSS.n443 8.47111
R15034 VSS.t1567 VSS.n5749 8.47111
R15035 VSS.t1567 VSS.n5746 8.47111
R15036 VSS.t2447 VSS.n617 8.47111
R15037 VSS.t2447 VSS.n614 8.47111
R15038 VSS.t3249 VSS.n5934 8.47111
R15039 VSS.t3249 VSS.n5931 8.47111
R15040 VSS.t3353 VSS.n5201 8.47111
R15041 VSS.t3402 VSS.n5153 8.47111
R15042 VSS.t1595 VSS.n5086 8.47111
R15043 VSS.t1855 VSS.n4928 8.47111
R15044 VSS.t1343 VSS.n5019 8.47111
R15045 VSS.t2770 VSS.n5275 8.47111
R15046 VSS.n5304 VSS.n5264 8.47111
R15047 VSS.n5304 VSS.n5261 8.47111
R15048 VSS.n5069 VSS.n5008 8.47111
R15049 VSS.n5069 VSS.n5005 8.47111
R15050 VSS.n5329 VSS.n4917 8.47111
R15051 VSS.n5329 VSS.n4914 8.47111
R15052 VSS.n5136 VSS.n5075 8.47111
R15053 VSS.n5136 VSS.n5072 8.47111
R15054 VSS.n5184 VSS.n5142 8.47111
R15055 VSS.n5184 VSS.n5139 8.47111
R15056 VSS.n5325 VSS.n5190 8.47111
R15057 VSS.n5325 VSS.n5187 8.47111
R15058 VSS.t3645 VSS.n5527 8.47111
R15059 VSS.t46 VSS.n852 8.47111
R15060 VSS.t1622 VSS.n5479 8.47111
R15061 VSS.t1881 VSS.n1077 8.47111
R15062 VSS.t1367 VSS.n1009 8.47111
R15063 VSS.t3457 VSS.n942 8.47111
R15064 VSS.n992 VSS.n931 8.47111
R15065 VSS.n992 VSS.n928 8.47111
R15066 VSS.n1060 VSS.n998 8.47111
R15067 VSS.n1060 VSS.n995 8.47111
R15068 VSS.n5462 VSS.n1066 8.47111
R15069 VSS.n5462 VSS.n1063 8.47111
R15070 VSS.n5510 VSS.n5468 8.47111
R15071 VSS.n5510 VSS.n5465 8.47111
R15072 VSS.n5588 VSS.n841 8.47111
R15073 VSS.n5588 VSS.n838 8.47111
R15074 VSS.n5584 VSS.n5516 8.47111
R15075 VSS.n5584 VSS.n5513 8.47111
R15076 VSS.t2295 VSS.n1716 8.47111
R15077 VSS.t74 VSS.n1408 8.47111
R15078 VSS.t1648 VSS.n1501 8.47111
R15079 VSS.t1909 VSS.n1649 8.47111
R15080 VSS.t1395 VSS.n1574 8.47111
R15081 VSS.t2945 VSS.n4074 8.47111
R15082 VSS.n4103 VSS.n4063 8.47111
R15083 VSS.n4103 VSS.n4060 8.47111
R15084 VSS.n1603 VSS.n1563 8.47111
R15085 VSS.n1603 VSS.n1560 8.47111
R15086 VSS.n1678 VSS.n1638 8.47111
R15087 VSS.n1678 VSS.n1635 8.47111
R15088 VSS.n1699 VSS.n1490 8.47111
R15089 VSS.n1699 VSS.n1487 8.47111
R15090 VSS.n4127 VSS.n1397 8.47111
R15091 VSS.n4127 VSS.n1394 8.47111
R15092 VSS.n4123 VSS.n1705 8.47111
R15093 VSS.n4123 VSS.n1702 8.47111
R15094 VSS.t3279 VSS.n4170 8.47111
R15095 VSS.t3279 VSS.n1287 8.47111
R15096 VSS.t3279 VSS.n4175 8.47111
R15097 VSS.t1104 VSS.n2943 8.47111
R15098 VSS.t1104 VSS.n2921 8.47111
R15099 VSS.t1104 VSS.n2948 8.47111
R15100 VSS.t1676 VSS.n3296 8.47111
R15101 VSS.t1676 VSS.n2895 8.47111
R15102 VSS.t1676 VSS.n3301 8.47111
R15103 VSS.t1936 VSS.n3097 8.47111
R15104 VSS.t1936 VSS.n2985 8.47111
R15105 VSS.t1936 VSS.n3102 8.47111
R15106 VSS.t1421 VSS.n3168 8.47111
R15107 VSS.t1421 VSS.n3139 8.47111
R15108 VSS.t1421 VSS.n3173 8.47111
R15109 VSS.t3653 VSS.n3232 8.47111
R15110 VSS.t3653 VSS.n3210 8.47111
R15111 VSS.t3653 VSS.n3237 8.47111
R15112 VSS.t2555 VSS.n3277 8.47111
R15113 VSS.t2555 VSS.n3274 8.47111
R15114 VSS.t2555 VSS.n3282 8.47111
R15115 VSS.t2555 VSS.n3261 8.47111
R15116 VSS.t2555 VSS.n3268 8.47111
R15117 VSS.t3653 VSS.n3197 8.47111
R15118 VSS.t3653 VSS.n3204 8.47111
R15119 VSS.t1421 VSS.n3126 8.47111
R15120 VSS.t1421 VSS.n3133 8.47111
R15121 VSS.t1936 VSS.n2972 8.47111
R15122 VSS.t1936 VSS.n2979 8.47111
R15123 VSS.t1676 VSS.n2882 8.47111
R15124 VSS.t1676 VSS.n2889 8.47111
R15125 VSS.t1104 VSS.n2908 8.47111
R15126 VSS.t1104 VSS.n2915 8.47111
R15127 VSS.t3279 VSS.n1274 8.47111
R15128 VSS.t3279 VSS.n1281 8.47111
R15129 VSS.t2958 VSS.n1466 8.47111
R15130 VSS.t2958 VSS.n1463 8.47111
R15131 VSS.t2958 VSS.n1471 8.47111
R15132 VSS.t2958 VSS.n1450 8.47111
R15133 VSS.t2958 VSS.n1457 8.47111
R15134 VSS.t2945 VSS.n4068 8.47111
R15135 VSS.t2945 VSS.n4072 8.47111
R15136 VSS.t1395 VSS.n1568 8.47111
R15137 VSS.t1395 VSS.n1572 8.47111
R15138 VSS.t1909 VSS.n1643 8.47111
R15139 VSS.t1909 VSS.n1647 8.47111
R15140 VSS.t1648 VSS.n1495 8.47111
R15141 VSS.t1648 VSS.n1499 8.47111
R15142 VSS.t74 VSS.n1402 8.47111
R15143 VSS.t74 VSS.n1406 8.47111
R15144 VSS.t2295 VSS.n1710 8.47111
R15145 VSS.t2295 VSS.n1714 8.47111
R15146 VSS.t3118 VSS.n910 8.47111
R15147 VSS.t3118 VSS.n907 8.47111
R15148 VSS.t3118 VSS.n915 8.47111
R15149 VSS.t3118 VSS.n894 8.47111
R15150 VSS.t3118 VSS.n901 8.47111
R15151 VSS.t3457 VSS.n936 8.47111
R15152 VSS.t3457 VSS.n940 8.47111
R15153 VSS.t1367 VSS.n1003 8.47111
R15154 VSS.t1367 VSS.n1007 8.47111
R15155 VSS.t1881 VSS.n1071 8.47111
R15156 VSS.t1881 VSS.n1075 8.47111
R15157 VSS.t1622 VSS.n5473 8.47111
R15158 VSS.t1622 VSS.n5477 8.47111
R15159 VSS.t46 VSS.n846 8.47111
R15160 VSS.t46 VSS.n850 8.47111
R15161 VSS.t3645 VSS.n5521 8.47111
R15162 VSS.t3645 VSS.n5525 8.47111
R15163 VSS.t2612 VSS.n4986 8.47111
R15164 VSS.t2612 VSS.n4983 8.47111
R15165 VSS.t2612 VSS.n4991 8.47111
R15166 VSS.t2612 VSS.n4970 8.47111
R15167 VSS.t2612 VSS.n4977 8.47111
R15168 VSS.t2770 VSS.n5269 8.47111
R15169 VSS.t2770 VSS.n5273 8.47111
R15170 VSS.t1343 VSS.n5013 8.47111
R15171 VSS.t1343 VSS.n5017 8.47111
R15172 VSS.t1855 VSS.n4922 8.47111
R15173 VSS.t1855 VSS.n4926 8.47111
R15174 VSS.t1595 VSS.n5080 8.47111
R15175 VSS.t1595 VSS.n5084 8.47111
R15176 VSS.t3402 VSS.n5147 8.47111
R15177 VSS.t3402 VSS.n5151 8.47111
R15178 VSS.t3353 VSS.n5195 8.47111
R15179 VSS.t3353 VSS.n5199 8.47111
R15180 VSS.t2238 VSS.n2277 8.47111
R15181 VSS.t2238 VSS.n2271 8.47111
R15182 VSS.t2238 VSS.n2262 8.47111
R15183 VSS.t2210 VSS.n2238 8.47111
R15184 VSS.t2210 VSS.n2235 8.47111
R15185 VSS.t2210 VSS.n2228 8.47111
R15186 VSS.t2210 VSS.n2226 8.47111
R15187 VSS.t2210 VSS.n2223 8.47111
R15188 VSS.t2182 VSS.n3038 8.47111
R15189 VSS.t2182 VSS.n3032 8.47111
R15190 VSS.t2182 VSS.n3023 8.47111
R15191 VSS.t2182 VSS.n3021 8.47111
R15192 VSS.t2182 VSS.n3018 8.47111
R15193 VSS.t2154 VSS.n1160 8.47111
R15194 VSS.t2154 VSS.n1154 8.47111
R15195 VSS.t2154 VSS.n1145 8.47111
R15196 VSS.t2154 VSS.n1143 8.47111
R15197 VSS.t2154 VSS.n1140 8.47111
R15198 VSS.t2126 VSS.n4818 8.47111
R15199 VSS.t2126 VSS.n4812 8.47111
R15200 VSS.t2126 VSS.n4803 8.47111
R15201 VSS.t2126 VSS.n4801 8.47111
R15202 VSS.t2126 VSS.n4798 8.47111
R15203 VSS.t2098 VSS.n4779 8.47111
R15204 VSS.t2098 VSS.n4776 8.47111
R15205 VSS.t2098 VSS.n4769 8.47111
R15206 VSS.t2098 VSS.n4767 8.47111
R15207 VSS.t2098 VSS.n4764 8.47111
R15208 VSS.t2070 VSS.n422 8.47111
R15209 VSS.t2070 VSS.n416 8.47111
R15210 VSS.t2070 VSS.n406 8.47111
R15211 VSS.t2070 VSS.n404 8.47111
R15212 VSS.t2070 VSS.n401 8.47111
R15213 VSS.t1994 VSS.n2482 8.47111
R15214 VSS.t1479 VSS.n3368 8.47111
R15215 VSS.t2256 VSS.n2408 8.47111
R15216 VSS.n2437 VSS.n2397 8.47111
R15217 VSS.n2437 VSS.n2394 8.47111
R15218 VSS.n3397 VSS.n3357 8.47111
R15219 VSS.n3397 VSS.n3354 8.47111
R15220 VSS.n2511 VSS.n2471 8.47111
R15221 VSS.n2511 VSS.n2468 8.47111
R15222 VSS.t2238 VSS.n2260 8.47111
R15223 VSS.t2238 VSS.n2257 8.47111
R15224 VSS.n2583 VSS.n2543 8.47111
R15225 VSS.n2583 VSS.n2540 8.47111
R15226 VSS.n3417 VSS.n2312 8.47111
R15227 VSS.n3417 VSS.n2309 8.47111
R15228 VSS.t2940 VSS.n2012 8.47111
R15229 VSS.n2006 VSS.n1998 8.47111
R15230 VSS.n2005 VSS.n1999 8.47111
R15231 VSS.n2004 VSS.n2000 8.47111
R15232 VSS.n2003 VSS.n2001 8.47111
R15233 VSS.n3572 VSS.n1989 8.47111
R15234 VSS.n3572 VSS.n1987 8.47111
R15235 VSS.n3572 VSS.n1984 8.47111
R15236 VSS.n2104 VSS.n2103 8.47111
R15237 VSS.n2078 VSS.n2071 8.47111
R15238 VSS.t3237 VSS.n3448 8.47111
R15239 VSS.t3237 VSS.n3445 8.47111
R15240 VSS.t3237 VSS.n3453 8.47111
R15241 VSS.t3237 VSS.n3432 8.47111
R15242 VSS.t3237 VSS.n3439 8.47111
R15243 VSS.t1184 VSS.n2317 8.47111
R15244 VSS.t1184 VSS.n2321 8.47111
R15245 VSS.t1730 VSS.n2548 8.47111
R15246 VSS.t1730 VSS.n2552 8.47111
R15247 VSS.t1994 VSS.n2476 8.47111
R15248 VSS.t1994 VSS.n2480 8.47111
R15249 VSS.t1479 VSS.n3362 8.47111
R15250 VSS.t1479 VSS.n3366 8.47111
R15251 VSS.t2256 VSS.n2402 8.47111
R15252 VSS.t2256 VSS.n2406 8.47111
R15253 VSS.t2627 VSS.n2197 8.47111
R15254 VSS.t2627 VSS.n2194 8.47111
R15255 VSS.t2627 VSS.n2202 8.47111
R15256 VSS.t2627 VSS.n2181 8.47111
R15257 VSS.t2627 VSS.n2188 8.47111
R15258 VSS.t2658 VSS.n3923 8.47111
R15259 VSS.t2658 VSS.n3927 8.47111
R15260 VSS.t1449 VSS.n3856 8.47111
R15261 VSS.t1449 VSS.n3860 8.47111
R15262 VSS.t1963 VSS.n3649 8.47111
R15263 VSS.t1963 VSS.n3653 8.47111
R15264 VSS.t1704 VSS.n3789 8.47111
R15265 VSS.t1704 VSS.n3793 8.47111
R15266 VSS.t1148 VSS.n3741 8.47111
R15267 VSS.t1148 VSS.n3745 8.47111
R15268 VSS.t3263 VSS.n3693 8.47111
R15269 VSS.t3263 VSS.n3697 8.47111
R15270 VSS.t2042 VSS.n111 8.47111
R15271 VSS.t2042 VSS.n108 8.47111
R15272 VSS.t2042 VSS.n105 8.47111
R15273 VSS.t2042 VSS.n103 8.47111
R15274 VSS.t2042 VSS.n101 8.47111
R15275 VSS.t1798 VSS.n276 8.47111
R15276 VSS.t1798 VSS.n270 8.47111
R15277 VSS.t1798 VSS.n260 8.47111
R15278 VSS.t1798 VSS.n258 8.47111
R15279 VSS.t1798 VSS.n255 8.47111
R15280 VSS.t1538 VSS.n200 8.47111
R15281 VSS.t1538 VSS.n194 8.47111
R15282 VSS.t1538 VSS.n184 8.47111
R15283 VSS.t1538 VSS.n182 8.47111
R15284 VSS.t1538 VSS.n179 8.47111
R15285 VSS.t1280 VSS.n4439 8.47111
R15286 VSS.t1280 VSS.n4433 8.47111
R15287 VSS.t1280 VSS.n4426 8.47111
R15288 VSS.t1280 VSS.n4424 8.47111
R15289 VSS.t1280 VSS.n4421 8.47111
R15290 VSS.t3387 VSS.n4403 8.47111
R15291 VSS.t3387 VSS.n4397 8.47111
R15292 VSS.t3387 VSS.n4387 8.47111
R15293 VSS.t3387 VSS.n4385 8.47111
R15294 VSS.t3387 VSS.n4382 8.47111
R15295 VSS.t2858 VSS.n4312 8.47111
R15296 VSS.t2858 VSS.n4306 8.47111
R15297 VSS.t2858 VSS.n4299 8.47111
R15298 VSS.t2858 VSS.n4297 8.47111
R15299 VSS.t2858 VSS.n4294 8.47111
R15300 VSS.t2981 VSS.n4563 8.47111
R15301 VSS.t2981 VSS.n4557 8.47111
R15302 VSS.t2981 VSS.n4550 8.47111
R15303 VSS.t2981 VSS.n4548 8.47111
R15304 VSS.t2981 VSS.n4545 8.47111
R15305 VSS.n4721 VSS.n4713 8.47111
R15306 VSS.n4716 VSS.n4715 8.47111
R15307 VSS.n4727 VSS.n4726 8.47111
R15308 VSS.n3592 VSS.n1922 8.45091
R15309 VSS.n4587 VSS.t384 8.44127
R15310 VSS.n4586 VSS.t372 8.44127
R15311 VSS.n4336 VSS.t430 8.44127
R15312 VSS.n4335 VSS.t428 8.44127
R15313 VSS.n4365 VSS.t445 8.44127
R15314 VSS.n4379 VSS.t443 8.44127
R15315 VSS.n4463 VSS.t707 8.44127
R15316 VSS.n4462 VSS.t648 8.44127
R15317 VSS.n225 VSS.t805 8.44127
R15318 VSS.n224 VSS.t803 8.44127
R15319 VSS.n239 VSS.t875 8.44127
R15320 VSS.n252 VSS.t873 8.44127
R15321 VSS.n121 VSS.t1036 8.44127
R15322 VSS.n120 VSS.t892 8.44127
R15323 VSS.t117 VSS.n32 8.44127
R15324 VSS.n58 VSS.t114 8.44127
R15325 VSS.n3959 VSS.t572 8.44127
R15326 VSS.n3958 VSS.t436 8.44127
R15327 VSS.n3892 VSS.t746 8.44127
R15328 VSS.n3891 VSS.t744 8.44127
R15329 VSS.n3624 VSS.t980 8.44127
R15330 VSS.n3638 VSS.t978 8.44127
R15331 VSS.n3825 VSS.t859 8.44127
R15332 VSS.n3824 VSS.t836 8.44127
R15333 VSS.t131 VSS.n4025 8.44127
R15334 VSS.n1815 VSS.t637 8.44127
R15335 VSS.t485 VSS.n1798 8.44127
R15336 VSS.n1770 VSS.t417 8.44127
R15337 VSS.n2353 VSS.t673 8.44127
R15338 VSS.n2352 VSS.t644 8.44127
R15339 VSS.n2524 VSS.t658 8.44127
R15340 VSS.n2537 VSS.t862 8.44127
R15341 VSS.t1095 VSS.n1864 8.44127
R15342 VSS.n1836 VSS.t1091 8.44127
R15343 VSS.t1054 VSS.n5354 8.44127
R15344 VSS.n4887 VSS.t1051 8.44127
R15345 VSS.t1062 VSS.n4867 8.44127
R15346 VSS.n4854 VSS.t896 8.44127
R15347 VSS.t903 VSS.n5436 8.44127
R15348 VSS.n1126 VSS.t900 8.44127
R15349 VSS.t1072 VSS.n3074 8.44127
R15350 VSS.n3004 VSS.t907 8.44127
R15351 VSS.t1079 VSS.n3492 8.44127
R15352 VSS.n3479 VSS.t1076 8.44127
R15353 VSS.n5915 VSS.t386 8.44127
R15354 VSS.n5928 VSS.t294 8.44127
R15355 VSS.n5845 VSS.t532 8.44127
R15356 VSS.n5858 VSS.t433 8.44127
R15357 VSS.n598 VSS.t626 8.44127
R15358 VSS.n611 VSS.t622 8.44127
R15359 VSS.n5635 VSS.t653 8.44127
R15360 VSS.n5649 VSS.t651 8.44127
R15361 VSS.n5730 VSS.t814 8.44127
R15362 VSS.n5743 VSS.t808 8.44127
R15363 VSS.n5704 VSS.t954 8.44127
R15364 VSS.n5717 VSS.t950 8.44127
R15365 VSS.t1043 VSS.n6017 8.44127
R15366 VSS.n386 VSS.t1040 8.44127
R15367 VSS.t258 VSS.n573 8.44127
R15368 VSS.n513 VSS.t256 8.44127
R15369 VSS.n5231 VSS.t299 8.44127
R15370 VSS.n5230 VSS.t297 8.44127
R15371 VSS.t628 VSS.n695 8.44127
R15372 VSS.n666 VSS.t448 8.44127
R15373 VSS.n5116 VSS.t823 8.44127
R15374 VSS.n5115 VSS.t817 8.44127
R15375 VSS.n4897 VSS.t963 8.44127
R15376 VSS.n4911 VSS.t957 8.44127
R15377 VSS.n5049 VSS.t720 8.44127
R15378 VSS.n5048 VSS.t718 8.44127
R15379 VSS.n5245 VSS.t537 8.44127
R15380 VSS.n5258 VSS.t535 8.44127
R15381 VSS.n5557 VSS.t395 8.44127
R15382 VSS.n5556 VSS.t393 8.44127
R15383 VSS.n821 VSS.t453 8.44127
R15384 VSS.n835 VSS.t451 8.44127
R15385 VSS.t842 VSS.n768 8.44127
R15386 VSS.n740 VSS.t826 8.44127
R15387 VSS.n1107 VSS.t880 8.44127
R15388 VSS.n1106 VSS.t878 8.44127
R15389 VSS.n1039 VSS.t731 8.44127
R15390 VSS.n1038 VSS.t723 8.44127
R15391 VSS.n972 VSS.t550 8.44127
R15392 VSS.n971 VSS.t546 8.44127
R15393 VSS.n1746 VSS.t404 8.44127
R15394 VSS.n1745 VSS.t398 8.44127
R15395 VSS.n1377 VSS.t458 8.44127
R15396 VSS.n1391 VSS.t456 8.44127
R15397 VSS.n1531 VSS.t828 8.44127
R15398 VSS.n1530 VSS.t849 8.44127
R15399 VSS.n1618 VSS.t885 8.44127
R15400 VSS.n1632 VSS.t883 8.44127
R15401 VSS.n1544 VSS.t725 8.44127
R15402 VSS.n1557 VSS.t734 8.44127
R15403 VSS.n4043 VSS.t561 8.44127
R15404 VSS.n4057 VSS.t553 8.44127
R15405 VSS.t413 VSS.n1318 8.44127
R15406 VSS.n1289 VSS.t407 8.44127
R15407 VSS.n2923 VSS.t634 8.44127
R15408 VSS.n2922 VSS.t461 8.44127
R15409 VSS.n2855 VSS.t833 8.44127
R15410 VSS.n2868 VSS.t831 8.44127
R15411 VSS.n2987 VSS.t975 8.44127
R15412 VSS.n2986 VSS.t888 8.44127
R15413 VSS.n3141 VSS.t752 8.44127
R15414 VSS.n3140 VSS.t741 8.44127
R15415 VSS.n3212 VSS.t555 8.44127
R15416 VSS.n3211 VSS.t568 8.44127
R15417 VSS.t317 VSS.n4160 8.44127
R15418 VSS.n1336 VSS.t288 8.44127
R15419 VSS.t284 VSS.n1249 8.44127
R15420 VSS.n1226 VSS.t282 8.44127
R15421 VSS.t128 VSS.n5616 8.44127
R15422 VSS.n786 VSS.t125 8.44127
R15423 VSS.t263 VSS.n5826 8.44127
R15424 VSS.n713 VSS.t121 8.44127
R15425 VSS.n2451 VSS.t996 8.44127
R15426 VSS.n2465 VSS.t994 8.44127
R15427 VSS.n3337 VSS.t763 8.44127
R15428 VSS.n3351 VSS.t656 8.44127
R15429 VSS.n2377 VSS.t581 8.44127
R15430 VSS.n2391 VSS.t439 8.44127
R15431 VSS.t424 VSS.n3604 8.44127
R15432 VSS.n1882 VSS.t421 8.44127
R15433 VSS.t291 VSS.n3534 8.44127
R15434 VSS.n2165 VSS.t321 8.44127
R15435 VSS.n1968 VSS.t3074 8.35705
R15436 VSS.n2284 VSS.t1087 8.30575
R15437 VSS.n2242 VSS.t2807 8.30575
R15438 VSS.n3044 VSS.t3061 8.30575
R15439 VSS.n5406 VSS.t4163 8.30575
R15440 VSS.n4823 VSS.t3474 8.30575
R15441 VSS.n4783 VSS.t3513 8.30575
R15442 VSS.n427 VSS.t2803 8.30575
R15443 VSS.n3538 VSS.n2148 8.24596
R15444 VSS.t2595 VSS.n1951 8.23845
R15445 VSS.n1237 VSS.n1235 8.216
R15446 VSS.n1230 VSS.n1229 8.216
R15447 VSS.n795 VSS.n758 8.216
R15448 VSS.n796 VSS.n757 8.216
R15449 VSS.n721 VSS.n685 8.216
R15450 VSS.n722 VSS.n682 8.216
R15451 VSS.n593 VSS.n562 8.216
R15452 VSS.n5991 VSS.n492 8.216
R15453 VSS.n1344 VSS.n1308 8.216
R15454 VSS.n1345 VSS.n1305 8.216
R15455 VSS.n1808 VSS.n1772 8.15833
R15456 VSS.n1821 VSS.n1802 8.15833
R15457 VSS.n3558 VSS.n3557 8.11479
R15458 VSS.n3541 VSS.n3540 7.90941
R15459 VSS.n3538 VSS.n2132 7.90941
R15460 VSS.n3514 VSS.t2570 7.78597
R15461 VSS.n1191 VSS.t3459 7.78597
R15462 VSS.n5393 VSS.t2566 7.78597
R15463 VSS.n5381 VSS.t2876 7.78597
R15464 VSS.n4756 VSS.t4127 7.78597
R15465 VSS.t4123 VSS.n4238 7.78597
R15466 VSS.t342 VSS.n30 7.70851
R15467 VSS.t514 VSS.t2404 7.63762
R15468 VSS.n1239 VSS.t357 7.6185
R15469 VSS.n759 VSS.t354 7.6185
R15470 VSS.n686 VSS.t336 7.6185
R15471 VSS.n564 VSS.t348 7.6185
R15472 VSS.n1309 VSS.t330 7.6185
R15473 VSS.t3601 VSS.n3477 7.61124
R15474 VSS.t4100 VSS.n3015 7.61124
R15475 VSS.t3494 VSS.n1137 7.61124
R15476 VSS.t3127 VSS.n4852 7.61124
R15477 VSS.t2634 VSS.n4885 7.61124
R15478 VSS.t3063 VSS.n398 7.61124
R15479 VSS.t3991 VSS.n2265 7.58355
R15480 VSS.t3987 VSS.n2275 7.58355
R15481 VSS.t3985 VSS.n2231 7.58355
R15482 VSS.t3981 VSS.n3505 7.58355
R15483 VSS.t3979 VSS.n3026 7.58355
R15484 VSS.t3975 VSS.n3036 7.58355
R15485 VSS.t3973 VSS.n1148 7.58355
R15486 VSS.t3969 VSS.n1158 7.58355
R15487 VSS.t3967 VSS.n4806 7.58355
R15488 VSS.t3963 VSS.n4816 7.58355
R15489 VSS.t3961 VSS.n4772 7.58355
R15490 VSS.t3957 VSS.n5367 7.58355
R15491 VSS.t3955 VSS.n409 7.58355
R15492 VSS.t3951 VSS.n420 7.58355
R15493 VSS.n1791 VSS.t2406 7.46405
R15494 VSS.t240 VSS.t3155 7.40458
R15495 VSS.t2904 VSS.t1211 7.39174
R15496 VSS.t4119 VSS.n3519 7.38671
R15497 VSS.n4192 VSS.t2887 7.38671
R15498 VSS.n5403 VSS.t3466 7.38671
R15499 VSS.t2883 VSS.n5386 7.38671
R15500 VSS.t2562 VSS.n5374 7.38671
R15501 VSS.n1255 VSS.n1254 7.31976
R15502 VSS.n5602 VSS.n772 7.31976
R15503 VSS.n5811 VSS.n699 7.31976
R15504 VSS.n5986 VSS.n577 7.31976
R15505 VSS.n4145 VSS.n1322 7.31976
R15506 VSS.n44 VSS.t1208 7.28615
R15507 VSS.n2144 VSS.t3157 7.23631
R15508 VSS.n1821 VSS.t130 7.11691
R15509 VSS.n1825 VSS.n1788 7.11691
R15510 VSS.n1824 VSS.n1785 7.11691
R15511 VSS.n1916 VSS.n1843 7.11474
R15512 VSS.n3610 VSS.n1849 7.09656
R15513 VSS.t2594 VSS.t4066 7.08154
R15514 VSS.t2593 VSS.t4063 7.08154
R15515 VSS.n4188 VSS.n1212 7.02101
R15516 VSS.n1255 VSS.n1253 7.02101
R15517 VSS.n776 VSS.n742 7.02101
R15518 VSS.n793 VSS.n772 7.02101
R15519 VSS.n703 VSS.n668 7.02101
R15520 VSS.n719 VSS.n699 7.02101
R15521 VSS.n5988 VSS.n499 7.02101
R15522 VSS.n591 VSS.n577 7.02101
R15523 VSS.n1326 VSS.n1291 7.02101
R15524 VSS.n1342 VSS.n1322 7.02101
R15525 VSS.n3594 VSS.t199 7.01861
R15526 VSS.n50 VSS.n22 6.98315
R15527 VSS.t290 VSS.n2132 6.89976
R15528 VSS.n3530 VSS.n2141 6.89976
R15529 VSS.n2163 VSS.n2140 6.89976
R15530 VSS.n3609 VSS.n1869 6.82633
R15531 VSS.n1790 VSS.t1164 6.76977
R15532 VSS.t2573 VSS.n3521 6.72791
R15533 VSS.n3521 VSS.t2572 6.72791
R15534 VSS.t3462 VSS.n4194 6.72791
R15535 VSS.n4194 VSS.t3461 6.72791
R15536 VSS.t2569 VSS.n5395 6.72791
R15537 VSS.n5395 VSS.t2568 6.72791
R15538 VSS.t2879 VSS.n5388 6.72791
R15539 VSS.n5388 VSS.t2878 6.72791
R15540 VSS.t4130 VSS.n5376 6.72791
R15541 VSS.n5376 VSS.t4129 6.72791
R15542 VSS.n45 VSS.t1197 6.65262
R15543 VSS.t1228 VSS.n1845 6.63405
R15544 VSS.n1825 VSS.t415 6.5962
R15545 VSS.n3515 VSS.t2571 6.5882
R15546 VSS.t3460 VSS.n1188 6.5882
R15547 VSS.t2567 VSS.n1168 6.5882
R15548 VSS.n5382 VSS.t2877 6.5882
R15549 VSS.n4757 VSS.t4128 6.5882
R15550 VSS.t4124 VSS.n4237 6.5882
R15551 VSS.t357 VSS.t2274 6.5729
R15552 VSS.t354 VSS.t3120 6.5729
R15553 VSS.t336 VSS.t2258 6.5729
R15554 VSS.t348 VSS.t2349 6.5729
R15555 VSS.t330 VSS.t2333 6.5729
R15556 VSS.n2143 VSS.t2888 6.56321
R15557 VSS.n1238 VSS.n1206 6.5018
R15558 VSS.n778 VSS.n777 6.5018
R15559 VSS.n705 VSS.n704 6.5018
R15560 VSS.n563 VSS.n496 6.5018
R15561 VSS.n1328 VSS.n1327 6.5018
R15562 VSS.n1969 VSS.t3075 6.50004
R15563 VSS.n1241 VSS.t2276 6.42352
R15564 VSS.n761 VSS.t3122 6.42352
R15565 VSS.n688 VSS.t2260 6.42352
R15566 VSS.n566 VSS.t2351 6.42352
R15567 VSS.n1311 VSS.t2335 6.42352
R15568 VSS.n2281 VSS.t1131 6.42262
R15569 VSS.t319 VSS.n2141 6.39494
R15570 VSS.n3539 VSS.n2162 6.31391
R15571 VSS.n1807 VSS.n1806 6.26319
R15572 VSS.n2281 VSS.t2862 6.22666
R15573 VSS.t1763 VSS.n2278 6.13916
R15574 VSS.n3500 VSS.t1760 6.13916
R15575 VSS.t1768 VSS.n3039 6.13916
R15576 VSS.t1770 VSS.n1161 6.13916
R15577 VSS.t1772 VSS.n4819 6.13916
R15578 VSS.n5362 VSS.t1754 6.13916
R15579 VSS.n5998 VSS.t2063 6.13916
R15580 VSS.t1774 VSS.n423 6.13916
R15581 VSS.n1253 VSS.t278 6.12478
R15582 VSS.n1237 VSS.n1236 6.12478
R15583 VSS.n1229 VSS.n1224 6.12478
R15584 VSS.n793 VSS.t127 6.12478
R15585 VSS.n797 VSS.n758 6.12478
R15586 VSS.n796 VSS.n755 6.12478
R15587 VSS.n719 VSS.t147 6.12478
R15588 VSS.n723 VSS.n685 6.12478
R15589 VSS.n722 VSS.n680 6.12478
R15590 VSS.n591 VSS.t246 6.12478
R15591 VSS.n594 VSS.n562 6.12478
R15592 VSS.n511 VSS.n492 6.12478
R15593 VSS.n1342 VSS.t301 6.12478
R15594 VSS.n1346 VSS.n1308 6.12478
R15595 VSS.n1345 VSS.n1303 6.12478
R15596 VSS.t2906 VSS.t1199 6.12467
R15597 VSS.n4030 VSS.n1808 6.07548
R15598 VSS.n1796 VSS.t2409 6.07548
R15599 VSS.n1856 VSS.t91 6.05722
R15600 VSS.n46 VSS.t1196 6.01908
R15601 VSS.n1244 VSS.n1205 5.97951
R15602 VSS.n807 VSS.n806 5.97951
R15603 VSS.n733 VSS.n732 5.97951
R15604 VSS.n588 VSS.n582 5.97951
R15605 VSS.n1351 VSS.n1350 5.97951
R15606 VSS.t2410 VSS.n1774 5.90191
R15607 VSS.t4065 VSS.n1927 5.90137
R15608 VSS.n3541 VSS.n2149 5.89011
R15609 VSS.n2147 VSS.t3160 5.89011
R15610 VSS.n6238 VSS.n3 5.83103
R15611 VSS.n1240 VSS.t1116 5.82603
R15612 VSS.n760 VSS.t1220 5.82603
R15613 VSS.n687 VSS.t1212 5.82603
R15614 VSS.n565 VSS.t1204 5.82603
R15615 VSS.n1310 VSS.t1169 5.82603
R15616 VSS.n55 VSS.n54 5.80791
R15617 VSS.n4714 VSS.n4710 5.7829
R15618 VSS.n2156 VSS.n2150 5.76321
R15619 VSS.n2281 VSS.t2407 5.72834
R15620 VSS.n2158 VSS.t3161 5.72184
R15621 VSS.n1829 VSS.n1828 5.70538
R15622 VSS.n1236 VSS.t275 5.67666
R15623 VSS.n797 VSS.t123 5.67666
R15624 VSS.n723 VSS.t119 5.67666
R15625 VSS.n594 VSS.t249 5.67666
R15626 VSS.n1346 VSS.t286 5.67666
R15627 VSS.n2050 VSS.n2034 5.66778
R15628 VSS.n2050 VSS.n2029 5.66778
R15629 VSS.n4729 VSS.n4711 5.66778
R15630 VSS.n4729 VSS.n4728 5.66767
R15631 VSS.n4708 VSS.n4619 5.66514
R15632 VSS.n2062 VSS.n2061 5.64202
R15633 VSS.n4734 VSS.n4732 5.63434
R15634 VSS.n171 VSS.n152 5.63343
R15635 VSS.n3590 VSS.n1928 5.6324
R15636 VSS.t3635 VSS.n4253 5.62393
R15637 VSS.n4732 VSS.n4224 5.62393
R15638 VSS.t3249 VSS.n5954 5.62393
R15639 VSS.t3649 VSS.n5884 5.62393
R15640 VSS.t2447 VSS.n637 5.62393
R15641 VSS.t1318 VSS.n5675 5.62393
R15642 VSS.t1567 VSS.n5769 5.62393
R15643 VSS.t1828 VSS.n466 5.62393
R15644 VSS.t2423 VSS.n540 5.62393
R15645 VSS.t2555 VSS.n3257 5.62393
R15646 VSS.t3653 VSS.n3193 5.62393
R15647 VSS.t1421 VSS.n3122 5.62393
R15648 VSS.t1936 VSS.n2968 5.62393
R15649 VSS.t1676 VSS.n2878 5.62393
R15650 VSS.t1104 VSS.n2904 5.62393
R15651 VSS.t3279 VSS.n1270 5.62393
R15652 VSS.t2958 VSS.n1446 5.62393
R15653 VSS.t2945 VSS.n4065 5.62393
R15654 VSS.t1395 VSS.n1565 5.62393
R15655 VSS.t1909 VSS.n1640 5.62393
R15656 VSS.t1648 VSS.n1492 5.62393
R15657 VSS.t74 VSS.n1399 5.62393
R15658 VSS.t2295 VSS.n1707 5.62393
R15659 VSS.t3118 VSS.n890 5.62393
R15660 VSS.t3457 VSS.n933 5.62393
R15661 VSS.t1367 VSS.n1000 5.62393
R15662 VSS.t1881 VSS.n1068 5.62393
R15663 VSS.t1622 VSS.n5470 5.62393
R15664 VSS.t46 VSS.n843 5.62393
R15665 VSS.t3645 VSS.n5518 5.62393
R15666 VSS.t2612 VSS.n4966 5.62393
R15667 VSS.t2770 VSS.n5266 5.62393
R15668 VSS.t1343 VSS.n5010 5.62393
R15669 VSS.t1855 VSS.n4919 5.62393
R15670 VSS.t1595 VSS.n5077 5.62393
R15671 VSS.t3402 VSS.n5144 5.62393
R15672 VSS.t3353 VSS.n5192 5.62393
R15673 VSS.t2238 VSS.n2280 5.62393
R15674 VSS.t2210 VSS.n2240 5.62393
R15675 VSS.t2182 VSS.n3041 5.62393
R15676 VSS.t2154 VSS.n1163 5.62393
R15677 VSS.t2126 VSS.n4821 5.62393
R15678 VSS.t2098 VSS.n4781 5.62393
R15679 VSS.t2070 VSS.n425 5.62393
R15680 VSS.t3237 VSS.n3428 5.62393
R15681 VSS.t1184 VSS.n2314 5.62393
R15682 VSS.t1730 VSS.n2545 5.62393
R15683 VSS.t1994 VSS.n2473 5.62393
R15684 VSS.t1479 VSS.n3359 5.62393
R15685 VSS.t2256 VSS.n2399 5.62393
R15686 VSS.t2627 VSS.n2177 5.62393
R15687 VSS.t2658 VSS.n3920 5.62393
R15688 VSS.t1449 VSS.n3853 5.62393
R15689 VSS.t1963 VSS.n3646 5.62393
R15690 VSS.t1704 VSS.n3786 5.62393
R15691 VSS.t1148 VSS.n3738 5.62393
R15692 VSS.t3263 VSS.n3690 5.62393
R15693 VSS.t2042 VSS.n113 5.62393
R15694 VSS.t1798 VSS.n279 5.62393
R15695 VSS.t1538 VSS.n203 5.62393
R15696 VSS.t1280 VSS.n4442 5.62393
R15697 VSS.t3387 VSS.n4406 5.62393
R15698 VSS.t2858 VSS.n4315 5.62393
R15699 VSS.t2981 VSS.n4566 5.62393
R15700 VSS.n6203 VSS.n138 5.62352
R15701 VSS.n1628 VSS.n1206 5.62197
R15702 VSS.n1541 VSS.n1207 5.62197
R15703 VSS.n1554 VSS.n1208 5.62197
R15704 VSS.n1387 VSS.n1209 5.62197
R15705 VSS.n4053 VSS.n1210 5.62197
R15706 VSS.n1756 VSS.n1211 5.62197
R15707 VSS.n4190 VSS.n1222 5.62197
R15708 VSS.n1117 VSS.n778 5.62197
R15709 VSS.n5622 VSS.n753 5.62197
R15710 VSS.n1049 VSS.n779 5.62197
R15711 VSS.n831 VSS.n775 5.62197
R15712 VSS.n982 VSS.n780 5.62197
R15713 VSS.n5567 VSS.n774 5.62197
R15714 VSS.n5620 VSS.n784 5.62197
R15715 VSS.n4907 VSS.n705 5.62197
R15716 VSS.n5126 VSS.n702 5.62197
R15717 VSS.n5059 VSS.n706 5.62197
R15718 VSS.n5832 VSS.n678 5.62197
R15719 VSS.n5255 VSS.n707 5.62197
R15720 VSS.n5241 VSS.n701 5.62197
R15721 VSS.n5830 VSS.n711 5.62197
R15722 VSS.n5714 VSS.n496 5.62197
R15723 VSS.n5740 VSS.n495 5.62197
R15724 VSS.n5645 VSS.n497 5.62197
R15725 VSS.n608 VSS.n494 5.62197
R15726 VSS.n5855 VSS.n498 5.62197
R15727 VSS.n5925 VSS.n493 5.62197
R15728 VSS.n5990 VSS.n509 5.62197
R15729 VSS.n3497 VSS.n3476 5.62197
R15730 VSS.n3079 VSS.n3014 5.62197
R15731 VSS.n5441 VSS.n1136 5.62197
R15732 VSS.n4872 VSS.n4851 5.62197
R15733 VSS.n5359 VSS.n4884 5.62197
R15734 VSS.n6022 VSS.n397 5.62197
R15735 VSS.n3610 VSS.n1848 5.62197
R15736 VSS.n2461 VSS.n1872 5.62197
R15737 VSS.n2534 VSS.n1874 5.62197
R15738 VSS.n3347 VSS.n1871 5.62197
R15739 VSS.n2363 VSS.n1875 5.62197
R15740 VSS.n2387 VSS.n1870 5.62197
R15741 VSS.n3608 VSS.n1879 5.62197
R15742 VSS.n3634 VSS.n1807 5.62197
R15743 VSS.n3835 VSS.n1809 5.62197
R15744 VSS.n3902 VSS.n1805 5.62197
R15745 VSS.n4029 VSS.n1813 5.62197
R15746 VSS.n3969 VSS.n1804 5.62197
R15747 VSS.n4031 VSS.n1783 5.62197
R15748 VSS.n3539 VSS.n2161 5.62197
R15749 VSS.n2997 VSS.n1328 5.62197
R15750 VSS.n2865 VSS.n1325 5.62197
R15751 VSS.n3151 VSS.n1329 5.62197
R15752 VSS.n2933 VSS.n1324 5.62197
R15753 VSS.n3222 VSS.n1330 5.62197
R15754 VSS.n4166 VSS.n1301 5.62197
R15755 VSS.n4164 VSS.n1334 5.62197
R15756 VSS.n131 VSS.n16 5.62197
R15757 VSS.n249 VSS.n17 5.62197
R15758 VSS.n235 VSS.n18 5.62197
R15759 VSS.n4473 VSS.n19 5.62197
R15760 VSS.n4375 VSS.n20 5.62197
R15761 VSS.n4346 VSS.n21 5.62197
R15762 VSS.n4597 VSS.n22 5.62197
R15763 VSS.n6233 VSS.n48 5.62197
R15764 VSS.t3635 VSS.n4268 5.61485
R15765 VSS.t3635 VSS.n4250 5.61485
R15766 VSS.n171 VSS.n159 5.61485
R15767 VSS.n171 VSS.n170 5.61485
R15768 VSS.t2658 VSS.n3931 5.61485
R15769 VSS.t1449 VSS.n3864 5.61485
R15770 VSS.t1963 VSS.n3657 5.61485
R15771 VSS.t1704 VSS.n3797 5.61485
R15772 VSS.t1148 VSS.n3749 5.61485
R15773 VSS.t3263 VSS.n3701 5.61485
R15774 VSS.t1184 VSS.n2325 5.61485
R15775 VSS.t1730 VSS.n2556 5.61485
R15776 VSS.t3249 VSS.n5959 5.61485
R15777 VSS.t3249 VSS.n5938 5.61485
R15778 VSS.t3649 VSS.n5889 5.61485
R15779 VSS.t3649 VSS.n5868 5.61485
R15780 VSS.t2447 VSS.n642 5.61485
R15781 VSS.t2447 VSS.n621 5.61485
R15782 VSS.t1318 VSS.n5680 5.61485
R15783 VSS.t1318 VSS.n5659 5.61485
R15784 VSS.t1567 VSS.n5774 5.61485
R15785 VSS.t1567 VSS.n5753 5.61485
R15786 VSS.t1828 VSS.n471 5.61485
R15787 VSS.t1828 VSS.n450 5.61485
R15788 VSS.t2423 VSS.n545 5.61485
R15789 VSS.t2423 VSS.n525 5.61485
R15790 VSS.t3353 VSS.n5203 5.61485
R15791 VSS.t3402 VSS.n5155 5.61485
R15792 VSS.t1595 VSS.n5088 5.61485
R15793 VSS.t1855 VSS.n4930 5.61485
R15794 VSS.t1343 VSS.n5021 5.61485
R15795 VSS.t2770 VSS.n5277 5.61485
R15796 VSS.t3645 VSS.n5529 5.61485
R15797 VSS.t46 VSS.n854 5.61485
R15798 VSS.t1622 VSS.n5481 5.61485
R15799 VSS.t1881 VSS.n1079 5.61485
R15800 VSS.t1367 VSS.n1011 5.61485
R15801 VSS.t3457 VSS.n944 5.61485
R15802 VSS.t2295 VSS.n1718 5.61485
R15803 VSS.t74 VSS.n1410 5.61485
R15804 VSS.t1648 VSS.n1503 5.61485
R15805 VSS.t1909 VSS.n1651 5.61485
R15806 VSS.t1395 VSS.n1576 5.61485
R15807 VSS.t2945 VSS.n4076 5.61485
R15808 VSS.t3279 VSS.n1285 5.61485
R15809 VSS.t1104 VSS.n2919 5.61485
R15810 VSS.t1676 VSS.n2893 5.61485
R15811 VSS.t1936 VSS.n2983 5.61485
R15812 VSS.t1421 VSS.n3137 5.61485
R15813 VSS.t3653 VSS.n3208 5.61485
R15814 VSS.t2555 VSS.n3272 5.61485
R15815 VSS.t2555 VSS.n3254 5.61485
R15816 VSS.t3653 VSS.n3190 5.61485
R15817 VSS.t1421 VSS.n3119 5.61485
R15818 VSS.t1936 VSS.n2965 5.61485
R15819 VSS.t1676 VSS.n2875 5.61485
R15820 VSS.t1104 VSS.n2901 5.61485
R15821 VSS.t3279 VSS.n1267 5.61485
R15822 VSS.n1624 VSS.n1206 5.61485
R15823 VSS.n1537 VSS.n1207 5.61485
R15824 VSS.n1550 VSS.n1208 5.61485
R15825 VSS.n1383 VSS.n1209 5.61485
R15826 VSS.n4049 VSS.n1210 5.61485
R15827 VSS.n1752 VSS.n1211 5.61485
R15828 VSS.n4190 VSS.n1243 5.61485
R15829 VSS.t2958 VSS.n1461 5.61485
R15830 VSS.t2958 VSS.n1442 5.61485
R15831 VSS.t2945 VSS.n4064 5.61485
R15832 VSS.t1395 VSS.n1564 5.61485
R15833 VSS.t1909 VSS.n1639 5.61485
R15834 VSS.t1648 VSS.n1491 5.61485
R15835 VSS.t74 VSS.n1398 5.61485
R15836 VSS.t2295 VSS.n1706 5.61485
R15837 VSS.n1113 VSS.n778 5.61485
R15838 VSS.n5622 VSS.n764 5.61485
R15839 VSS.n1045 VSS.n779 5.61485
R15840 VSS.n827 VSS.n775 5.61485
R15841 VSS.n978 VSS.n780 5.61485
R15842 VSS.n5563 VSS.n774 5.61485
R15843 VSS.n5620 VSS.n5614 5.61485
R15844 VSS.t3118 VSS.n905 5.61485
R15845 VSS.t3118 VSS.n886 5.61485
R15846 VSS.t3457 VSS.n932 5.61485
R15847 VSS.t1367 VSS.n999 5.61485
R15848 VSS.t1881 VSS.n1067 5.61485
R15849 VSS.t1622 VSS.n5469 5.61485
R15850 VSS.t46 VSS.n842 5.61485
R15851 VSS.t3645 VSS.n5517 5.61485
R15852 VSS.n4903 VSS.n705 5.61485
R15853 VSS.n5122 VSS.n702 5.61485
R15854 VSS.n5055 VSS.n706 5.61485
R15855 VSS.n5832 VSS.n691 5.61485
R15856 VSS.n5251 VSS.n707 5.61485
R15857 VSS.n5237 VSS.n701 5.61485
R15858 VSS.n5830 VSS.n5824 5.61485
R15859 VSS.t2612 VSS.n4981 5.61485
R15860 VSS.t2612 VSS.n4962 5.61485
R15861 VSS.t2770 VSS.n5265 5.61485
R15862 VSS.t1343 VSS.n5009 5.61485
R15863 VSS.t1855 VSS.n4918 5.61485
R15864 VSS.t1595 VSS.n5076 5.61485
R15865 VSS.t3402 VSS.n5143 5.61485
R15866 VSS.t3353 VSS.n5191 5.61485
R15867 VSS.n5710 VSS.n496 5.61485
R15868 VSS.n5736 VSS.n495 5.61485
R15869 VSS.n5641 VSS.n497 5.61485
R15870 VSS.n604 VSS.n494 5.61485
R15871 VSS.n5851 VSS.n498 5.61485
R15872 VSS.n5921 VSS.n493 5.61485
R15873 VSS.n5990 VSS.n569 5.61485
R15874 VSS.n3497 VSS.n3488 5.61485
R15875 VSS.n3079 VSS.n3070 5.61485
R15876 VSS.n5441 VSS.n5432 5.61485
R15877 VSS.n4872 VSS.n4863 5.61485
R15878 VSS.n5359 VSS.n5350 5.61485
R15879 VSS.n6022 VSS.n6013 5.61485
R15880 VSS.t2238 VSS.n2288 5.61485
R15881 VSS.t2238 VSS.n2264 5.61485
R15882 VSS.t2210 VSS.n2245 5.61485
R15883 VSS.t2210 VSS.n2230 5.61485
R15884 VSS.t2182 VSS.n3048 5.61485
R15885 VSS.t2182 VSS.n3025 5.61485
R15886 VSS.t2154 VSS.n5410 5.61485
R15887 VSS.t2154 VSS.n1147 5.61485
R15888 VSS.t2126 VSS.n4827 5.61485
R15889 VSS.t2126 VSS.n4805 5.61485
R15890 VSS.t2098 VSS.n4786 5.61485
R15891 VSS.t2098 VSS.n4771 5.61485
R15892 VSS.t2070 VSS.n431 5.61485
R15893 VSS.t2070 VSS.n408 5.61485
R15894 VSS.t1994 VSS.n2484 5.61485
R15895 VSS.t1479 VSS.n3370 5.61485
R15896 VSS.t2256 VSS.n2410 5.61485
R15897 VSS.n3572 VSS.n1991 5.61485
R15898 VSS.t2940 VSS.n1997 5.61485
R15899 VSS.n3576 VSS.n1980 5.61485
R15900 VSS.n3583 VSS.n1962 5.61485
R15901 VSS.n3610 VSS.n1860 5.61485
R15902 VSS.n2457 VSS.n1872 5.61485
R15903 VSS.n2530 VSS.n1874 5.61485
R15904 VSS.n3343 VSS.n1871 5.61485
R15905 VSS.n2359 VSS.n1875 5.61485
R15906 VSS.n2383 VSS.n1870 5.61485
R15907 VSS.n3595 VSS.n1915 5.61485
R15908 VSS.n3608 VSS.n3602 5.61485
R15909 VSS.t3237 VSS.n3443 5.61485
R15910 VSS.t3237 VSS.n3424 5.61485
R15911 VSS.t1184 VSS.n2313 5.61485
R15912 VSS.t1730 VSS.n2544 5.61485
R15913 VSS.t1994 VSS.n2472 5.61485
R15914 VSS.t1479 VSS.n3358 5.61485
R15915 VSS.t2256 VSS.n2398 5.61485
R15916 VSS.n3630 VSS.n1807 5.61485
R15917 VSS.n3831 VSS.n1809 5.61485
R15918 VSS.n3898 VSS.n1805 5.61485
R15919 VSS.n4029 VSS.n4023 5.61485
R15920 VSS.n3965 VSS.n1804 5.61485
R15921 VSS.n4031 VSS.n1794 5.61485
R15922 VSS.n3539 VSS.n3532 5.61485
R15923 VSS.t2627 VSS.n2192 5.61485
R15924 VSS.t2627 VSS.n2173 5.61485
R15925 VSS.t2658 VSS.n3919 5.61485
R15926 VSS.t1449 VSS.n3852 5.61485
R15927 VSS.t1963 VSS.n3645 5.61485
R15928 VSS.t1704 VSS.n3785 5.61485
R15929 VSS.t1148 VSS.n3737 5.61485
R15930 VSS.t3263 VSS.n3689 5.61485
R15931 VSS.n2993 VSS.n1328 5.61485
R15932 VSS.n2861 VSS.n1325 5.61485
R15933 VSS.n3147 VSS.n1329 5.61485
R15934 VSS.n2929 VSS.n1324 5.61485
R15935 VSS.n3218 VSS.n1330 5.61485
R15936 VSS.n4166 VSS.n1314 5.61485
R15937 VSS.n4164 VSS.n4158 5.61485
R15938 VSS.n127 VSS.n16 5.61485
R15939 VSS.n245 VSS.n17 5.61485
R15940 VSS.n231 VSS.n18 5.61485
R15941 VSS.n4469 VSS.n19 5.61485
R15942 VSS.n4371 VSS.n20 5.61485
R15943 VSS.n4342 VSS.n21 5.61485
R15944 VSS.n4593 VSS.n22 5.61485
R15945 VSS.n6233 VSS.n37 5.61485
R15946 VSS.t2042 VSS.n116 5.61485
R15947 VSS.t2042 VSS.n107 5.61485
R15948 VSS.t1798 VSS.n284 5.61485
R15949 VSS.t1798 VSS.n262 5.61485
R15950 VSS.t1538 VSS.n208 5.61485
R15951 VSS.t1538 VSS.n186 5.61485
R15952 VSS.t1280 VSS.n4448 5.61485
R15953 VSS.t1280 VSS.n4428 5.61485
R15954 VSS.t3387 VSS.n4412 5.61485
R15955 VSS.t3387 VSS.n4389 5.61485
R15956 VSS.t2858 VSS.n4321 5.61485
R15957 VSS.t2858 VSS.n4301 5.61485
R15958 VSS.t2981 VSS.n4572 5.61485
R15959 VSS.t2981 VSS.n4552 5.61485
R15960 VSS.n6235 VSS.n6234 5.59673
R15961 VSS.n1828 VSS.n1775 5.59224
R15962 VSS.n1828 VSS.n1795 5.59224
R15963 VSS.t2406 VSS.t1129 5.55477
R15964 VSS.n1823 VSS.t2403 5.55477
R15965 VSS.n2281 VSS.t3158 5.55356
R15966 VSS.n4192 VSS.t1115 5.52729
R15967 VSS.n5403 VSS.t1136 5.52729
R15968 VSS.n5386 VSS.t1227 5.52729
R15969 VSS.n5374 VSS.t1219 5.52729
R15970 VSS.n3519 VSS.t1203 5.52729
R15971 VSS.t90 VSS.n1846 5.48039
R15972 VSS.n2150 VSS.n2134 5.47658
R15973 VSS.n2150 VSS.n2146 5.47658
R15974 VSS.n6240 VSS.n6239 5.43749
R15975 VSS.n3521 VSS.n2219 5.43699
R15976 VSS.n4196 VSS.n4194 5.43699
R15977 VSS.n5401 VSS.n5395 5.43699
R15978 VSS.n5388 VSS.n1175 5.43699
R15979 VSS.n5376 VSS.n4754 5.43699
R15980 VSS.n2290 VSS.t3986 5.41697
R15981 VSS.t3980 VSS.n3504 5.41697
R15982 VSS.n3050 VSS.t3974 5.41697
R15983 VSS.n5412 VSS.t3968 5.41697
R15984 VSS.n4829 VSS.t3962 5.41697
R15985 VSS.t3956 VSS.n5366 5.41697
R15986 VSS.n433 VSS.t3950 5.41697
R15987 VSS.n3516 VSS.t4116 5.39044
R15988 VSS.n1192 VSS.t2884 5.39044
R15989 VSS.n5394 VSS.t3463 5.39044
R15990 VSS.n5383 VSS.t2880 5.39044
R15991 VSS.n4758 VSS.t2559 5.39044
R15992 VSS.t4131 VSS.n4236 5.39044
R15993 VSS.n49 VSS.t345 5.38555
R15994 VSS.t3157 VSS.t2860 5.38529
R15995 VSS.t3154 VSS.n2139 5.38529
R15996 VSS.n4240 VSS.n3 5.29776
R15997 VSS.n1900 VSS.n1855 5.28811
R15998 VSS.n1901 VSS.n1852 5.28811
R15999 VSS.n3557 VSS.n3556 5.24313
R16000 VSS.n4189 VSS.n4188 5.22854
R16001 VSS.n1247 VSS.t2279 5.22854
R16002 VSS.n5621 VSS.n776 5.22854
R16003 VSS.n766 VSS.t3125 5.22854
R16004 VSS.n5831 VSS.n703 5.22854
R16005 VSS.n693 VSS.t2263 5.22854
R16006 VSS.n5989 VSS.n5988 5.22854
R16007 VSS.n571 VSS.t2354 5.22854
R16008 VSS.n4165 VSS.n1326 5.22854
R16009 VSS.n1316 VSS.t2338 5.22854
R16010 VSS.n28 VSS.n27 5.17437
R16011 VSS.t2280 VSS.n1214 5.07917
R16012 VSS.t3126 VSS.n744 5.07917
R16013 VSS.t2264 VSS.n670 5.07917
R16014 VSS.t2355 VSS.n501 5.07917
R16015 VSS.t2339 VSS.n1293 5.07917
R16016 VSS.t2234 VSS.n2266 5.05587
R16017 VSS.n2284 VSS.n2283 5.05587
R16018 VSS.t2206 VSS.n2232 5.05587
R16019 VSS.n2242 VSS.n2220 5.05587
R16020 VSS.t2178 VSS.n3027 5.05587
R16021 VSS.n3044 VSS.n3043 5.05587
R16022 VSS.t2150 VSS.n1149 5.05587
R16023 VSS.n5406 VSS.n5405 5.05587
R16024 VSS.t2122 VSS.n4807 5.05587
R16025 VSS.n4823 VSS.n4822 5.05587
R16026 VSS.t2094 VSS.n4773 5.05587
R16027 VSS.n4783 VSS.n4761 5.05587
R16028 VSS.t2066 VSS.n410 5.05587
R16029 VSS.n1244 VSS.n1215 5.04397
R16030 VSS.n1245 VSS.n1244 5.04397
R16031 VSS.n806 VSS.n745 5.04397
R16032 VSS.n806 VSS.n765 5.04397
R16033 VSS.n732 VSS.n671 5.04397
R16034 VSS.n732 VSS.n692 5.04397
R16035 VSS.n582 VSS.n502 5.04397
R16036 VSS.n582 VSS.n570 5.04397
R16037 VSS.n1350 VSS.n1294 5.04397
R16038 VSS.n1350 VSS.n1315 5.04397
R16039 VSS.n4010 VSS.t2410 5.03406
R16040 VSS.n6155 VSS.n26 4.96319
R16041 VSS.n310 VSS.n27 4.96319
R16042 VSS.t4062 VSS.n3577 4.95253
R16043 VSS.n4192 VSS.t2277 4.9298
R16044 VSS.n5403 VSS.t3123 4.9298
R16045 VSS.n5386 VSS.t2261 4.9298
R16046 VSS.n5374 VSS.t2352 4.9298
R16047 VSS.n3519 VSS.t2336 4.9298
R16048 VSS.n3600 VSS.t377 4.90356
R16049 VSS.t3161 VSS.n2148 4.88046
R16050 VSS.n3497 VSS.n3477 4.87643
R16051 VSS.n3079 VSS.n3015 4.87643
R16052 VSS.n5441 VSS.n1137 4.87643
R16053 VSS.n4872 VSS.n4852 4.87643
R16054 VSS.n5359 VSS.n4885 4.87643
R16055 VSS.n6022 VSS.n398 4.87643
R16056 VSS.t2276 VSS.t1113 4.78042
R16057 VSS.n1235 VSS.t2273 4.78042
R16058 VSS.t3122 VSS.t1134 4.78042
R16059 VSS.n795 VSS.t3119 4.78042
R16060 VSS.t2260 VSS.t1225 4.78042
R16061 VSS.n721 VSS.t2257 4.78042
R16062 VSS.t2351 VSS.t1217 4.78042
R16063 VSS.n593 VSS.t2348 4.78042
R16064 VSS.t2335 VSS.t1201 4.78042
R16065 VSS.n1344 VSS.t2332 4.78042
R16066 VSS.t4063 VSS.t4073 4.72119
R16067 VSS.n1791 VSS.t1128 4.68692
R16068 VSS.t2405 VSS.n1779 4.68692
R16069 VSS.t345 VSS.t2901 4.64642
R16070 VSS.n3577 VSS.t3076 4.64303
R16071 VSS.n3497 VSS.n3468 4.54431
R16072 VSS.n3079 VSS.n3006 4.54431
R16073 VSS.n5441 VSS.n1128 4.54431
R16074 VSS.n4872 VSS.n4843 4.54431
R16075 VSS.n5359 VSS.n4876 4.54431
R16076 VSS.n6022 VSS.n388 4.54431
R16077 VSS.n2144 VSS.t2859 4.54392
R16078 VSS.t3156 VSS.n2137 4.54392
R16079 VSS.n2162 VSS.t3154 4.54346
R16080 VSS.n6235 VSS.n8 4.54084
R16081 VSS.n43 VSS.t2903 4.54084
R16082 VSS.n3576 VSS.n1951 4.53703
R16083 VSS.n3598 VSS.n1838 4.51901
R16084 VSS.n1898 VSS.n1868 4.51901
R16085 VSS.n2117 VSS.n2116 4.5005
R16086 VSS.n2115 VSS.n2114 4.5005
R16087 VSS.n3564 VSS.n3563 4.5005
R16088 VSS.n2113 VSS.n2112 4.5005
R16089 VSS.n3566 VSS.n3565 4.5005
R16090 VSS.n6247 VSS.n6246 4.5005
R16091 VSS.n4747 VSS.n4746 4.5005
R16092 VSS.n4744 VSS.n4743 4.5005
R16093 VSS.n4207 VSS.n4206 4.5005
R16094 VSS.n4204 VSS.n4203 4.5005
R16095 VSS.n2125 VSS.n2124 4.5005
R16096 VSS.n3550 VSS.n3549 4.5005
R16097 VSS.n3562 VSS.n3561 4.5005
R16098 VSS.n6096 VSS.n6047 4.50025
R16099 VSS.n6096 VSS.n6046 4.50025
R16100 VSS.n6096 VSS.n6045 4.50025
R16101 VSS.n6096 VSS.n6044 4.50025
R16102 VSS.n6096 VSS.n6042 4.50025
R16103 VSS.n6096 VSS.n6041 4.50025
R16104 VSS.n6073 VSS.n6048 4.50025
R16105 VSS.n6077 VSS.n6048 4.50025
R16106 VSS.n6079 VSS.n6048 4.50025
R16107 VSS.n6081 VSS.n6048 4.50025
R16108 VSS.n6091 VSS.n6055 4.50025
R16109 VSS.n2811 VSS.n2762 4.50025
R16110 VSS.n2811 VSS.n2761 4.50025
R16111 VSS.n2811 VSS.n2759 4.50025
R16112 VSS.n2811 VSS.n2758 4.50025
R16113 VSS.n2811 VSS.n2757 4.50025
R16114 VSS.n2798 VSS.n2770 4.50025
R16115 VSS.n2800 VSS.n2770 4.50025
R16116 VSS.n2802 VSS.n2770 4.50025
R16117 VSS.n2804 VSS.n2770 4.50025
R16118 VSS.n2809 VSS.n2808 4.50025
R16119 VSS.n2660 VSS.n2658 4.50025
R16120 VSS.n2660 VSS.n2657 4.50025
R16121 VSS.n2660 VSS.n2656 4.50025
R16122 VSS.n2660 VSS.n2655 4.50025
R16123 VSS.n2660 VSS.n2653 4.50025
R16124 VSS.n2661 VSS.n2660 4.50025
R16125 VSS.n2652 VSS.n2651 4.50025
R16126 VSS.n2652 VSS.n2649 4.50025
R16127 VSS.n2652 VSS.n2648 4.50025
R16128 VSS.n2652 VSS.n2647 4.50025
R16129 VSS.n2664 VSS.n2663 4.50025
R16130 VSS.n4647 VSS.n4646 4.50025
R16131 VSS.n4647 VSS.n4644 4.50025
R16132 VSS.n4654 VSS.n4653 4.50025
R16133 VSS.n4654 VSS.n4652 4.50025
R16134 VSS.n4654 VSS.n4651 4.50025
R16135 VSS.n4654 VSS.n4650 4.50025
R16136 VSS.n4672 VSS.n4629 4.50025
R16137 VSS.n6095 VSS.n6094 4.50013
R16138 VSS.n6089 VSS.n6088 4.50013
R16139 VSS.n6090 VSS.n6067 4.50013
R16140 VSS.n6088 VSS.n6083 4.50013
R16141 VSS.n6088 VSS.n6084 4.50013
R16142 VSS.n6067 VSS.n6065 4.50013
R16143 VSS.n6088 VSS.n6085 4.50013
R16144 VSS.n6067 VSS.n6064 4.50013
R16145 VSS.n6067 VSS.n6063 4.50013
R16146 VSS.n6088 VSS.n6087 4.50013
R16147 VSS.n6067 VSS.n6062 4.50013
R16148 VSS.n6088 VSS.n6061 4.50013
R16149 VSS.n6032 VSS.n376 4.50013
R16150 VSS.n6036 VSS.n6035 4.50013
R16151 VSS.n6034 VSS.n6032 4.50013
R16152 VSS.n367 VSS.n358 4.50013
R16153 VSS.n371 VSS.n370 4.50013
R16154 VSS.n369 VSS.n367 4.50013
R16155 VSS.n349 VSS.n340 4.50013
R16156 VSS.n353 VSS.n352 4.50013
R16157 VSS.n351 VSS.n349 4.50013
R16158 VSS.n331 VSS.n330 4.50013
R16159 VSS.n6140 VSS.n6139 4.50013
R16160 VSS.n333 VSS.n330 4.50013
R16161 VSS.n4675 VSS.n4674 4.50013
R16162 VSS.n4694 VSS.n4693 4.50013
R16163 VSS.n4677 VSS.n4674 4.50013
R16164 VSS.n2689 VSS.n2688 4.50013
R16165 VSS.n2694 VSS.n2118 4.50013
R16166 VSS.n2688 VSS.n2615 4.50013
R16167 VSS.n2705 VSS.n2704 4.50013
R16168 VSS.n2708 VSS.n2707 4.50013
R16169 VSS.n2704 VSS.n2604 4.50013
R16170 VSS.n2722 VSS.n2721 4.50013
R16171 VSS.n2725 VSS.n2724 4.50013
R16172 VSS.n2721 VSS.n2592 4.50013
R16173 VSS.n2831 VSS.n2830 4.50013
R16174 VSS.n2834 VSS.n2833 4.50013
R16175 VSS.n2830 VSS.n2735 4.50013
R16176 VSS.n2747 VSS.n2740 4.50013
R16177 VSS.n2751 VSS.n2750 4.50013
R16178 VSS.n2749 VSS.n2747 4.50013
R16179 VSS.n2771 VSS.n2756 4.50013
R16180 VSS.n2790 VSS.n2784 4.50013
R16181 VSS.n2772 VSS.n2771 4.50013
R16182 VSS.n2790 VSS.n2785 4.50013
R16183 VSS.n2790 VSS.n2786 4.50013
R16184 VSS.n2776 VSS.n2771 4.50013
R16185 VSS.n2790 VSS.n2787 4.50013
R16186 VSS.n2778 VSS.n2771 4.50013
R16187 VSS.n2780 VSS.n2771 4.50013
R16188 VSS.n2790 VSS.n2789 4.50013
R16189 VSS.n2782 VSS.n2771 4.50013
R16190 VSS.n2791 VSS.n2790 4.50013
R16191 VSS.n2659 VSS.n2634 4.50013
R16192 VSS.n2678 VSS.n2673 4.50013
R16193 VSS.n2662 VSS.n2627 4.50013
R16194 VSS.n2678 VSS.n2674 4.50013
R16195 VSS.n2678 VSS.n2675 4.50013
R16196 VSS.n2667 VSS.n2627 4.50013
R16197 VSS.n2678 VSS.n2676 4.50013
R16198 VSS.n2669 VSS.n2627 4.50013
R16199 VSS.n2671 VSS.n2627 4.50013
R16200 VSS.n2679 VSS.n2678 4.50013
R16201 VSS.n2680 VSS.n2627 4.50013
R16202 VSS.n2678 VSS.n2626 4.50013
R16203 VSS.n4649 VSS.n4648 4.50013
R16204 VSS.n4667 VSS.n4665 4.50013
R16205 VSS.n4655 VSS.n4648 4.50013
R16206 VSS.n4657 VSS.n4648 4.50013
R16207 VSS.n4667 VSS.n4663 4.50013
R16208 VSS.n4659 VSS.n4648 4.50013
R16209 VSS.n4661 VSS.n4648 4.50013
R16210 VSS.n4668 VSS.n4667 4.50013
R16211 VSS.n4648 VSS.n4628 4.50013
R16212 VSS.n6107 VSS.n380 4.49817
R16213 VSS.n6107 VSS.n378 4.49817
R16214 VSS.n6097 VSS.n6033 4.49817
R16215 VSS.n6099 VSS.n6033 4.49817
R16216 VSS.n6101 VSS.n6033 4.49817
R16217 VSS.n6103 VSS.n6033 4.49817
R16218 VSS.n6105 VSS.n6037 4.49817
R16219 VSS.n6118 VSS.n362 4.49817
R16220 VSS.n6118 VSS.n360 4.49817
R16221 VSS.n6108 VSS.n368 4.49817
R16222 VSS.n6110 VSS.n368 4.49817
R16223 VSS.n6112 VSS.n368 4.49817
R16224 VSS.n6114 VSS.n368 4.49817
R16225 VSS.n6116 VSS.n372 4.49817
R16226 VSS.n6129 VSS.n344 4.49817
R16227 VSS.n6129 VSS.n342 4.49817
R16228 VSS.n6119 VSS.n350 4.49817
R16229 VSS.n6121 VSS.n350 4.49817
R16230 VSS.n6123 VSS.n350 4.49817
R16231 VSS.n6125 VSS.n350 4.49817
R16232 VSS.n6127 VSS.n354 4.49817
R16233 VSS.n6130 VSS.n329 4.49817
R16234 VSS.n6136 VSS.n329 4.49817
R16235 VSS.n6131 VSS.n332 4.49817
R16236 VSS.n6134 VSS.n332 4.49817
R16237 VSS.n6137 VSS.n332 4.49817
R16238 VSS.n6142 VSS.n332 4.49817
R16239 VSS.n6144 VSS.n335 4.49817
R16240 VSS.n4684 VSS.n4673 4.49817
R16241 VSS.n4690 VSS.n4673 4.49817
R16242 VSS.n4685 VSS.n4676 4.49817
R16243 VSS.n4688 VSS.n4676 4.49817
R16244 VSS.n4691 VSS.n4676 4.49817
R16245 VSS.n4696 VSS.n4676 4.49817
R16246 VSS.n4698 VSS.n4679 4.49817
R16247 VSS.n2695 VSS.n2687 4.49817
R16248 VSS.n2687 VSS.n2685 4.49817
R16249 VSS.n2697 VSS.n2693 4.49817
R16250 VSS.n2697 VSS.n2692 4.49817
R16251 VSS.n2697 VSS.n2691 4.49817
R16252 VSS.n2697 VSS.n2690 4.49817
R16253 VSS.n2699 VSS.n2620 4.49817
R16254 VSS.n2703 VSS.n2702 4.49817
R16255 VSS.n2703 VSS.n2700 4.49817
R16256 VSS.n2714 VSS.n2712 4.49817
R16257 VSS.n2714 VSS.n2711 4.49817
R16258 VSS.n2714 VSS.n2710 4.49817
R16259 VSS.n2714 VSS.n2709 4.49817
R16260 VSS.n2716 VSS.n2605 4.49817
R16261 VSS.n2720 VSS.n2719 4.49817
R16262 VSS.n2720 VSS.n2717 4.49817
R16263 VSS.n2731 VSS.n2729 4.49817
R16264 VSS.n2731 VSS.n2728 4.49817
R16265 VSS.n2731 VSS.n2727 4.49817
R16266 VSS.n2731 VSS.n2726 4.49817
R16267 VSS.n2733 VSS.n2593 4.49817
R16268 VSS.n2823 VSS.n2734 4.49817
R16269 VSS.n2827 VSS.n2734 4.49817
R16270 VSS.n2839 VSS.n2590 4.49817
R16271 VSS.n2839 VSS.n2837 4.49817
R16272 VSS.n2839 VSS.n2836 4.49817
R16273 VSS.n2839 VSS.n2835 4.49817
R16274 VSS.n2841 VSS.n2736 4.49817
R16275 VSS.n2822 VSS.n2744 4.49817
R16276 VSS.n2822 VSS.n2742 4.49817
R16277 VSS.n2812 VSS.n2748 4.49817
R16278 VSS.n2814 VSS.n2748 4.49817
R16279 VSS.n2816 VSS.n2748 4.49817
R16280 VSS.n2818 VSS.n2748 4.49817
R16281 VSS.n2820 VSS.n2752 4.49817
R16282 VSS.n6096 VSS.n6043 4.49774
R16283 VSS.n6075 VSS.n6048 4.49774
R16284 VSS.n2811 VSS.n2760 4.49774
R16285 VSS.n2806 VSS.n2770 4.49774
R16286 VSS.n2660 VSS.n2654 4.49774
R16287 VSS.n2652 VSS.n2650 4.49774
R16288 VSS.n6067 VSS.n6066 4.49725
R16289 VSS.n6088 VSS.n6086 4.49725
R16290 VSS.n2774 VSS.n2771 4.49725
R16291 VSS.n2790 VSS.n2788 4.49725
R16292 VSS.n2665 VSS.n2627 4.49725
R16293 VSS.n2678 VSS.n2677 4.49725
R16294 VSS.n4647 VSS.n4645 4.49699
R16295 VSS.n4666 VSS.n4647 4.49699
R16296 VSS.n4667 VSS.n4664 4.49639
R16297 VSS.n4667 VSS.n4662 4.49639
R16298 VSS.n6107 VSS.n379 4.49181
R16299 VSS.n6107 VSS.n377 4.49181
R16300 VSS.n6118 VSS.n361 4.49181
R16301 VSS.n6118 VSS.n359 4.49181
R16302 VSS.n6129 VSS.n343 4.49181
R16303 VSS.n6129 VSS.n341 4.49181
R16304 VSS.n6133 VSS.n329 4.49181
R16305 VSS.n6141 VSS.n329 4.49181
R16306 VSS.n4687 VSS.n4673 4.49181
R16307 VSS.n4695 VSS.n4673 4.49181
R16308 VSS.n2687 VSS.n2686 4.49181
R16309 VSS.n2687 VSS.n2684 4.49181
R16310 VSS.n2703 VSS.n2701 4.49181
R16311 VSS.n2706 VSS.n2703 4.49181
R16312 VSS.n2720 VSS.n2718 4.49181
R16313 VSS.n2723 VSS.n2720 4.49181
R16314 VSS.n2825 VSS.n2734 4.49181
R16315 VSS.n2832 VSS.n2734 4.49181
R16316 VSS.n2822 VSS.n2743 4.49181
R16317 VSS.n2822 VSS.n2741 4.49181
R16318 VSS.n1806 VSS.n1784 4.47661
R16319 VSS.n1806 VSS.n1789 4.47661
R16320 VSS.n2162 VSS.n2142 4.37519
R16321 VSS.n6153 VSS.n6152 4.37069
R16322 VSS.n4352 VSS.n4351 4.37069
R16323 VSS.n4522 VSS.n4521 4.37069
R16324 VSS.n4360 VSS.n4359 4.37069
R16325 VSS.n4479 VSS.n4478 4.37069
R16326 VSS.n6158 VSS.n6157 4.37069
R16327 VSS.n320 VSS.n319 4.37069
R16328 VSS.n6241 VSS.n6240 4.37069
R16329 VSS.n1254 VSS.t2280 4.33231
R16330 VSS.n5602 VSS.t3126 4.33231
R16331 VSS.n5811 VSS.t2264 4.33231
R16332 VSS.n5986 VSS.t2355 4.33231
R16333 VSS.n4145 VSS.t2339 4.33231
R16334 VSS.n310 VSS.t116 4.32966
R16335 VSS.n1917 VSS.t190 4.32673
R16336 VSS.n2099 VSS.n2098 4.251
R16337 VSS.n2074 VSS.n1981 4.251
R16338 VSS.n2095 VSS.n2089 4.251
R16339 VSS.n2086 VSS.n2080 4.251
R16340 VSS.n2063 VSS.n2062 4.251
R16341 VSS.n4729 VSS.n4710 4.251
R16342 VSS.t2977 VSS.n2042 4.23324
R16343 VSS.n2046 VSS.n2045 4.23324
R16344 VSS.n2032 VSS.n2031 4.23324
R16345 VSS.n2053 VSS.n2052 4.23324
R16346 VSS.n2056 VSS.n2023 4.23324
R16347 VSS.n2056 VSS.n2020 4.23324
R16348 VSS.n2056 VSS.n2017 4.23324
R16349 VSS.t2297 VSS.t374 4.23059
R16350 VSS.t2296 VSS.t93 4.23059
R16351 VSS.t377 VSS.t2365 4.23059
R16352 VSS.t2238 VSS.n2258 4.21493
R16353 VSS.n3498 VSS.n3497 4.20982
R16354 VSS.n3497 VSS.n3474 4.20982
R16355 VSS.n3497 VSS.n3473 4.20982
R16356 VSS.n3497 VSS.n3471 4.20982
R16357 VSS.n3497 VSS.n3489 4.20982
R16358 VSS.n3079 VSS.n3065 4.20982
R16359 VSS.n3079 VSS.n3012 4.20982
R16360 VSS.n3079 VSS.n3011 4.20982
R16361 VSS.n3079 VSS.n3009 4.20982
R16362 VSS.n3079 VSS.n3071 4.20982
R16363 VSS.n5441 VSS.n5427 4.20982
R16364 VSS.n5441 VSS.n1134 4.20982
R16365 VSS.n5441 VSS.n1133 4.20982
R16366 VSS.n5441 VSS.n1131 4.20982
R16367 VSS.n5441 VSS.n5433 4.20982
R16368 VSS.n4873 VSS.n4872 4.20982
R16369 VSS.n4872 VSS.n4849 4.20982
R16370 VSS.n4872 VSS.n4848 4.20982
R16371 VSS.n4872 VSS.n4846 4.20982
R16372 VSS.n4872 VSS.n4864 4.20982
R16373 VSS.n5360 VSS.n5359 4.20982
R16374 VSS.n5359 VSS.n4882 4.20982
R16375 VSS.n5359 VSS.n4881 4.20982
R16376 VSS.n5359 VSS.n4879 4.20982
R16377 VSS.n5359 VSS.n5351 4.20982
R16378 VSS.n6022 VSS.n6010 4.20982
R16379 VSS.n6022 VSS.n394 4.20982
R16380 VSS.n6022 VSS.n393 4.20982
R16381 VSS.n6022 VSS.n391 4.20982
R16382 VSS.n6022 VSS.n6014 4.20982
R16383 VSS.t2238 VSS.n2285 4.20982
R16384 VSS.t2238 VSS.n2291 4.20982
R16385 VSS.t2238 VSS.n2270 4.20982
R16386 VSS.t2238 VSS.n2268 4.20982
R16387 VSS.t2238 VSS.n2267 4.20982
R16388 VSS.t2238 VSS.n2299 4.20982
R16389 VSS.t2238 VSS.n2300 4.20982
R16390 VSS.n3501 VSS.t2210 4.20982
R16391 VSS.n3506 VSS.t2210 4.20982
R16392 VSS.n3510 VSS.t2210 4.20982
R16393 VSS.t2210 VSS.n2234 4.20982
R16394 VSS.t2210 VSS.n2233 4.20982
R16395 VSS.t2210 VSS.n2251 4.20982
R16396 VSS.t2210 VSS.n2252 4.20982
R16397 VSS.t2210 VSS.n2224 4.20982
R16398 VSS.t2182 VSS.n3045 4.20982
R16399 VSS.t2182 VSS.n3051 4.20982
R16400 VSS.t2182 VSS.n3031 4.20982
R16401 VSS.t2182 VSS.n3029 4.20982
R16402 VSS.t2182 VSS.n3028 4.20982
R16403 VSS.t2182 VSS.n3059 4.20982
R16404 VSS.t2182 VSS.n3060 4.20982
R16405 VSS.t2182 VSS.n3019 4.20982
R16406 VSS.t2154 VSS.n5407 4.20982
R16407 VSS.t2154 VSS.n5413 4.20982
R16408 VSS.t2154 VSS.n1153 4.20982
R16409 VSS.t2154 VSS.n1151 4.20982
R16410 VSS.t2154 VSS.n1150 4.20982
R16411 VSS.t2154 VSS.n5421 4.20982
R16412 VSS.t2154 VSS.n5422 4.20982
R16413 VSS.t2154 VSS.n1141 4.20982
R16414 VSS.t2126 VSS.n4824 4.20982
R16415 VSS.t2126 VSS.n4830 4.20982
R16416 VSS.t2126 VSS.n4811 4.20982
R16417 VSS.t2126 VSS.n4809 4.20982
R16418 VSS.t2126 VSS.n4808 4.20982
R16419 VSS.t2126 VSS.n4838 4.20982
R16420 VSS.t2126 VSS.n4839 4.20982
R16421 VSS.t2126 VSS.n4799 4.20982
R16422 VSS.n5363 VSS.t2098 4.20982
R16423 VSS.n5368 VSS.t2098 4.20982
R16424 VSS.n5372 VSS.t2098 4.20982
R16425 VSS.t2098 VSS.n4775 4.20982
R16426 VSS.t2098 VSS.n4774 4.20982
R16427 VSS.t2098 VSS.n4792 4.20982
R16428 VSS.t2098 VSS.n4793 4.20982
R16429 VSS.t2098 VSS.n4765 4.20982
R16430 VSS.t2070 VSS.n428 4.20982
R16431 VSS.t2070 VSS.n434 4.20982
R16432 VSS.t2070 VSS.n415 4.20982
R16433 VSS.t2070 VSS.n414 4.20982
R16434 VSS.t2070 VSS.n412 4.20982
R16435 VSS.t2070 VSS.n411 4.20982
R16436 VSS.t2070 VSS.n6004 4.20982
R16437 VSS.t2070 VSS.n6005 4.20982
R16438 VSS.t2070 VSS.n402 4.20982
R16439 VSS.n4016 VSS.n4011 4.2026
R16440 VSS.n6161 VSS.n14 4.19738
R16441 VSS.n5702 VSS.n589 4.19707
R16442 VSS.n5633 VSS.n580 4.19707
R16443 VSS.n6149 VSS.n9 4.19677
R16444 VSS.n4482 VSS.n13 4.19677
R16445 VSS.n6244 VSS.n3 4.19677
R16446 VSS.n3325 VSS.n1827 4.19646
R16447 VSS.n5987 VSS.n5981 4.19615
R16448 VSS.n4754 VSS.n4749 4.19615
R16449 VSS.n316 VSS.n15 4.19585
R16450 VSS.n4355 VSS.n10 4.19554
R16451 VSS.n588 VSS.n583 4.19523
R16452 VSS.n4003 VSS.n3998 4.19492
R16453 VSS.n1615 VSS.n1198 4.19462
R16454 VSS.n5913 VSS.n579 4.19462
R16455 VSS.n2156 VSS.n2151 4.19462
R16456 VSS.n4363 VSS.n12 4.19431
R16457 VSS.n5728 VSS.n581 4.19431
R16458 VSS.n1360 VSS.n1347 4.194
R16459 VSS.n5843 VSS.n590 4.1937
R16460 VSS.n4151 VSS.n4146 4.1937
R16461 VSS.n3976 VSS.n1826 4.19339
R16462 VSS.n4009 VSS.n4004 4.19308
R16463 VSS.n2847 VSS.n1352 4.19308
R16464 VSS.n3088 VSS.n1351 4.19278
R16465 VSS.n3517 VSS.t4117 4.19267
R16466 VSS.t2885 VSS.n1187 4.19267
R16467 VSS.t3464 VSS.n1167 4.19267
R16468 VSS.n5384 VSS.t2881 4.19267
R16469 VSS.n4759 VSS.t2560 4.19267
R16470 VSS.t4132 VSS.n4235 4.19267
R16471 VSS.n4144 VSS.n4139 4.19247
R16472 VSS.n1205 VSS.n1200 4.19216
R16473 VSS.n4114 VSS.n1195 4.19216
R16474 VSS.n813 VSS.n808 4.19216
R16475 VSS.n5316 VSS.n724 4.19216
R16476 VSS.n5453 VSS.n807 4.19185
R16477 VSS.n5340 VSS.n733 4.19185
R16478 VSS.n2448 VSS.n1896 4.19185
R16479 VSS.n5804 VSS.n5799 4.19155
R16480 VSS.n4525 VSS.n11 4.19124
R16481 VSS.n819 VSS.n799 4.19124
R16482 VSS.n5817 VSS.n5812 4.19124
R16483 VSS.n3335 VSS.n1894 4.19124
R16484 VSS.n3599 VSS.n1903 4.19124
R16485 VSS.n2853 VSS.n1349 4.19124
R16486 VSS.n3622 VSS.n1829 4.19093
R16487 VSS.n1689 VSS.n1199 4.19063
R16488 VSS.n2375 VSS.n1897 4.19063
R16489 VSS.n1375 VSS.n1197 4.19032
R16490 VSS.n3547 VSS.n3542 4.19032
R16491 VSS.n3159 VSS.n1348 4.19032
R16492 VSS.n5575 VSS.n798 4.19001
R16493 VSS.n4201 VSS.n4196 4.19001
R16494 VSS.n5401 VSS.n5392 4.18971
R16495 VSS.n1764 VSS.n1194 4.1894
R16496 VSS.n4895 VSS.n731 4.1894
R16497 VSS.n3408 VSS.n1895 4.1894
R16498 VSS.n2219 VSS.n2214 4.1894
R16499 VSS.n805 VSS.n800 4.18909
R16500 VSS.n2522 VSS.n1893 4.18909
R16501 VSS.n5810 VSS.n5805 4.18878
R16502 VSS.n1892 VSS.n1887 4.18878
R16503 VSS.n730 VSS.n725 4.18848
R16504 VSS.n1175 VSS.n1170 4.18817
R16505 VSS.n5601 VSS.n5596 4.18786
R16506 VSS.n3497 VSS.n3490 4.1878
R16507 VSS.n3079 VSS.n3072 4.1878
R16508 VSS.n5441 VSS.n5434 4.1878
R16509 VSS.n4872 VSS.n4865 4.1878
R16510 VSS.n5359 VSS.n5352 4.1878
R16511 VSS.n6022 VSS.n6015 4.1878
R16512 VSS.n5608 VSS.n5603 4.18756
R16513 VSS.n1369 VSS.n1196 4.18295
R16514 VSS.n1626 VSS.n1206 4.17719
R16515 VSS.n1539 VSS.n1207 4.17719
R16516 VSS.n1552 VSS.n1208 4.17719
R16517 VSS.n1385 VSS.n1209 4.17719
R16518 VSS.n4051 VSS.n1210 4.17719
R16519 VSS.n1754 VSS.n1211 4.17719
R16520 VSS.n4190 VSS.n1218 4.17719
R16521 VSS.n1115 VSS.n778 4.17719
R16522 VSS.n5622 VSS.n748 4.17719
R16523 VSS.n1047 VSS.n779 4.17719
R16524 VSS.n829 VSS.n775 4.17719
R16525 VSS.n980 VSS.n780 4.17719
R16526 VSS.n5565 VSS.n774 4.17719
R16527 VSS.n5620 VSS.n782 4.17719
R16528 VSS.n4905 VSS.n705 4.17719
R16529 VSS.n5124 VSS.n702 4.17719
R16530 VSS.n5057 VSS.n706 4.17719
R16531 VSS.n5832 VSS.n674 4.17719
R16532 VSS.n5253 VSS.n707 4.17719
R16533 VSS.n5239 VSS.n701 4.17719
R16534 VSS.n5830 VSS.n709 4.17719
R16535 VSS.n5712 VSS.n496 4.17719
R16536 VSS.n5738 VSS.n495 4.17719
R16537 VSS.n5643 VSS.n497 4.17719
R16538 VSS.n606 VSS.n494 4.17719
R16539 VSS.n5853 VSS.n498 4.17719
R16540 VSS.n5923 VSS.n493 4.17719
R16541 VSS.n5990 VSS.n505 4.17719
R16542 VSS.n3497 VSS.n3472 4.17719
R16543 VSS.n3079 VSS.n3010 4.17719
R16544 VSS.n5441 VSS.n1132 4.17719
R16545 VSS.n4872 VSS.n4847 4.17719
R16546 VSS.n5359 VSS.n4880 4.17719
R16547 VSS.n6022 VSS.n392 4.17719
R16548 VSS.n3610 VSS.n1844 4.17719
R16549 VSS.n2459 VSS.n1872 4.17719
R16550 VSS.n2532 VSS.n1874 4.17719
R16551 VSS.n3345 VSS.n1871 4.17719
R16552 VSS.n2361 VSS.n1875 4.17719
R16553 VSS.n2385 VSS.n1870 4.17719
R16554 VSS.n3608 VSS.n1877 4.17719
R16555 VSS.n3632 VSS.n1807 4.17719
R16556 VSS.n3833 VSS.n1809 4.17719
R16557 VSS.n3900 VSS.n1805 4.17719
R16558 VSS.n4029 VSS.n1811 4.17719
R16559 VSS.n3967 VSS.n1804 4.17719
R16560 VSS.n4031 VSS.n1778 4.17719
R16561 VSS.n3539 VSS.n2159 4.17719
R16562 VSS.n2995 VSS.n1328 4.17719
R16563 VSS.n2863 VSS.n1325 4.17719
R16564 VSS.n3149 VSS.n1329 4.17719
R16565 VSS.n2931 VSS.n1324 4.17719
R16566 VSS.n3220 VSS.n1330 4.17719
R16567 VSS.n4166 VSS.n1297 4.17719
R16568 VSS.n4164 VSS.n1332 4.17719
R16569 VSS.n129 VSS.n16 4.177
R16570 VSS.n247 VSS.n17 4.177
R16571 VSS.n233 VSS.n18 4.177
R16572 VSS.n4471 VSS.n19 4.177
R16573 VSS.n4373 VSS.n20 4.177
R16574 VSS.n4344 VSS.n21 4.177
R16575 VSS.n4595 VSS.n22 4.177
R16576 VSS.n6233 VSS.n42 4.177
R16577 VSS.n1622 VSS.n1206 4.17323
R16578 VSS.n1535 VSS.n1207 4.17323
R16579 VSS.n1548 VSS.n1208 4.17323
R16580 VSS.n1381 VSS.n1209 4.17323
R16581 VSS.n4047 VSS.n1210 4.17323
R16582 VSS.n1750 VSS.n1211 4.17323
R16583 VSS.n4190 VSS.n1252 4.17323
R16584 VSS.n1111 VSS.n778 4.17323
R16585 VSS.n5622 VSS.n771 4.17323
R16586 VSS.n1043 VSS.n779 4.17323
R16587 VSS.n825 VSS.n775 4.17323
R16588 VSS.n976 VSS.n780 4.17323
R16589 VSS.n5561 VSS.n774 4.17323
R16590 VSS.n5620 VSS.n5619 4.17323
R16591 VSS.n4901 VSS.n705 4.17323
R16592 VSS.n5120 VSS.n702 4.17323
R16593 VSS.n5053 VSS.n706 4.17323
R16594 VSS.n5832 VSS.n698 4.17323
R16595 VSS.n5249 VSS.n707 4.17323
R16596 VSS.n5235 VSS.n701 4.17323
R16597 VSS.n5830 VSS.n5829 4.17323
R16598 VSS.n5708 VSS.n496 4.17323
R16599 VSS.n5734 VSS.n495 4.17323
R16600 VSS.n5639 VSS.n497 4.17323
R16601 VSS.n602 VSS.n494 4.17323
R16602 VSS.n5849 VSS.n498 4.17323
R16603 VSS.n5919 VSS.n493 4.17323
R16604 VSS.n5990 VSS.n576 4.17323
R16605 VSS.n3497 VSS.n3495 4.17323
R16606 VSS.n3079 VSS.n3077 4.17323
R16607 VSS.n5441 VSS.n5439 4.17323
R16608 VSS.n4872 VSS.n4870 4.17323
R16609 VSS.n5359 VSS.n5357 4.17323
R16610 VSS.n6022 VSS.n6020 4.17323
R16611 VSS.n3610 VSS.n1867 4.17323
R16612 VSS.n2455 VSS.n1872 4.17323
R16613 VSS.n2528 VSS.n1874 4.17323
R16614 VSS.n3341 VSS.n1871 4.17323
R16615 VSS.n2357 VSS.n1875 4.17323
R16616 VSS.n2381 VSS.n1870 4.17323
R16617 VSS.n3608 VSS.n3607 4.17323
R16618 VSS.n3628 VSS.n1807 4.17323
R16619 VSS.n3829 VSS.n1809 4.17323
R16620 VSS.n3896 VSS.n1805 4.17323
R16621 VSS.n4029 VSS.n4028 4.17323
R16622 VSS.n3963 VSS.n1804 4.17323
R16623 VSS.n4031 VSS.n1801 4.17323
R16624 VSS.n3539 VSS.n3537 4.17323
R16625 VSS.n2991 VSS.n1328 4.17323
R16626 VSS.n2859 VSS.n1325 4.17323
R16627 VSS.n3145 VSS.n1329 4.17323
R16628 VSS.n2927 VSS.n1324 4.17323
R16629 VSS.n3216 VSS.n1330 4.17323
R16630 VSS.n4166 VSS.n1321 4.17323
R16631 VSS.n4164 VSS.n4163 4.17323
R16632 VSS.n125 VSS.n16 4.17317
R16633 VSS.n243 VSS.n17 4.17317
R16634 VSS.n229 VSS.n18 4.17317
R16635 VSS.n4467 VSS.n19 4.17317
R16636 VSS.n4369 VSS.n20 4.17317
R16637 VSS.n4340 VSS.n21 4.17317
R16638 VSS.n4591 VSS.n22 4.17317
R16639 VSS.n6233 VSS.n35 4.17317
R16640 VSS.n1857 VSS.t2367 4.13445
R16641 VSS.t1196 VSS.n45 4.11848
R16642 VSS.n1241 VSS.t1112 4.03356
R16643 VSS.t2275 VSS.n1219 4.03356
R16644 VSS.n761 VSS.t1133 4.03356
R16645 VSS.t3121 VSS.n749 4.03356
R16646 VSS.n688 VSS.t1224 4.03356
R16647 VSS.t2259 VSS.n675 4.03356
R16648 VSS.n566 VSS.t1216 4.03356
R16649 VSS.t2350 VSS.n506 4.03356
R16650 VSS.n1311 VSS.t1200 4.03356
R16651 VSS.t2334 VSS.n1298 4.03356
R16652 VSS.n1238 VSS.n1223 3.9994
R16653 VSS.n1239 VSS.n1238 3.9994
R16654 VSS.n777 VSS.n754 3.9994
R16655 VSS.n777 VSS.n759 3.9994
R16656 VSS.n704 VSS.n679 3.9994
R16657 VSS.n704 VSS.n686 3.9994
R16658 VSS.n563 VSS.n510 3.9994
R16659 VSS.n564 VSS.n563 3.9994
R16660 VSS.n1327 VSS.n1302 3.9994
R16661 VSS.n1327 VSS.n1309 3.9994
R16662 VSS.n2301 VSS.t2246 3.97258
R16663 VSS.n2253 VSS.t2218 3.97258
R16664 VSS.n3061 VSS.t2190 3.97258
R16665 VSS.n5423 VSS.t2162 3.97258
R16666 VSS.n4840 VSS.t2134 3.97258
R16667 VSS.n4794 VSS.t2106 3.97258
R16668 VSS.n6006 VSS.t2078 3.97258
R16669 VSS.t3328 VSS.n1861 3.94218
R16670 VSS.n1902 VSS.n1855 3.94218
R16671 VSS.n1901 VSS.n1850 3.94218
R16672 VSS.n3596 VSS.n1868 3.7499
R16673 VSS.n1912 VSS.t3327 3.7499
R16674 VSS.n1856 VSS.t90 3.7499
R16675 VSS.n6155 VSS.n24 3.69612
R16676 VSS.n31 VSS.t2906 3.69612
R16677 VSS.n1902 VSS.t419 3.65376
R16678 VSS.t1129 VSS.n1777 3.64549
R16679 VSS.n29 VSS.t2907 3.59053
R16680 VSS.t175 VSS.n1924 3.54102
R16681 VSS.t2595 VSS.n3584 3.54102
R16682 VSS.t2594 VSS.n1954 3.54102
R16683 VSS.t2860 VSS.n2136 3.53427
R16684 VSS.n3957 VSS.n3956 3.401
R16685 VSS.n3890 VSS.n3889 3.401
R16686 VSS.n3683 VSS.n3682 3.401
R16687 VSS.n3823 VSS.n3822 3.401
R16688 VSS.n3775 VSS.n3774 3.401
R16689 VSS.n3727 VSS.n3726 3.401
R16690 VSS.n2351 VSS.n2350 3.401
R16691 VSS.n2582 VSS.n2581 3.401
R16692 VSS.n5229 VSS.n5228 3.401
R16693 VSS.n5181 VSS.n5180 3.401
R16694 VSS.n5114 VSS.n5113 3.401
R16695 VSS.n4956 VSS.n4955 3.401
R16696 VSS.n5047 VSS.n5046 3.401
R16697 VSS.n5303 VSS.n5302 3.401
R16698 VSS.n5555 VSS.n5554 3.401
R16699 VSS.n880 VSS.n879 3.401
R16700 VSS.n5507 VSS.n5506 3.401
R16701 VSS.n1105 VSS.n1104 3.401
R16702 VSS.n1037 VSS.n1036 3.401
R16703 VSS.n970 VSS.n969 3.401
R16704 VSS.n1744 VSS.n1743 3.401
R16705 VSS.n1436 VSS.n1435 3.401
R16706 VSS.n1529 VSS.n1528 3.401
R16707 VSS.n1677 VSS.n1676 3.401
R16708 VSS.n1602 VSS.n1601 3.401
R16709 VSS.n4102 VSS.n4101 3.401
R16710 VSS.n2510 VSS.n2509 3.401
R16711 VSS.n3396 VSS.n3395 3.401
R16712 VSS.n2436 VSS.n2435 3.401
R16713 VSS.t3635 VSS.n4280 3.4005
R16714 VSS.t3249 VSS.n5971 3.4005
R16715 VSS.t3649 VSS.n5901 3.4005
R16716 VSS.t2447 VSS.n654 3.4005
R16717 VSS.t1318 VSS.n5692 3.4005
R16718 VSS.t1567 VSS.n5786 3.4005
R16719 VSS.t1828 VSS.n483 3.4005
R16720 VSS.t2423 VSS.n557 3.4005
R16721 VSS.t3279 VSS.n4177 3.4005
R16722 VSS.t1104 VSS.n2950 3.4005
R16723 VSS.t1676 VSS.n3303 3.4005
R16724 VSS.t1936 VSS.n3104 3.4005
R16725 VSS.t1421 VSS.n3175 3.4005
R16726 VSS.t3653 VSS.n3239 3.4005
R16727 VSS.t2555 VSS.n3284 3.4005
R16728 VSS.t2958 VSS.n1473 3.4005
R16729 VSS.t3118 VSS.n917 3.4005
R16730 VSS.t2612 VSS.n4993 3.4005
R16731 VSS.t3237 VSS.n3455 3.4005
R16732 VSS.t2627 VSS.n2204 3.4005
R16733 VSS.t2903 VSS.t1209 3.37935
R16734 VSS.n54 VSS.t2900 3.37935
R16735 VSS.t3327 VSS.n1842 3.36535
R16736 VSS.t2371 VSS.n1840 3.26921
R16737 VSS.n4746 VSS.n0 3.26279
R16738 VSS.n6248 VSS.n6247 3.25729
R16739 VSS.n3550 VSS.n2122 3.25257
R16740 VSS.n4206 VSS.n1178 3.25021
R16741 VSS.n2124 VSS.n1182 3.24629
R16742 VSS.n4745 VSS.n4744 3.24629
R16743 VSS.n4205 VSS.n4204 3.24
R16744 VSS.n1918 VSS.t3328 3.17307
R16745 VSS.t1113 VSS.n1217 3.13733
R16746 VSS.t1134 VSS.n747 3.13733
R16747 VSS.t1225 VSS.n673 3.13733
R16748 VSS.t1217 VSS.n504 3.13733
R16749 VSS.t1201 VSS.n1296 3.13733
R16750 VSS.t2596 VSS.t144 3.09552
R16751 VSS.t2367 VSS.t1229 3.07693
R16752 VSS.n1900 VSS.t2364 3.07693
R16753 VSS.t2907 VSS.n28 3.06259
R16754 VSS.n51 VSS.n50 3.03669
R16755 VSS.n50 VSS.n49 3.03669
R16756 VSS.n3518 VSS.t4118 2.99491
R16757 VSS.n4193 VSS.t2886 2.99491
R16758 VSS.n5402 VSS.t3465 2.99491
R16759 VSS.n5385 VSS.t2882 2.99491
R16760 VSS.n4760 VSS.t2561 2.99491
R16761 VSS.t4133 VSS.n4234 2.99491
R16762 VSS.n1920 VSS.t423 2.98079
R16763 VSS.t2407 VSS.n1792 2.95121
R16764 VSS.t415 VSS.n1785 2.95121
R16765 VSS.t3158 VSS.n2145 2.86117
R16766 VSS.n2163 VSS.t319 2.86117
R16767 VSS.t1208 VSS.n43 2.85141
R16768 VSS.t2902 VSS.n44 2.85141
R16769 VSS.n1880 VSS.n1849 2.80988
R16770 VSS.n3600 VSS.n1849 2.80988
R16771 VSS.t2977 VSS.n2040 2.80302
R16772 VSS.n2056 VSS.n2026 2.80302
R16773 VSS.n1971 VSS.t3077 2.78602
R16774 VSS.n3575 VSS.n1981 2.78602
R16775 VSS.n1822 VSS.n1774 2.60406
R16776 VSS.n1792 VSS.t1130 2.60406
R16777 VSS.n1857 VSS.t1228 2.59624
R16778 VSS.t2366 VSS.n1845 2.59624
R16779 VSS.t2277 VSS.n4191 2.53983
R16780 VSS.t275 VSS.n1224 2.53983
R16781 VSS.t3123 VSS.n762 2.53983
R16782 VSS.t123 VSS.n755 2.53983
R16783 VSS.t2261 VSS.n689 2.53983
R16784 VSS.t119 VSS.n680 2.53983
R16785 VSS.t2352 VSS.n567 2.53983
R16786 VSS.t249 VSS.n511 2.53983
R16787 VSS.t2336 VSS.n1312 2.53983
R16788 VSS.t286 VSS.n1303 2.53983
R16789 VSS.t2228 VSS.n2276 2.52818
R16790 VSS.t2198 VSS.n3503 2.52818
R16791 VSS.t2170 VSS.n3037 2.52818
R16792 VSS.t2144 VSS.n1159 2.52818
R16793 VSS.t2114 VSS.n4817 2.52818
R16794 VSS.t2086 VSS.n5365 2.52818
R16795 VSS.t2060 VSS.n421 2.52818
R16796 VSS.n2158 VSS.n2133 2.52462
R16797 VSS.n2145 VSS.t2861 2.52462
R16798 VSS.n3609 VSS.n1873 2.40396
R16799 VSS.n6231 VSS.n55 2.32346
R16800 VSS.t2298 VSS.t2371 2.30782
R16801 VSS.t3635 VSS.n4261 2.29824
R16802 VSS.t3249 VSS.n5948 2.29824
R16803 VSS.t3649 VSS.n5878 2.29824
R16804 VSS.t2447 VSS.n631 2.29824
R16805 VSS.t1318 VSS.n5669 2.29824
R16806 VSS.t1567 VSS.n5763 2.29824
R16807 VSS.t1828 VSS.n460 2.29824
R16808 VSS.t2423 VSS.n534 2.29824
R16809 VSS.t2555 VSS.n3265 2.29824
R16810 VSS.t3653 VSS.n3201 2.29824
R16811 VSS.t1421 VSS.n3130 2.29824
R16812 VSS.t1936 VSS.n2976 2.29824
R16813 VSS.t1676 VSS.n2886 2.29824
R16814 VSS.t1104 VSS.n2912 2.29824
R16815 VSS.t3279 VSS.n1278 2.29824
R16816 VSS.t2958 VSS.n1454 2.29824
R16817 VSS.t2945 VSS.n4070 2.29824
R16818 VSS.t1395 VSS.n1570 2.29824
R16819 VSS.t1909 VSS.n1645 2.29824
R16820 VSS.t1648 VSS.n1497 2.29824
R16821 VSS.t74 VSS.n1404 2.29824
R16822 VSS.t2295 VSS.n1712 2.29824
R16823 VSS.t3118 VSS.n898 2.29824
R16824 VSS.t3457 VSS.n938 2.29824
R16825 VSS.t1367 VSS.n1005 2.29824
R16826 VSS.t1881 VSS.n1073 2.29824
R16827 VSS.t1622 VSS.n5475 2.29824
R16828 VSS.t46 VSS.n848 2.29824
R16829 VSS.t3645 VSS.n5523 2.29824
R16830 VSS.t2612 VSS.n4974 2.29824
R16831 VSS.t2770 VSS.n5271 2.29824
R16832 VSS.t1343 VSS.n5015 2.29824
R16833 VSS.t1855 VSS.n4924 2.29824
R16834 VSS.t1595 VSS.n5082 2.29824
R16835 VSS.t3402 VSS.n5149 2.29824
R16836 VSS.t3353 VSS.n5197 2.29824
R16837 VSS.t2238 VSS.n2274 2.29824
R16838 VSS.t2210 VSS.n2237 2.29824
R16839 VSS.t2182 VSS.n3035 2.29824
R16840 VSS.t2154 VSS.n1157 2.29824
R16841 VSS.t2126 VSS.n4815 2.29824
R16842 VSS.t2098 VSS.n4778 2.29824
R16843 VSS.t2070 VSS.n419 2.29824
R16844 VSS.t3237 VSS.n3436 2.29824
R16845 VSS.t1184 VSS.n2319 2.29824
R16846 VSS.t1730 VSS.n2550 2.29824
R16847 VSS.t1994 VSS.n2478 2.29824
R16848 VSS.t1479 VSS.n3364 2.29824
R16849 VSS.t2256 VSS.n2404 2.29824
R16850 VSS.t2627 VSS.n2185 2.29824
R16851 VSS.t2658 VSS.n3925 2.29824
R16852 VSS.t1449 VSS.n3858 2.29824
R16853 VSS.t1963 VSS.n3651 2.29824
R16854 VSS.t1704 VSS.n3791 2.29824
R16855 VSS.t1148 VSS.n3743 2.29824
R16856 VSS.t3263 VSS.n3695 2.29824
R16857 VSS.t2042 VSS.n110 2.29824
R16858 VSS.t1798 VSS.n273 2.29824
R16859 VSS.t1538 VSS.n197 2.29824
R16860 VSS.t1280 VSS.n4436 2.29824
R16861 VSS.t3387 VSS.n4400 2.29824
R16862 VSS.t2858 VSS.n4309 2.29824
R16863 VSS.t2981 VSS.n4560 2.29824
R16864 VSS.t2940 VSS.n2007 2.29759
R16865 VSS.n6030 VSS.n137 2.2505
R16866 VSS.n4738 VSS.n4737 2.2505
R16867 VSS.n4212 VSS.n4210 2.2505
R16868 VSS.n4701 VSS.n4700 2.2505
R16869 VSS.n1246 VSS.n1214 2.24109
R16870 VSS.n4191 VSS.t1114 2.24109
R16871 VSS.n794 VSS.n744 2.24109
R16872 VSS.n762 VSS.t1135 2.24109
R16873 VSS.n720 VSS.n670 2.24109
R16874 VSS.n689 VSS.t1226 2.24109
R16875 VSS.n592 VSS.n501 2.24109
R16876 VSS.n567 VSS.t1218 2.24109
R16877 VSS.n1343 VSS.n1293 2.24109
R16878 VSS.n1312 VSS.t1202 2.24109
R16879 VSS.t1209 VSS.n40 2.21787
R16880 VSS.t175 VSS.n1972 2.16701
R16881 VSS.n4729 VSS.n4709 2.126
R16882 VSS.n1911 VSS.n1862 2.11555
R16883 VSS.n1918 VSS.n1841 2.11555
R16884 VSS.n1919 VSS.t2297 2.01941
R16885 VSS.t1229 VSS.n1843 2.01941
R16886 VSS.n3583 VSS.n1953 1.97699
R16887 VSS.n2128 VSS.n2127 1.97679
R16888 VSS.n3576 VSS.n1970 1.97641
R16889 VSS.n3559 VSS.n2120 1.97415
R16890 VSS.n4208 VSS.n1181 1.97121
R16891 VSS.n4742 VSS.n1179 1.96535
R16892 VSS.n2123 VSS.n1183 1.96535
R16893 VSS.n2130 VSS.n2129 1.96535
R16894 VSS.n4638 VSS.n1177 1.96007
R16895 VSS.t3635 VSS.n4265 1.89511
R16896 VSS.t2423 VSS.n530 1.89511
R16897 VSS.t3249 VSS.n5944 1.89511
R16898 VSS.t3649 VSS.n5874 1.89511
R16899 VSS.t2447 VSS.n627 1.89511
R16900 VSS.t1318 VSS.n5665 1.89511
R16901 VSS.t1567 VSS.n5759 1.89511
R16902 VSS.t1828 VSS.n456 1.89511
R16903 VSS.t2555 VSS.n3269 1.89511
R16904 VSS.t3653 VSS.n3205 1.89511
R16905 VSS.t1421 VSS.n3134 1.89511
R16906 VSS.t1936 VSS.n2980 1.89511
R16907 VSS.t1676 VSS.n2890 1.89511
R16908 VSS.t1104 VSS.n2916 1.89511
R16909 VSS.t3279 VSS.n1282 1.89511
R16910 VSS.t2958 VSS.n1458 1.89511
R16911 VSS.n4092 VSS.t2945 1.89511
R16912 VSS.n1592 VSS.t1395 1.89511
R16913 VSS.n1667 VSS.t1909 1.89511
R16914 VSS.n1519 VSS.t1648 1.89511
R16915 VSS.n1426 VSS.t74 1.89511
R16916 VSS.n1734 VSS.t2295 1.89511
R16917 VSS.t3118 VSS.n902 1.89511
R16918 VSS.n960 VSS.t3457 1.89511
R16919 VSS.n1027 VSS.t1367 1.89511
R16920 VSS.n1095 VSS.t1881 1.89511
R16921 VSS.n5497 VSS.t1622 1.89511
R16922 VSS.n870 VSS.t46 1.89511
R16923 VSS.n5545 VSS.t3645 1.89511
R16924 VSS.t2612 VSS.n4978 1.89511
R16925 VSS.n5293 VSS.t2770 1.89511
R16926 VSS.n5037 VSS.t1343 1.89511
R16927 VSS.n4946 VSS.t1855 1.89511
R16928 VSS.n5104 VSS.t1595 1.89511
R16929 VSS.n5171 VSS.t3402 1.89511
R16930 VSS.n5219 VSS.t3353 1.89511
R16931 VSS.t3237 VSS.n3440 1.89511
R16932 VSS.n2341 VSS.t1184 1.89511
R16933 VSS.n2572 VSS.t1730 1.89511
R16934 VSS.n2500 VSS.t1994 1.89511
R16935 VSS.n3386 VSS.t1479 1.89511
R16936 VSS.n2426 VSS.t2256 1.89511
R16937 VSS.t2627 VSS.n2189 1.89511
R16938 VSS.n3947 VSS.t2658 1.89511
R16939 VSS.n3880 VSS.t1449 1.89511
R16940 VSS.n3673 VSS.t1963 1.89511
R16941 VSS.n3813 VSS.t1704 1.89511
R16942 VSS.n3765 VSS.t1148 1.89511
R16943 VSS.n3717 VSS.t3263 1.89511
R16944 VSS.n4204 VSS.n1182 1.88386
R16945 VSS.n2124 VSS.n2122 1.87757
R16946 VSS.n4744 VSS.n1178 1.87757
R16947 VSS.n4206 VSS.n4205 1.87364
R16948 VSS.n6247 VSS.n0 1.86657
R16949 VSS.n4746 VSS.n4745 1.86107
R16950 VSS.t3635 VSS.n4275 1.82604
R16951 VSS.t3635 VSS.n4251 1.82604
R16952 VSS.t3635 VSS.n4247 1.82604
R16953 VSS.n3730 VSS.n3686 1.82604
R16954 VSS.n3778 VSS.n3734 1.82604
R16955 VSS.n3845 VSS.n3782 1.82604
R16956 VSS.n3990 VSS.n3642 1.82604
R16957 VSS.n3912 VSS.n3849 1.82604
R16958 VSS.n3986 VSS.n3916 1.82604
R16959 VSS.t3249 VSS.n5956 1.82604
R16960 VSS.t3249 VSS.n5962 1.82604
R16961 VSS.t3649 VSS.n5886 1.82604
R16962 VSS.t3649 VSS.n5892 1.82604
R16963 VSS.t2447 VSS.n639 1.82604
R16964 VSS.t2447 VSS.n645 1.82604
R16965 VSS.t1318 VSS.n5677 1.82604
R16966 VSS.t1318 VSS.n5683 1.82604
R16967 VSS.t1567 VSS.n5771 1.82604
R16968 VSS.t1567 VSS.n5777 1.82604
R16969 VSS.t1828 VSS.n468 1.82604
R16970 VSS.t1828 VSS.n474 1.82604
R16971 VSS.t2423 VSS.n542 1.82604
R16972 VSS.t2423 VSS.n548 1.82604
R16973 VSS.t2423 VSS.n518 1.82604
R16974 VSS.t3649 VSS.n5862 1.82604
R16975 VSS.t1318 VSS.n5653 1.82604
R16976 VSS.t1828 VSS.n444 1.82604
R16977 VSS.t1567 VSS.n5747 1.82604
R16978 VSS.t2447 VSS.n615 1.82604
R16979 VSS.t3249 VSS.n5932 1.82604
R16980 VSS.n5304 VSS.n5262 1.82604
R16981 VSS.n5069 VSS.n5006 1.82604
R16982 VSS.n5329 VSS.n4915 1.82604
R16983 VSS.n5136 VSS.n5073 1.82604
R16984 VSS.n5184 VSS.n5140 1.82604
R16985 VSS.n5325 VSS.n5188 1.82604
R16986 VSS.n992 VSS.n929 1.82604
R16987 VSS.n1060 VSS.n996 1.82604
R16988 VSS.n5462 VSS.n1064 1.82604
R16989 VSS.n5510 VSS.n5466 1.82604
R16990 VSS.n5588 VSS.n839 1.82604
R16991 VSS.n5584 VSS.n5514 1.82604
R16992 VSS.n4103 VSS.n4061 1.82604
R16993 VSS.n1603 VSS.n1561 1.82604
R16994 VSS.n1678 VSS.n1636 1.82604
R16995 VSS.n1699 VSS.n1488 1.82604
R16996 VSS.n4127 VSS.n1395 1.82604
R16997 VSS.n4123 VSS.n1703 1.82604
R16998 VSS.t3279 VSS.n4172 1.82604
R16999 VSS.t1104 VSS.n2945 1.82604
R17000 VSS.t1676 VSS.n3298 1.82604
R17001 VSS.t1936 VSS.n3099 1.82604
R17002 VSS.t1421 VSS.n3170 1.82604
R17003 VSS.t3653 VSS.n3234 1.82604
R17004 VSS.t2555 VSS.n3279 1.82604
R17005 VSS.t2555 VSS.n3255 1.82604
R17006 VSS.t2555 VSS.n3251 1.82604
R17007 VSS.t3653 VSS.n3191 1.82604
R17008 VSS.t3653 VSS.n3187 1.82604
R17009 VSS.t1421 VSS.n3120 1.82604
R17010 VSS.t1421 VSS.n3116 1.82604
R17011 VSS.t1936 VSS.n2966 1.82604
R17012 VSS.t1936 VSS.n2962 1.82604
R17013 VSS.t1676 VSS.n2876 1.82604
R17014 VSS.t1676 VSS.n2872 1.82604
R17015 VSS.t1104 VSS.n2902 1.82604
R17016 VSS.t1104 VSS.n2898 1.82604
R17017 VSS.t3279 VSS.n1268 1.82604
R17018 VSS.t3279 VSS.n1264 1.82604
R17019 VSS.t2958 VSS.n1468 1.82604
R17020 VSS.t2958 VSS.n1443 1.82604
R17021 VSS.t2958 VSS.n1439 1.82604
R17022 VSS.n4083 VSS.t2945 1.82604
R17023 VSS.n4088 VSS.t2945 1.82604
R17024 VSS.n1583 VSS.t1395 1.82604
R17025 VSS.n1588 VSS.t1395 1.82604
R17026 VSS.n1658 VSS.t1909 1.82604
R17027 VSS.n1663 VSS.t1909 1.82604
R17028 VSS.n1510 VSS.t1648 1.82604
R17029 VSS.n1515 VSS.t1648 1.82604
R17030 VSS.n1417 VSS.t74 1.82604
R17031 VSS.n1422 VSS.t74 1.82604
R17032 VSS.n1725 VSS.t2295 1.82604
R17033 VSS.n1730 VSS.t2295 1.82604
R17034 VSS.t3118 VSS.n912 1.82604
R17035 VSS.t3118 VSS.n887 1.82604
R17036 VSS.t3118 VSS.n883 1.82604
R17037 VSS.n951 VSS.t3457 1.82604
R17038 VSS.n956 VSS.t3457 1.82604
R17039 VSS.n1018 VSS.t1367 1.82604
R17040 VSS.n1023 VSS.t1367 1.82604
R17041 VSS.n1086 VSS.t1881 1.82604
R17042 VSS.n1091 VSS.t1881 1.82604
R17043 VSS.n5488 VSS.t1622 1.82604
R17044 VSS.n5493 VSS.t1622 1.82604
R17045 VSS.n861 VSS.t46 1.82604
R17046 VSS.n866 VSS.t46 1.82604
R17047 VSS.n5536 VSS.t3645 1.82604
R17048 VSS.n5541 VSS.t3645 1.82604
R17049 VSS.t2612 VSS.n4988 1.82604
R17050 VSS.t2612 VSS.n4963 1.82604
R17051 VSS.t2612 VSS.n4959 1.82604
R17052 VSS.n5284 VSS.t2770 1.82604
R17053 VSS.n5289 VSS.t2770 1.82604
R17054 VSS.n5028 VSS.t1343 1.82604
R17055 VSS.n5033 VSS.t1343 1.82604
R17056 VSS.n4937 VSS.t1855 1.82604
R17057 VSS.n4942 VSS.t1855 1.82604
R17058 VSS.n5095 VSS.t1595 1.82604
R17059 VSS.n5100 VSS.t1595 1.82604
R17060 VSS.n5162 VSS.t3402 1.82604
R17061 VSS.n5167 VSS.t3402 1.82604
R17062 VSS.n5210 VSS.t3353 1.82604
R17063 VSS.n5215 VSS.t3353 1.82604
R17064 VSS.n2437 VSS.n2395 1.82604
R17065 VSS.n3397 VSS.n3355 1.82604
R17066 VSS.n2511 VSS.n2469 1.82604
R17067 VSS.n2583 VSS.n2541 1.82604
R17068 VSS.n3417 VSS.n2310 1.82604
R17069 VSS.t3237 VSS.n3450 1.82604
R17070 VSS.t3237 VSS.n3425 1.82604
R17071 VSS.t3237 VSS.n3421 1.82604
R17072 VSS.n2332 VSS.t1184 1.82604
R17073 VSS.n2337 VSS.t1184 1.82604
R17074 VSS.n2563 VSS.t1730 1.82604
R17075 VSS.n2568 VSS.t1730 1.82604
R17076 VSS.n2491 VSS.t1994 1.82604
R17077 VSS.n2496 VSS.t1994 1.82604
R17078 VSS.n3377 VSS.t1479 1.82604
R17079 VSS.n3382 VSS.t1479 1.82604
R17080 VSS.n2417 VSS.t2256 1.82604
R17081 VSS.n2422 VSS.t2256 1.82604
R17082 VSS.t2627 VSS.n2199 1.82604
R17083 VSS.t2627 VSS.n2174 1.82604
R17084 VSS.t2627 VSS.n2170 1.82604
R17085 VSS.n3938 VSS.t2658 1.82604
R17086 VSS.n3943 VSS.t2658 1.82604
R17087 VSS.n3871 VSS.t1449 1.82604
R17088 VSS.n3876 VSS.t1449 1.82604
R17089 VSS.n3664 VSS.t1963 1.82604
R17090 VSS.n3669 VSS.t1963 1.82604
R17091 VSS.n3804 VSS.t1704 1.82604
R17092 VSS.n3809 VSS.t1704 1.82604
R17093 VSS.n3756 VSS.t1148 1.82604
R17094 VSS.n3761 VSS.t1148 1.82604
R17095 VSS.n3708 VSS.t3263 1.82604
R17096 VSS.n3713 VSS.t3263 1.82604
R17097 VSS.t3635 VSS.n4287 1.82481
R17098 VSS.t3635 VSS.n4286 1.82481
R17099 VSS.n3950 VSS.t2658 1.82481
R17100 VSS.n3951 VSS.t2658 1.82481
R17101 VSS.n3883 VSS.t1449 1.82481
R17102 VSS.n3884 VSS.t1449 1.82481
R17103 VSS.n3676 VSS.t1963 1.82481
R17104 VSS.n3677 VSS.t1963 1.82481
R17105 VSS.n3816 VSS.t1704 1.82481
R17106 VSS.n3817 VSS.t1704 1.82481
R17107 VSS.n3768 VSS.t1148 1.82481
R17108 VSS.n3769 VSS.t1148 1.82481
R17109 VSS.n3720 VSS.t3263 1.82481
R17110 VSS.n3721 VSS.t3263 1.82481
R17111 VSS.n2344 VSS.t1184 1.82481
R17112 VSS.n2345 VSS.t1184 1.82481
R17113 VSS.n2575 VSS.t1730 1.82481
R17114 VSS.n2576 VSS.t1730 1.82481
R17115 VSS.t3249 VSS.n5942 1.82481
R17116 VSS.t3249 VSS.n5941 1.82481
R17117 VSS.t3649 VSS.n5872 1.82481
R17118 VSS.t3649 VSS.n5871 1.82481
R17119 VSS.t2447 VSS.n625 1.82481
R17120 VSS.t2447 VSS.n624 1.82481
R17121 VSS.t1318 VSS.n5663 1.82481
R17122 VSS.t1318 VSS.n5662 1.82481
R17123 VSS.t1567 VSS.n5757 1.82481
R17124 VSS.t1567 VSS.n5756 1.82481
R17125 VSS.t1828 VSS.n454 1.82481
R17126 VSS.t1828 VSS.n453 1.82481
R17127 VSS.t2423 VSS.n528 1.82481
R17128 VSS.t2423 VSS.n527 1.82481
R17129 VSS.n5222 VSS.t3353 1.82481
R17130 VSS.n5223 VSS.t3353 1.82481
R17131 VSS.n5174 VSS.t3402 1.82481
R17132 VSS.n5175 VSS.t3402 1.82481
R17133 VSS.n5107 VSS.t1595 1.82481
R17134 VSS.n5108 VSS.t1595 1.82481
R17135 VSS.n4949 VSS.t1855 1.82481
R17136 VSS.n4950 VSS.t1855 1.82481
R17137 VSS.n5040 VSS.t1343 1.82481
R17138 VSS.n5041 VSS.t1343 1.82481
R17139 VSS.n5296 VSS.t2770 1.82481
R17140 VSS.n5297 VSS.t2770 1.82481
R17141 VSS.n5548 VSS.t3645 1.82481
R17142 VSS.n5549 VSS.t3645 1.82481
R17143 VSS.n873 VSS.t46 1.82481
R17144 VSS.n874 VSS.t46 1.82481
R17145 VSS.n5500 VSS.t1622 1.82481
R17146 VSS.n5501 VSS.t1622 1.82481
R17147 VSS.n1098 VSS.t1881 1.82481
R17148 VSS.n1099 VSS.t1881 1.82481
R17149 VSS.n1030 VSS.t1367 1.82481
R17150 VSS.n1031 VSS.t1367 1.82481
R17151 VSS.n963 VSS.t3457 1.82481
R17152 VSS.n964 VSS.t3457 1.82481
R17153 VSS.n1737 VSS.t2295 1.82481
R17154 VSS.n1738 VSS.t2295 1.82481
R17155 VSS.n1429 VSS.t74 1.82481
R17156 VSS.n1430 VSS.t74 1.82481
R17157 VSS.n1522 VSS.t1648 1.82481
R17158 VSS.n1523 VSS.t1648 1.82481
R17159 VSS.n1670 VSS.t1909 1.82481
R17160 VSS.n1671 VSS.t1909 1.82481
R17161 VSS.n1595 VSS.t1395 1.82481
R17162 VSS.n1596 VSS.t1395 1.82481
R17163 VSS.n4095 VSS.t2945 1.82481
R17164 VSS.n4096 VSS.t2945 1.82481
R17165 VSS.t3279 VSS.n4184 1.82481
R17166 VSS.t3279 VSS.n4183 1.82481
R17167 VSS.t1104 VSS.n2957 1.82481
R17168 VSS.t1104 VSS.n2956 1.82481
R17169 VSS.t1676 VSS.n3310 1.82481
R17170 VSS.t1676 VSS.n3309 1.82481
R17171 VSS.t1936 VSS.n3111 1.82481
R17172 VSS.t1936 VSS.n3110 1.82481
R17173 VSS.t1421 VSS.n3182 1.82481
R17174 VSS.t1421 VSS.n3181 1.82481
R17175 VSS.t3653 VSS.n3246 1.82481
R17176 VSS.t3653 VSS.n3245 1.82481
R17177 VSS.t2555 VSS.n3291 1.82481
R17178 VSS.t2555 VSS.n3290 1.82481
R17179 VSS.t2958 VSS.n1480 1.82481
R17180 VSS.t2958 VSS.n1479 1.82481
R17181 VSS.t3118 VSS.n924 1.82481
R17182 VSS.t3118 VSS.n923 1.82481
R17183 VSS.t2612 VSS.n5000 1.82481
R17184 VSS.t2612 VSS.n4999 1.82481
R17185 VSS.n2503 VSS.t1994 1.82481
R17186 VSS.n2504 VSS.t1994 1.82481
R17187 VSS.n3389 VSS.t1479 1.82481
R17188 VSS.n3390 VSS.t1479 1.82481
R17189 VSS.n2429 VSS.t2256 1.82481
R17190 VSS.n2430 VSS.t2256 1.82481
R17191 VSS.t3237 VSS.n3462 1.82481
R17192 VSS.t3237 VSS.n3461 1.82481
R17193 VSS.t2627 VSS.n2211 1.82481
R17194 VSS.t2627 VSS.n2210 1.82481
R17195 VSS.t1798 VSS.n281 1.81364
R17196 VSS.t1798 VSS.n287 1.81364
R17197 VSS.t1798 VSS.n269 1.81364
R17198 VSS.t1798 VSS.n268 1.81364
R17199 VSS.t1798 VSS.n266 1.81364
R17200 VSS.t1798 VSS.n265 1.81364
R17201 VSS.t1798 VSS.n296 1.81364
R17202 VSS.t1798 VSS.n297 1.81364
R17203 VSS.t1798 VSS.n256 1.81364
R17204 VSS.t1538 VSS.n205 1.81364
R17205 VSS.t1538 VSS.n211 1.81364
R17206 VSS.t1538 VSS.n193 1.81364
R17207 VSS.t1538 VSS.n192 1.81364
R17208 VSS.t1538 VSS.n190 1.81364
R17209 VSS.t1538 VSS.n189 1.81364
R17210 VSS.t1538 VSS.n221 1.81364
R17211 VSS.t1538 VSS.n222 1.81364
R17212 VSS.t1538 VSS.n180 1.81364
R17213 VSS.t1280 VSS.n4445 1.81364
R17214 VSS.t1280 VSS.n4451 1.81364
R17215 VSS.n4493 VSS.t1280 1.81364
R17216 VSS.n4494 VSS.t1280 1.81364
R17217 VSS.t1280 VSS.n4432 1.81364
R17218 VSS.t1280 VSS.n4431 1.81364
R17219 VSS.t1280 VSS.n4459 1.81364
R17220 VSS.t1280 VSS.n4460 1.81364
R17221 VSS.t1280 VSS.n4422 1.81364
R17222 VSS.t3387 VSS.n4409 1.81364
R17223 VSS.t3387 VSS.n4415 1.81364
R17224 VSS.t3387 VSS.n4396 1.81364
R17225 VSS.t3387 VSS.n4395 1.81364
R17226 VSS.t3387 VSS.n4393 1.81364
R17227 VSS.t3387 VSS.n4392 1.81364
R17228 VSS.t3387 VSS.n4507 1.81364
R17229 VSS.t3387 VSS.n4508 1.81364
R17230 VSS.t3387 VSS.n4383 1.81364
R17231 VSS.t2858 VSS.n4318 1.81364
R17232 VSS.t2858 VSS.n4324 1.81364
R17233 VSS.n4537 VSS.t2858 1.81364
R17234 VSS.n4538 VSS.t2858 1.81364
R17235 VSS.t2858 VSS.n4305 1.81364
R17236 VSS.t2858 VSS.n4304 1.81364
R17237 VSS.t2858 VSS.n4332 1.81364
R17238 VSS.t2858 VSS.n4333 1.81364
R17239 VSS.t2858 VSS.n4295 1.81364
R17240 VSS.t2981 VSS.n4569 1.81364
R17241 VSS.t2981 VSS.n4575 1.81364
R17242 VSS.n4609 VSS.t2981 1.81364
R17243 VSS.n4610 VSS.t2981 1.81364
R17244 VSS.t2981 VSS.n4556 1.81364
R17245 VSS.t2981 VSS.n4555 1.81364
R17246 VSS.t2981 VSS.n4583 1.81364
R17247 VSS.t2981 VSS.n4584 1.81364
R17248 VSS.t2981 VSS.n4546 1.81364
R17249 VSS.t152 VSS.n3522 1.79715
R17250 VSS.n3520 VSS.t4119 1.79715
R17251 VSS.n4195 VSS.t227 1.79715
R17252 VSS.t2887 VSS.n1186 1.79715
R17253 VSS.n5400 VSS.t212 1.79715
R17254 VSS.n1166 VSS.t3466 1.79715
R17255 VSS.t215 VSS.n5389 1.79715
R17256 VSS.n5387 VSS.t2883 1.79715
R17257 VSS.t193 VSS.n5377 1.79715
R17258 VSS.n5375 VSS.t2562 1.79715
R17259 VSS.t196 VSS.n6237 1.79715
R17260 VSS.t4134 VSS.n4233 1.79715
R17261 VSS.n39 VSS.t2904 1.79552
R17262 VSS.n2633 VSS.n2113 1.76532
R17263 VSS.n3556 VSS.n3555 1.7605
R17264 VSS.n3555 VSS.n3554 1.7605
R17265 VSS.n3554 VSS.n3553 1.7605
R17266 VSS.n3553 VSS.n3552 1.7605
R17267 VSS.n3552 VSS.n3551 1.7605
R17268 VSS.n3595 VSS.n1910 1.7283
R17269 VSS.t2368 VSS.n1858 1.63485
R17270 VSS.t419 VSS.n1850 1.63485
R17271 VSS.n1910 VSS.n1909 1.61672
R17272 VSS.n1174 VSS.n1173 1.59199
R17273 VSS.n5399 VSS.n5398 1.59199
R17274 VSS.n4199 VSS.n4198 1.59199
R17275 VSS.n2218 VSS.n2217 1.59199
R17276 VSS.n4149 VSS.n4148 1.59199
R17277 VSS.n1358 VSS.n1357 1.59199
R17278 VSS.n4143 VSS.n4142 1.59199
R17279 VSS.n3157 VSS.n3156 1.59199
R17280 VSS.n2845 VSS.n2844 1.59199
R17281 VSS.n2851 VSS.n2850 1.59199
R17282 VSS.n3086 VSS.n3085 1.59199
R17283 VSS.n3545 VSS.n3544 1.59199
R17284 VSS.n2155 VSS.n2154 1.59199
R17285 VSS.n4008 VSS.n4007 1.59199
R17286 VSS.n3974 VSS.n3973 1.59199
R17287 VSS.n4014 VSS.n4013 1.59199
R17288 VSS.n3323 VSS.n3322 1.59199
R17289 VSS.n4002 VSS.n4001 1.59199
R17290 VSS.n3620 VSS.n3619 1.59199
R17291 VSS.n1907 VSS.n1906 1.59199
R17292 VSS.n2373 VSS.n2372 1.59199
R17293 VSS.n2446 VSS.n2445 1.59199
R17294 VSS.n3406 VSS.n3405 1.59199
R17295 VSS.n3333 VSS.n3332 1.59199
R17296 VSS.n2520 VSS.n2519 1.59199
R17297 VSS.n1891 VSS.n1890 1.59199
R17298 VSS.n4753 VSS.n4752 1.59199
R17299 VSS.n5985 VSS.n5984 1.59199
R17300 VSS.n5911 VSS.n5910 1.59199
R17301 VSS.n5841 VSS.n5840 1.59199
R17302 VSS.n5631 VSS.n5630 1.59199
R17303 VSS.n5700 VSS.n5699 1.59199
R17304 VSS.n5726 VSS.n5725 1.59199
R17305 VSS.n587 VSS.n586 1.59199
R17306 VSS.n5815 VSS.n5814 1.59199
R17307 VSS.n5314 VSS.n5313 1.59199
R17308 VSS.n5809 VSS.n5808 1.59199
R17309 VSS.n729 VSS.n728 1.59199
R17310 VSS.n5803 VSS.n5802 1.59199
R17311 VSS.n4893 VSS.n4892 1.59199
R17312 VSS.n5338 VSS.n5337 1.59199
R17313 VSS.n5606 VSS.n5605 1.59199
R17314 VSS.n5573 VSS.n5572 1.59199
R17315 VSS.n5600 VSS.n5599 1.59199
R17316 VSS.n817 VSS.n816 1.59199
R17317 VSS.n812 VSS.n811 1.59199
R17318 VSS.n804 VSS.n803 1.59199
R17319 VSS.n5451 VSS.n5450 1.59199
R17320 VSS.n1762 VSS.n1761 1.59199
R17321 VSS.n4112 VSS.n4111 1.59199
R17322 VSS.n1367 VSS.n1366 1.59199
R17323 VSS.n1373 VSS.n1372 1.59199
R17324 VSS.n1613 VSS.n1612 1.59199
R17325 VSS.n1687 VSS.n1686 1.59199
R17326 VSS.n1204 VSS.n1203 1.59199
R17327 VSS.n30 VSS.n29 1.58434
R17328 VSS.t1210 VSS.n39 1.58434
R17329 VSS.t517 VSS.n1796 1.56264
R17330 VSS.t1131 VSS.n1776 1.56264
R17331 VSS.t165 VSS.t2594 1.54801
R17332 VSS.n1971 VSS.t109 1.54801
R17333 VSS.t3441 VSS.t136 1.54801
R17334 VSS.n6242 VSS.n3 1.51793
R17335 VSS.n318 VSS.n15 1.51793
R17336 VSS.n6159 VSS.n14 1.51793
R17337 VSS.n4480 VSS.n13 1.51793
R17338 VSS.n4361 VSS.n12 1.51793
R17339 VSS.n4523 VSS.n11 1.51793
R17340 VSS.n4353 VSS.n10 1.51793
R17341 VSS.n6151 VSS.n9 1.51793
R17342 VSS.n2147 VSS.t243 1.51497
R17343 VSS.t2862 VSS.n2135 1.51497
R17344 VSS.n3557 VSS.n3550 1.50436
R17345 VSS.n1899 VSS.n1840 1.44258
R17346 VSS.t1230 VSS.n1858 1.44258
R17347 VSS.n6219 VSS 1.39744
R17348 VSS.t130 VSS.n1772 1.38907
R17349 VSS.n3540 VSS.t290 1.3467
R17350 VSS.t2370 VSS.t2296 1.34644
R17351 VSS.n1247 VSS.t360 1.34485
R17352 VSS.n1216 VSS.t1115 1.34485
R17353 VSS.t333 VSS.n766 1.34485
R17354 VSS.t1136 VSS.n746 1.34485
R17355 VSS.t351 VSS.n693 1.34485
R17356 VSS.t1227 VSS.n672 1.34485
R17357 VSS.t339 VSS.n571 1.34485
R17358 VSS.t1219 VSS.n503 1.34485
R17359 VSS.t363 VSS.n1316 1.34485
R17360 VSS.t1203 VSS.n1295 1.34485
R17361 VSS.n1911 VSS.t2370 1.2503
R17362 VSS.n1912 VSS.t2369 1.2503
R17363 VSS.n1917 VSS.t1231 1.2503
R17364 VSS.n6150 VSS.n325 1.19675
R17365 VSS.n6152 VSS.n324 1.19675
R17366 VSS.n4354 VSS.n4349 1.19675
R17367 VSS.n4352 VSS.n4350 1.19675
R17368 VSS.n4524 VSS.n4519 1.19675
R17369 VSS.n4522 VSS.n4520 1.19675
R17370 VSS.n4362 VSS.n4357 1.19675
R17371 VSS.n4360 VSS.n4358 1.19675
R17372 VSS.n4481 VSS.n4476 1.19675
R17373 VSS.n4479 VSS.n4477 1.19675
R17374 VSS.n6160 VSS.n308 1.19675
R17375 VSS.n6158 VSS.n309 1.19675
R17376 VSS.n317 VSS.n314 1.19675
R17377 VSS.n319 VSS.n313 1.19675
R17378 VSS.n6243 VSS.n4 1.19675
R17379 VSS.n6241 VSS.n5 1.19675
R17380 VSS.n4751 VSS.n4750 1.19675
R17381 VSS.n1172 VSS.n1171 1.19675
R17382 VSS.n5397 VSS.n5396 1.19675
R17383 VSS.n4200 VSS.n4197 1.19675
R17384 VSS.n2216 VSS.n2215 1.19675
R17385 VSS.n4150 VSS.n4147 1.19675
R17386 VSS.n1359 VSS.n1356 1.19675
R17387 VSS.n4141 VSS.n4140 1.19675
R17388 VSS.n3158 VSS.n3155 1.19675
R17389 VSS.n2846 VSS.n2843 1.19675
R17390 VSS.n2852 VSS.n2849 1.19675
R17391 VSS.n3087 VSS.n3084 1.19675
R17392 VSS.n3546 VSS.n3543 1.19675
R17393 VSS.n2153 VSS.n2152 1.19675
R17394 VSS.n4006 VSS.n4005 1.19675
R17395 VSS.n3975 VSS.n3972 1.19675
R17396 VSS.n4015 VSS.n4012 1.19675
R17397 VSS.n3324 VSS.n3321 1.19675
R17398 VSS.n4000 VSS.n3999 1.19675
R17399 VSS.n3621 VSS.n3618 1.19675
R17400 VSS.n1914 VSS.n1913 1.19675
R17401 VSS.n1905 VSS.n1904 1.19675
R17402 VSS.n2374 VSS.n2371 1.19675
R17403 VSS.n2447 VSS.n2444 1.19675
R17404 VSS.n3407 VSS.n3404 1.19675
R17405 VSS.n3334 VSS.n3331 1.19675
R17406 VSS.n2521 VSS.n2518 1.19675
R17407 VSS.n1889 VSS.n1888 1.19675
R17408 VSS.n5983 VSS.n5982 1.19675
R17409 VSS.n5912 VSS.n5909 1.19675
R17410 VSS.n5842 VSS.n5839 1.19675
R17411 VSS.n5632 VSS.n5629 1.19675
R17412 VSS.n5701 VSS.n5698 1.19675
R17413 VSS.n5727 VSS.n5724 1.19675
R17414 VSS.n585 VSS.n584 1.19675
R17415 VSS.n5816 VSS.n5813 1.19675
R17416 VSS.n5315 VSS.n5312 1.19675
R17417 VSS.n5807 VSS.n5806 1.19675
R17418 VSS.n727 VSS.n726 1.19675
R17419 VSS.n5801 VSS.n5800 1.19675
R17420 VSS.n4894 VSS.n4891 1.19675
R17421 VSS.n5339 VSS.n5336 1.19675
R17422 VSS.n5607 VSS.n5604 1.19675
R17423 VSS.n5574 VSS.n5571 1.19675
R17424 VSS.n5598 VSS.n5597 1.19675
R17425 VSS.n818 VSS.n815 1.19675
R17426 VSS.n810 VSS.n809 1.19675
R17427 VSS.n802 VSS.n801 1.19675
R17428 VSS.n5452 VSS.n5449 1.19675
R17429 VSS.n1763 VSS.n1760 1.19675
R17430 VSS.n4113 VSS.n4110 1.19675
R17431 VSS.n1368 VSS.n1365 1.19675
R17432 VSS.n1374 VSS.n1371 1.19675
R17433 VSS.n1614 VSS.n1611 1.19675
R17434 VSS.n1688 VSS.n1685 1.19675
R17435 VSS.n1202 VSS.n1201 1.19675
R17436 VSS.n1961 VSS.n1958 1.19675
R17437 VSS.n1979 VSS.n1978 1.19675
R17438 VSS.n1974 VSS.n1973 1.19675
R17439 VSS.n3581 VSS.n3580 1.19675
R17440 VSS.t278 VSS.n1212 1.19548
R17441 VSS.t127 VSS.n742 1.19548
R17442 VSS.t147 VSS.n668 1.19548
R17443 VSS.t246 VSS.n499 1.19548
R17444 VSS.t301 VSS.n1291 1.19548
R17445 VSS.t4067 VSS.n1926 1.18067
R17446 VSS.t141 VSS.t187 1.18067
R17447 VSS.n5345 VSS.n5344 1.17676
R17448 VSS.n6026 VSS.n135 1.17676
R17449 VSS.n6221 VSS.n6220 1.17676
R17450 VSS.n5444 VSS.n1124 1.17676
R17451 VSS.n3082 VSS.n3002 1.17676
R17452 VSS.n3001 VSS.n1831 1.17676
R17453 VSS.n3613 VSS.n1834 1.17676
R17454 VSS.n5343 VSS.n1121 1.17562
R17455 VSS.t190 VSS.t2368 1.15416
R17456 VSS.n6117 VSS.n365 1.12607
R17457 VSS.n6128 VSS.n347 1.12596
R17458 VSS.n6146 VSS.n6145 1.12536
R17459 VSS.t2238 VSS.n2289 1.11116
R17460 VSS.t2238 VSS.n2293 1.11116
R17461 VSS.t2238 VSS.n2294 1.11116
R17462 VSS.t2238 VSS.n2298 1.11116
R17463 VSS.n3502 VSS.t2210 1.11116
R17464 VSS.n3509 VSS.t2210 1.11116
R17465 VSS.t2210 VSS.n2246 1.11116
R17466 VSS.t2210 VSS.n2250 1.11116
R17467 VSS.t2182 VSS.n3049 1.11116
R17468 VSS.t2182 VSS.n3053 1.11116
R17469 VSS.t2182 VSS.n3054 1.11116
R17470 VSS.t2182 VSS.n3058 1.11116
R17471 VSS.t2154 VSS.n5411 1.11116
R17472 VSS.t2154 VSS.n5415 1.11116
R17473 VSS.t2154 VSS.n5416 1.11116
R17474 VSS.t2154 VSS.n5420 1.11116
R17475 VSS.t2126 VSS.n4828 1.11116
R17476 VSS.t2126 VSS.n4832 1.11116
R17477 VSS.t2126 VSS.n4833 1.11116
R17478 VSS.t2126 VSS.n4837 1.11116
R17479 VSS.n5364 VSS.t2098 1.11116
R17480 VSS.n5371 VSS.t2098 1.11116
R17481 VSS.t2098 VSS.n4787 1.11116
R17482 VSS.t2098 VSS.n4791 1.11116
R17483 VSS.t2070 VSS.n432 1.11116
R17484 VSS.t2070 VSS.n5999 1.11116
R17485 VSS.t2070 VSS.n6003 1.11116
R17486 VSS.n3558 VSS.n2121 1.10813
R17487 VSS.t1166 VSS.t2408 1.04193
R17488 VSS.t1165 VSS.t2405 1.04193
R17489 VSS.n1205 VSS.n1204 1.02614
R17490 VSS.n1687 VSS.n1199 1.02614
R17491 VSS.n1613 VSS.n1198 1.02614
R17492 VSS.n1373 VSS.n1197 1.02614
R17493 VSS.n1367 VSS.n1196 1.02614
R17494 VSS.n4112 VSS.n1195 1.02614
R17495 VSS.n1762 VSS.n1194 1.02614
R17496 VSS.n5451 VSS.n807 1.02614
R17497 VSS.n805 VSS.n804 1.02614
R17498 VSS.n813 VSS.n812 1.02614
R17499 VSS.n817 VSS.n799 1.02614
R17500 VSS.n5601 VSS.n5600 1.02614
R17501 VSS.n5573 VSS.n798 1.02614
R17502 VSS.n5606 VSS.n5603 1.02614
R17503 VSS.n5338 VSS.n733 1.02614
R17504 VSS.n4893 VSS.n731 1.02614
R17505 VSS.n5804 VSS.n5803 1.02614
R17506 VSS.n730 VSS.n729 1.02614
R17507 VSS.n5810 VSS.n5809 1.02614
R17508 VSS.n5314 VSS.n724 1.02614
R17509 VSS.n5815 VSS.n5812 1.02614
R17510 VSS.n588 VSS.n587 1.02614
R17511 VSS.n5726 VSS.n581 1.02614
R17512 VSS.n5700 VSS.n589 1.02614
R17513 VSS.n5631 VSS.n580 1.02614
R17514 VSS.n5841 VSS.n590 1.02614
R17515 VSS.n5911 VSS.n579 1.02614
R17516 VSS.n5987 VSS.n5985 1.02614
R17517 VSS.n1892 VSS.n1891 1.02614
R17518 VSS.n2520 VSS.n1893 1.02614
R17519 VSS.n3333 VSS.n1894 1.02614
R17520 VSS.n3406 VSS.n1895 1.02614
R17521 VSS.n2446 VSS.n1896 1.02614
R17522 VSS.n2373 VSS.n1897 1.02614
R17523 VSS.n3599 VSS.n1907 1.02614
R17524 VSS.n3620 VSS.n1829 1.02614
R17525 VSS.n4003 VSS.n4002 1.02614
R17526 VSS.n3323 VSS.n1827 1.02614
R17527 VSS.n4014 VSS.n4011 1.02614
R17528 VSS.n3974 VSS.n1826 1.02614
R17529 VSS.n4009 VSS.n4008 1.02614
R17530 VSS.n2156 VSS.n2155 1.02614
R17531 VSS.n3545 VSS.n3542 1.02614
R17532 VSS.n3086 VSS.n1351 1.02614
R17533 VSS.n2851 VSS.n1349 1.02614
R17534 VSS.n2845 VSS.n1352 1.02614
R17535 VSS.n3157 VSS.n1348 1.02614
R17536 VSS.n4144 VSS.n4143 1.02614
R17537 VSS.n1358 VSS.n1347 1.02614
R17538 VSS.n4149 VSS.n4146 1.02614
R17539 VSS.n2219 VSS.n2218 1.02614
R17540 VSS.n4199 VSS.n4196 1.02614
R17541 VSS.n5401 VSS.n5399 1.02614
R17542 VSS.n1175 VSS.n1174 1.02614
R17543 VSS.n4754 VSS.n4753 1.02614
R17544 VSS.t2890 VSS.t3159 1.01015
R17545 VSS.t2889 VSS.t3156 1.01015
R17546 VSS.n5448 VSS.n5447 1.0005
R17547 VSS.n5342 VSS.n383 1.0005
R17548 VSS.n6028 VSS.n6027 1.0005
R17549 VSS.n6029 VSS.n134 1.0005
R17550 VSS.n5446 VSS.n5445 1.0005
R17551 VSS.n1617 VSS.n736 1.0005
R17552 VSS.n5628 VSS.n5627 1.0005
R17553 VSS.n5797 VSS.n5796 1.0005
R17554 VSS.n5795 VSS.n5794 1.0005
R17555 VSS.n365 VSS.n238 1.0005
R17556 VSS.n3320 VSS.n3319 1.0005
R17557 VSS.n3083 VSS.n1122 1.0005
R17558 VSS.n4137 VSS.n4136 1.0005
R17559 VSS.n4135 VSS.n4134 1.0005
R17560 VSS.n5594 VSS.n662 1.0005
R17561 VSS.n5836 VSS.n5835 1.0005
R17562 VSS.n5838 VSS.n5837 1.0005
R17563 VSS.n4518 VSS.n347 1.0005
R17564 VSS.n1819 VSS.n1364 1.0005
R17565 VSS.n3328 VSS.n3327 1.0005
R17566 VSS.n3617 VSS.n3616 1.0005
R17567 VSS.n4037 VSS.n4036 1.0005
R17568 VSS.n4038 VSS.n1341 1.0005
R17569 VSS.n4042 VSS.n4041 1.0005
R17570 VSS.n4040 VSS.n792 1.0005
R17571 VSS.n4039 VSS.n718 1.0005
R17572 VSS.n5979 VSS.n327 1.0005
R17573 VSS.n6147 VSS.n6146 1.0005
R17574 VSS.n2367 VSS.n1766 1.0005
R17575 VSS.n2597 VSS.n2450 1.0005
R17576 VSS.n3330 VSS.n3329 1.0005
R17577 VSS.n3615 VSS.n3614 1.0005
R17578 VSS.n3560 VSS.n3559 1.0005
R17579 VSS.n2130 VSS.n2119 1.0005
R17580 VSS.n2127 VSS.n2126 1.0005
R17581 VSS.n1183 VSS.n1180 1.0005
R17582 VSS.n4209 VSS.n4208 1.0005
R17583 VSS.n4742 VSS.n4741 1.0005
R17584 VSS.n4740 VSS.n1177 1.0005
R17585 VSS.n4739 VSS.n1 1.0005
R17586 VSS.t2977 VSS.n2047 0.975974
R17587 VSS.n3597 VSS.n3596 0.961884
R17588 VSS.n31 VSS.t342 0.950803
R17589 VSS.t1211 VSS.n38 0.950803
R17590 VSS.t1118 VSS.t2278 0.896736
R17591 VSS.t1117 VSS.t2275 0.896736
R17592 VSS.t1222 VSS.t3124 0.896736
R17593 VSS.t1221 VSS.t3121 0.896736
R17594 VSS.t1214 VSS.t2262 0.896736
R17595 VSS.t1213 VSS.t2259 0.896736
R17596 VSS.t1206 VSS.t2353 0.896736
R17597 VSS.t1205 VSS.t2350 0.896736
R17598 VSS.t1171 VSS.t2337 0.896736
R17599 VSS.t1170 VSS.t2334 0.896736
R17600 VSS.t3249 VSS.n5968 0.884415
R17601 VSS.t3649 VSS.n5898 0.884415
R17602 VSS.t2447 VSS.n651 0.884415
R17603 VSS.t1318 VSS.n5689 0.884415
R17604 VSS.t1567 VSS.n5783 0.884415
R17605 VSS.t1828 VSS.n480 0.884415
R17606 VSS.t2423 VSS.n554 0.884415
R17607 VSS.t2238 VSS.n2297 0.884415
R17608 VSS.t2210 VSS.n2249 0.884415
R17609 VSS.t2182 VSS.n3057 0.884415
R17610 VSS.t2154 VSS.n5419 0.884415
R17611 VSS.t2126 VSS.n4836 0.884415
R17612 VSS.t2098 VSS.n4790 0.884415
R17613 VSS.t2070 VSS.n6002 0.884415
R17614 VSS.t2042 VSS.n119 0.884415
R17615 VSS.t1798 VSS.n294 0.884415
R17616 VSS.t1538 VSS.n219 0.884415
R17617 VSS.t1280 VSS.n4457 0.884415
R17618 VSS.t3387 VSS.n4505 0.884415
R17619 VSS.t2858 VSS.n4330 0.884415
R17620 VSS.t2981 VSS.n4581 0.884415
R17621 VSS.t3635 VSS.n4283 0.882808
R17622 VSS.t2658 VSS.n3934 0.882808
R17623 VSS.t1449 VSS.n3867 0.882808
R17624 VSS.t1963 VSS.n3660 0.882808
R17625 VSS.t1704 VSS.n3800 0.882808
R17626 VSS.t1148 VSS.n3752 0.882808
R17627 VSS.t3263 VSS.n3704 0.882808
R17628 VSS.t1184 VSS.n2328 0.882808
R17629 VSS.t1730 VSS.n2559 0.882808
R17630 VSS.t3353 VSS.n5206 0.882808
R17631 VSS.t3402 VSS.n5158 0.882808
R17632 VSS.t1595 VSS.n5091 0.882808
R17633 VSS.t1855 VSS.n4933 0.882808
R17634 VSS.t1343 VSS.n5024 0.882808
R17635 VSS.t2770 VSS.n5280 0.882808
R17636 VSS.t3645 VSS.n5532 0.882808
R17637 VSS.t46 VSS.n857 0.882808
R17638 VSS.t1622 VSS.n5484 0.882808
R17639 VSS.t1881 VSS.n1082 0.882808
R17640 VSS.t1367 VSS.n1014 0.882808
R17641 VSS.t3457 VSS.n947 0.882808
R17642 VSS.t2295 VSS.n1721 0.882808
R17643 VSS.t74 VSS.n1413 0.882808
R17644 VSS.t1648 VSS.n1506 0.882808
R17645 VSS.t1909 VSS.n1654 0.882808
R17646 VSS.t1395 VSS.n1579 0.882808
R17647 VSS.t2945 VSS.n4079 0.882808
R17648 VSS.t3279 VSS.n4180 0.882808
R17649 VSS.t1104 VSS.n2953 0.882808
R17650 VSS.t1676 VSS.n3306 0.882808
R17651 VSS.t1936 VSS.n3107 0.882808
R17652 VSS.t1421 VSS.n3178 0.882808
R17653 VSS.t3653 VSS.n3242 0.882808
R17654 VSS.t2555 VSS.n3287 0.882808
R17655 VSS.t2958 VSS.n1476 0.882808
R17656 VSS.t3118 VSS.n920 0.882808
R17657 VSS.t2612 VSS.n4996 0.882808
R17658 VSS.t1994 VSS.n2487 0.882808
R17659 VSS.t1479 VSS.n3373 0.882808
R17660 VSS.t2256 VSS.n2413 0.882808
R17661 VSS.t3237 VSS.n3458 0.882808
R17662 VSS.t2627 VSS.n2207 0.882808
R17663 VSS.t199 VSS.n1908 0.865746
R17664 VSS.n1920 VSS.t2299 0.865746
R17665 VSS.t374 VSS.n1862 0.865746
R17666 VSS.t1231 VSS.n1842 0.865746
R17667 VSS.t116 VSS.n26 0.845214
R17668 VSS.n6030 VSS.n6029 0.832779
R17669 VSS.n4283 VSS.n4281 0.825372
R17670 VSS.n3934 VSS.n3932 0.825372
R17671 VSS.n3867 VSS.n3865 0.825372
R17672 VSS.n3660 VSS.n3658 0.825372
R17673 VSS.n3800 VSS.n3798 0.825372
R17674 VSS.n3752 VSS.n3750 0.825372
R17675 VSS.n3704 VSS.n3702 0.825372
R17676 VSS.n2328 VSS.n2326 0.825372
R17677 VSS.n2559 VSS.n2557 0.825372
R17678 VSS.n5206 VSS.n5204 0.825372
R17679 VSS.n5158 VSS.n5156 0.825372
R17680 VSS.n5091 VSS.n5089 0.825372
R17681 VSS.n4933 VSS.n4931 0.825372
R17682 VSS.n5024 VSS.n5022 0.825372
R17683 VSS.n5280 VSS.n5278 0.825372
R17684 VSS.n5532 VSS.n5530 0.825372
R17685 VSS.n857 VSS.n855 0.825372
R17686 VSS.n5484 VSS.n5482 0.825372
R17687 VSS.n1082 VSS.n1080 0.825372
R17688 VSS.n1014 VSS.n1012 0.825372
R17689 VSS.n947 VSS.n945 0.825372
R17690 VSS.n1721 VSS.n1719 0.825372
R17691 VSS.n1413 VSS.n1411 0.825372
R17692 VSS.n1506 VSS.n1504 0.825372
R17693 VSS.n1654 VSS.n1652 0.825372
R17694 VSS.n1579 VSS.n1577 0.825372
R17695 VSS.n4079 VSS.n4077 0.825372
R17696 VSS.n4180 VSS.n4178 0.825372
R17697 VSS.n2953 VSS.n2951 0.825372
R17698 VSS.n3306 VSS.n3304 0.825372
R17699 VSS.n3107 VSS.n3105 0.825372
R17700 VSS.n3178 VSS.n3176 0.825372
R17701 VSS.n3242 VSS.n3240 0.825372
R17702 VSS.n3287 VSS.n3285 0.825372
R17703 VSS.n1476 VSS.n1474 0.825372
R17704 VSS.n920 VSS.n918 0.825372
R17705 VSS.n4996 VSS.n4994 0.825372
R17706 VSS.n2487 VSS.n2485 0.825372
R17707 VSS.n3373 VSS.n3371 0.825372
R17708 VSS.n2413 VSS.n2411 0.825372
R17709 VSS.n3458 VSS.n3456 0.825372
R17710 VSS.n2207 VSS.n2205 0.825372
R17711 VSS.n4581 VSS.n4580 0.823515
R17712 VSS.n4330 VSS.n4329 0.823515
R17713 VSS.n4505 VSS.n4504 0.823515
R17714 VSS.n4457 VSS.n4456 0.823515
R17715 VSS.n219 VSS.n218 0.823515
R17716 VSS.n294 VSS.n293 0.823515
R17717 VSS.n119 VSS.n118 0.823515
R17718 VSS.n2297 VSS.n2296 0.823515
R17719 VSS.n4790 VSS.n4789 0.823515
R17720 VSS.n4836 VSS.n4835 0.823515
R17721 VSS.n5419 VSS.n5418 0.823515
R17722 VSS.n3057 VSS.n3056 0.823515
R17723 VSS.n2249 VSS.n2248 0.823515
R17724 VSS.n5968 VSS.n5967 0.823515
R17725 VSS.n5898 VSS.n5897 0.823515
R17726 VSS.n651 VSS.n650 0.823515
R17727 VSS.n5689 VSS.n5688 0.823515
R17728 VSS.n5783 VSS.n5782 0.823515
R17729 VSS.n480 VSS.n479 0.823515
R17730 VSS.n6002 VSS.n6001 0.823515
R17731 VSS.n554 VSS.n553 0.823515
R17732 VSS.n4581 VSS.n4579 0.816709
R17733 VSS.n4330 VSS.n4328 0.816709
R17734 VSS.n4505 VSS.n4503 0.816709
R17735 VSS.n4457 VSS.n4455 0.816709
R17736 VSS.n219 VSS.n217 0.816709
R17737 VSS.n294 VSS.n292 0.816709
R17738 VSS.n119 VSS.n117 0.816709
R17739 VSS.n2297 VSS.n2295 0.816709
R17740 VSS.n4790 VSS.n4788 0.816709
R17741 VSS.n4836 VSS.n4834 0.816709
R17742 VSS.n5419 VSS.n5417 0.816709
R17743 VSS.n3057 VSS.n3055 0.816709
R17744 VSS.n2249 VSS.n2247 0.816709
R17745 VSS.n5968 VSS.n5966 0.816709
R17746 VSS.n5898 VSS.n5896 0.816709
R17747 VSS.n651 VSS.n649 0.816709
R17748 VSS.n5689 VSS.n5687 0.816709
R17749 VSS.n5783 VSS.n5781 0.816709
R17750 VSS.n480 VSS.n478 0.816709
R17751 VSS.n6002 VSS.n6000 0.816709
R17752 VSS.n554 VSS.n552 0.816709
R17753 VSS.n4283 VSS.n4282 0.813913
R17754 VSS.n3934 VSS.n3933 0.813913
R17755 VSS.n3867 VSS.n3866 0.813913
R17756 VSS.n3660 VSS.n3659 0.813913
R17757 VSS.n3800 VSS.n3799 0.813913
R17758 VSS.n3752 VSS.n3751 0.813913
R17759 VSS.n3704 VSS.n3703 0.813913
R17760 VSS.n2328 VSS.n2327 0.813913
R17761 VSS.n2559 VSS.n2558 0.813913
R17762 VSS.n5206 VSS.n5205 0.813913
R17763 VSS.n5158 VSS.n5157 0.813913
R17764 VSS.n5091 VSS.n5090 0.813913
R17765 VSS.n4933 VSS.n4932 0.813913
R17766 VSS.n5024 VSS.n5023 0.813913
R17767 VSS.n5280 VSS.n5279 0.813913
R17768 VSS.n5532 VSS.n5531 0.813913
R17769 VSS.n857 VSS.n856 0.813913
R17770 VSS.n5484 VSS.n5483 0.813913
R17771 VSS.n1082 VSS.n1081 0.813913
R17772 VSS.n1014 VSS.n1013 0.813913
R17773 VSS.n947 VSS.n946 0.813913
R17774 VSS.n1721 VSS.n1720 0.813913
R17775 VSS.n1413 VSS.n1412 0.813913
R17776 VSS.n1506 VSS.n1505 0.813913
R17777 VSS.n1654 VSS.n1653 0.813913
R17778 VSS.n1579 VSS.n1578 0.813913
R17779 VSS.n4079 VSS.n4078 0.813913
R17780 VSS.n4180 VSS.n4179 0.813913
R17781 VSS.n2953 VSS.n2952 0.813913
R17782 VSS.n3306 VSS.n3305 0.813913
R17783 VSS.n3107 VSS.n3106 0.813913
R17784 VSS.n3178 VSS.n3177 0.813913
R17785 VSS.n3242 VSS.n3241 0.813913
R17786 VSS.n3287 VSS.n3286 0.813913
R17787 VSS.n1476 VSS.n1475 0.813913
R17788 VSS.n920 VSS.n919 0.813913
R17789 VSS.n4996 VSS.n4995 0.813913
R17790 VSS.n2487 VSS.n2486 0.813913
R17791 VSS.n3373 VSS.n3372 0.813913
R17792 VSS.n2413 VSS.n2412 0.813913
R17793 VSS.n3458 VSS.n3457 0.813913
R17794 VSS.n2207 VSS.n2206 0.813913
R17795 VSS.n3616 VSS.n1122 0.772656
R17796 VSS.n4038 VSS.n4037 0.772538
R17797 VSS.n5795 VSS.n365 0.772419
R17798 VSS.n4136 VSS.n1364 0.772301
R17799 VSS.n5837 VSS.n347 0.772301
R17800 VSS.n2126 VSS.n1180 0.772183
R17801 VSS.n2126 VSS.n2119 0.772065
R17802 VSS.n1174 VSS.n1172 0.771732
R17803 VSS.n5399 VSS.n5397 0.771732
R17804 VSS.n4200 VSS.n4199 0.771732
R17805 VSS.n2218 VSS.n2216 0.771732
R17806 VSS.n4150 VSS.n4149 0.771732
R17807 VSS.n1359 VSS.n1358 0.771732
R17808 VSS.n4143 VSS.n4141 0.771732
R17809 VSS.n3158 VSS.n3157 0.771732
R17810 VSS.n2846 VSS.n2845 0.771732
R17811 VSS.n2852 VSS.n2851 0.771732
R17812 VSS.n3087 VSS.n3086 0.771732
R17813 VSS.n3546 VSS.n3545 0.771732
R17814 VSS.n2155 VSS.n2153 0.771732
R17815 VSS.n4008 VSS.n4006 0.771732
R17816 VSS.n3975 VSS.n3974 0.771732
R17817 VSS.n4015 VSS.n4014 0.771732
R17818 VSS.n3324 VSS.n3323 0.771732
R17819 VSS.n4002 VSS.n4000 0.771732
R17820 VSS.n3621 VSS.n3620 0.771732
R17821 VSS.n1907 VSS.n1905 0.771732
R17822 VSS.n2374 VSS.n2373 0.771732
R17823 VSS.n2447 VSS.n2446 0.771732
R17824 VSS.n3407 VSS.n3406 0.771732
R17825 VSS.n3334 VSS.n3333 0.771732
R17826 VSS.n2521 VSS.n2520 0.771732
R17827 VSS.n1891 VSS.n1889 0.771732
R17828 VSS.n4753 VSS.n4751 0.771732
R17829 VSS.n5985 VSS.n5983 0.771732
R17830 VSS.n5912 VSS.n5911 0.771732
R17831 VSS.n5842 VSS.n5841 0.771732
R17832 VSS.n5632 VSS.n5631 0.771732
R17833 VSS.n5701 VSS.n5700 0.771732
R17834 VSS.n5727 VSS.n5726 0.771732
R17835 VSS.n587 VSS.n585 0.771732
R17836 VSS.n5816 VSS.n5815 0.771732
R17837 VSS.n5315 VSS.n5314 0.771732
R17838 VSS.n5809 VSS.n5807 0.771732
R17839 VSS.n729 VSS.n727 0.771732
R17840 VSS.n5803 VSS.n5801 0.771732
R17841 VSS.n4894 VSS.n4893 0.771732
R17842 VSS.n5339 VSS.n5338 0.771732
R17843 VSS.n5607 VSS.n5606 0.771732
R17844 VSS.n5574 VSS.n5573 0.771732
R17845 VSS.n5600 VSS.n5598 0.771732
R17846 VSS.n818 VSS.n817 0.771732
R17847 VSS.n812 VSS.n810 0.771732
R17848 VSS.n804 VSS.n802 0.771732
R17849 VSS.n5452 VSS.n5451 0.771732
R17850 VSS.n1763 VSS.n1762 0.771732
R17851 VSS.n4113 VSS.n4112 0.771732
R17852 VSS.n1368 VSS.n1367 0.771732
R17853 VSS.n1374 VSS.n1373 0.771732
R17854 VSS.n1614 VSS.n1613 0.771732
R17855 VSS.n1688 VSS.n1687 0.771732
R17856 VSS.n1204 VSS.n1202 0.771732
R17857 VSS.n5447 VSS.n383 0.771711
R17858 VSS.n5447 VSS.n5446 0.771593
R17859 VSS.n6029 VSS.n6028 0.771593
R17860 VSS.n3320 VSS.n736 0.771475
R17861 VSS.n6146 VSS.n327 0.771475
R17862 VSS.n4041 VSS.n4040 0.771356
R17863 VSS.n3328 VSS.n3320 0.771002
R17864 VSS.n4135 VSS.n662 0.771002
R17865 VSS.n5796 VSS.n5628 0.770648
R17866 VSS.n5837 VSS.n5836 0.77053
R17867 VSS.n4741 VSS.n4740 0.77053
R17868 VSS.n5628 VSS.n736 0.770293
R17869 VSS.n4040 VSS.n4039 0.770293
R17870 VSS.n2597 VSS.n1364 0.770175
R17871 VSS.n4136 VSS.n4135 0.770175
R17872 VSS.n4041 VSS.n4038 0.770175
R17873 VSS.n3560 VSS.n2119 0.769821
R17874 VSS.n4741 VSS.n4209 0.769703
R17875 VSS.t423 VSS.n1838 0.769608
R17876 VSS.n1919 VSS.n1899 0.769608
R17877 VSS.n5446 VSS.n1122 0.769348
R17878 VSS.n4740 VSS.n4739 0.76923
R17879 VSS.n4037 VSS.n1766 0.769112
R17880 VSS.n3616 VSS.n3615 0.768758
R17881 VSS.n3329 VSS.n3328 0.76864
R17882 VSS.n4209 VSS.n1180 0.76864
R17883 VSS.n5836 VSS.n662 0.768167
R17884 VSS.n4039 VSS.n327 0.768049
R17885 VSS.n5796 VSS.n5795 0.767458
R17886 VSS.n6028 VSS.n383 0.76734
R17887 VSS.n1960 VSS.n1959 0.7661
R17888 VSS.n3582 VSS.n3579 0.7661
R17889 VSS.n4588 VSS.n4587 0.76585
R17890 VSS.n4337 VSS.n4336 0.76585
R17891 VSS.n4366 VSS.n4365 0.76585
R17892 VSS.n4464 VSS.n4463 0.76585
R17893 VSS.n226 VSS.n225 0.76585
R17894 VSS.n240 VSS.n239 0.76585
R17895 VSS.n122 VSS.n121 0.76585
R17896 VSS.n32 VSS.n25 0.76585
R17897 VSS.n3960 VSS.n3959 0.76585
R17898 VSS.n3893 VSS.n3892 0.76585
R17899 VSS.n3625 VSS.n3624 0.76585
R17900 VSS.n3826 VSS.n3825 0.76585
R17901 VSS.n4025 VSS.n1810 0.76585
R17902 VSS.n1798 VSS.n1773 0.76585
R17903 VSS.n2354 VSS.n2353 0.76585
R17904 VSS.n2525 VSS.n2524 0.76585
R17905 VSS.n1864 VSS.n1839 0.76585
R17906 VSS.n5354 VSS.n4877 0.76585
R17907 VSS.n4867 VSS.n4844 0.76585
R17908 VSS.n5436 VSS.n1129 0.76585
R17909 VSS.n3074 VSS.n3007 0.76585
R17910 VSS.n3492 VSS.n3469 0.76585
R17911 VSS.n5916 VSS.n5915 0.76585
R17912 VSS.n5846 VSS.n5845 0.76585
R17913 VSS.n599 VSS.n598 0.76585
R17914 VSS.n5636 VSS.n5635 0.76585
R17915 VSS.n5731 VSS.n5730 0.76585
R17916 VSS.n5705 VSS.n5704 0.76585
R17917 VSS.n6017 VSS.n389 0.76585
R17918 VSS.n573 VSS.n500 0.76585
R17919 VSS.n5232 VSS.n5231 0.76585
R17920 VSS.n695 VSS.n669 0.76585
R17921 VSS.n5117 VSS.n5116 0.76585
R17922 VSS.n4898 VSS.n4897 0.76585
R17923 VSS.n5050 VSS.n5049 0.76585
R17924 VSS.n5246 VSS.n5245 0.76585
R17925 VSS.n5558 VSS.n5557 0.76585
R17926 VSS.n822 VSS.n821 0.76585
R17927 VSS.n768 VSS.n743 0.76585
R17928 VSS.n1108 VSS.n1107 0.76585
R17929 VSS.n1040 VSS.n1039 0.76585
R17930 VSS.n973 VSS.n972 0.76585
R17931 VSS.n1747 VSS.n1746 0.76585
R17932 VSS.n1378 VSS.n1377 0.76585
R17933 VSS.n1532 VSS.n1531 0.76585
R17934 VSS.n1619 VSS.n1618 0.76585
R17935 VSS.n1545 VSS.n1544 0.76585
R17936 VSS.n4044 VSS.n4043 0.76585
R17937 VSS.n1318 VSS.n1292 0.76585
R17938 VSS.n2924 VSS.n2923 0.76585
R17939 VSS.n2856 VSS.n2855 0.76585
R17940 VSS.n2988 VSS.n2987 0.76585
R17941 VSS.n3142 VSS.n3141 0.76585
R17942 VSS.n3213 VSS.n3212 0.76585
R17943 VSS.n4160 VSS.n1331 0.76585
R17944 VSS.n1249 VSS.n1213 0.76585
R17945 VSS.n5616 VSS.n781 0.76585
R17946 VSS.n5826 VSS.n708 0.76585
R17947 VSS.n2452 VSS.n2451 0.76585
R17948 VSS.n3338 VSS.n3337 0.76585
R17949 VSS.n2378 VSS.n2377 0.76585
R17950 VSS.n3604 VSS.n1876 0.76585
R17951 VSS.n3534 VSS.n2157 0.76585
R17952 VSS.n3523 VSS.n2219 0.757502
R17953 VSS.n4196 VSS.n1185 0.757502
R17954 VSS.n5401 VSS.n1165 0.757502
R17955 VSS.n5390 VSS.n1175 0.757502
R17956 VSS.n5378 VSS.n4754 0.757502
R17957 VSS.n4701 VSS.n4212 0.735789
R17958 VSS.n2117 VSS.n2115 0.729713
R17959 VSS.n4737 VSS.n4736 0.726011
R17960 VSS.n1936 VSS.n1933 0.718937
R17961 VSS.n3588 VSS.n3587 0.718937
R17962 VSS.n4603 VSS.n4586 0.718592
R17963 VSS.n4531 VSS.n4335 0.718592
R17964 VSS.n4514 VSS.n4379 0.718592
R17965 VSS.n4487 VSS.n4462 0.718592
R17966 VSS.n6167 VSS.n224 0.718592
R17967 VSS.n303 VSS.n252 0.718592
R17968 VSS.n6225 VSS.n120 0.718592
R17969 VSS.n59 VSS.n58 0.718592
R17970 VSS.n3982 VSS.n3958 0.718592
R17971 VSS.n3908 VSS.n3891 0.718592
R17972 VSS.n3993 VSS.n3638 0.718592
R17973 VSS.n3841 VSS.n3824 0.718592
R17974 VSS.n1816 VSS.n1815 0.718592
R17975 VSS.n1771 VSS.n1770 0.718592
R17976 VSS.n3413 VSS.n2352 0.718592
R17977 VSS.n2586 VSS.n2537 0.718592
R17978 VSS.n1837 VSS.n1836 0.718592
R17979 VSS.n4888 VSS.n4887 0.718592
R17980 VSS.n4855 VSS.n4854 0.718592
R17981 VSS.n1127 VSS.n1126 0.718592
R17982 VSS.n3005 VSS.n3004 0.718592
R17983 VSS.n3480 VSS.n3479 0.718592
R17984 VSS.n5974 VSS.n5928 0.718592
R17985 VSS.n5904 VSS.n5858 0.718592
R17986 VSS.n657 VSS.n611 0.718592
R17987 VSS.n5695 VSS.n5649 0.718592
R17988 VSS.n5789 VSS.n5743 0.718592
R17989 VSS.n5719 VSS.n5717 0.718592
R17990 VSS.n387 VSS.n386 0.718592
R17991 VSS.n514 VSS.n513 0.718592
R17992 VSS.n5321 VSS.n5230 0.718592
R17993 VSS.n667 VSS.n666 0.718592
R17994 VSS.n5132 VSS.n5115 0.718592
R17995 VSS.n5332 VSS.n4911 0.718592
R17996 VSS.n5065 VSS.n5048 0.718592
R17997 VSS.n5307 VSS.n5258 0.718592
R17998 VSS.n5580 VSS.n5556 0.718592
R17999 VSS.n5591 VSS.n835 0.718592
R18000 VSS.n741 VSS.n740 0.718592
R18001 VSS.n5458 VSS.n1106 0.718592
R18002 VSS.n1056 VSS.n1038 0.718592
R18003 VSS.n988 VSS.n971 0.718592
R18004 VSS.n4119 VSS.n1745 0.718592
R18005 VSS.n4130 VSS.n1391 0.718592
R18006 VSS.n1695 VSS.n1530 0.718592
R18007 VSS.n1681 VSS.n1632 0.718592
R18008 VSS.n1606 VSS.n1557 0.718592
R18009 VSS.n4106 VSS.n4057 0.718592
R18010 VSS.n1290 VSS.n1289 0.718592
R18011 VSS.n2939 VSS.n2922 0.718592
R18012 VSS.n3314 VSS.n2868 0.718592
R18013 VSS.n3093 VSS.n2986 0.718592
R18014 VSS.n3164 VSS.n3140 0.718592
R18015 VSS.n3228 VSS.n3211 0.718592
R18016 VSS.n1337 VSS.n1336 0.718592
R18017 VSS.n1227 VSS.n1226 0.718592
R18018 VSS.n787 VSS.n786 0.718592
R18019 VSS.n714 VSS.n713 0.718592
R18020 VSS.n2514 VSS.n2465 0.718592
R18021 VSS.n3400 VSS.n3351 0.718592
R18022 VSS.n2440 VSS.n2391 0.718592
R18023 VSS.n1883 VSS.n1882 0.718592
R18024 VSS.n2166 VSS.n2165 0.718592
R18025 VSS.n4747 VSS.n1177 0.696287
R18026 VSS.n4743 VSS.n4742 0.691007
R18027 VSS.n4203 VSS.n1183 0.691007
R18028 VSS.n3549 VSS.n2130 0.691007
R18029 VSS.n4208 VSS.n4207 0.68514
R18030 VSS.t2940 VSS.n2009 0.68391
R18031 VSS.n2066 VSS.t2940 0.68391
R18032 VSS.n3559 VSS.n3558 0.682207
R18033 VSS.n3512 VSS.n2219 0.679674
R18034 VSS.n4196 VSS.n1190 0.679674
R18035 VSS.n5401 VSS.n5391 0.679674
R18036 VSS.n5379 VSS.n1175 0.679674
R18037 VSS.n4754 VSS.n6 0.679674
R18038 VSS.n2127 VSS.n2125 0.679567
R18039 VSS.n4700 VSS.n4699 0.676505
R18040 VSS.n3598 VSS.t3329 0.673469
R18041 VSS.n1916 VSS.t1230 0.673469
R18042 VSS.n6246 VSS.n1 0.6649
R18043 VSS.n6194 VSS.n6183 0.649813
R18044 VSS.n6194 VSS.n6179 0.649813
R18045 VSS.n171 VSS.n156 0.649813
R18046 VSS.n172 VSS.n171 0.649813
R18047 VSS.n4732 VSS.n4227 0.649813
R18048 VSS.n4732 VSS.n4232 0.649813
R18049 VSS.n3572 VSS.n1985 0.649813
R18050 VSS.t2905 VSS.t1198 0.634035
R18051 VSS.t1197 VSS.t2902 0.634035
R18052 VSS.n6151 VSS.n6150 0.632703
R18053 VSS.n4354 VSS.n4353 0.632703
R18054 VSS.n4524 VSS.n4523 0.632703
R18055 VSS.n4362 VSS.n4361 0.632703
R18056 VSS.n4481 VSS.n4480 0.632703
R18057 VSS.n6160 VSS.n6159 0.632703
R18058 VSS.n318 VSS.n317 0.632703
R18059 VSS.n6243 VSS.n6242 0.632703
R18060 VSS.t157 VSS.t175 0.619503
R18061 VSS.t2595 VSS.t3443 0.619503
R18062 VSS.t2594 VSS.t3442 0.619503
R18063 VSS.t2599 VSS.t3077 0.619503
R18064 VSS.t2598 VSS.t3076 0.619503
R18065 VSS.t3075 VSS.t2597 0.619503
R18066 VSS.t3074 VSS.t2596 0.619503
R18067 VSS.t2593 VSS.t3441 0.619503
R18068 VSS.t3440 VSS.t2592 0.619503
R18069 VSS.n2080 VSS.n1966 0.619503
R18070 VSS.t160 VSS.t168 0.619503
R18071 VSS.n3572 VSS.n2068 0.615418
R18072 VSS.n3572 VSS.n2069 0.615418
R18073 VSS.n3329 VSS.n2842 0.610594
R18074 VSS.n2609 VSS.n1766 0.61024
R18075 VSS.n3615 VSS.n1832 0.609413
R18076 VSS.n2598 VSS.n2597 0.607995
R18077 VSS.t4126 VSS.n6236 0.599382
R18078 VSS.t4125 VSS.n7 0.599382
R18079 VSS.n3565 VSS.n2113 0.591781
R18080 VSS.n3565 VSS.n3564 0.591287
R18081 VSS.n6152 VSS.n6151 0.58636
R18082 VSS.n4353 VSS.n4352 0.58636
R18083 VSS.n4523 VSS.n4522 0.58636
R18084 VSS.n4361 VSS.n4360 0.58636
R18085 VSS.n4480 VSS.n4479 0.58636
R18086 VSS.n6159 VSS.n6158 0.58636
R18087 VSS.n319 VSS.n318 0.58636
R18088 VSS.n6242 VSS.n6241 0.58636
R18089 VSS.t2369 VSS.t92 0.577331
R18090 VSS.t91 VSS.t2366 0.577331
R18091 VSS.n2007 VSS.n2006 0.531978
R18092 VSS.t1167 VSS.n1775 0.521213
R18093 VSS.n1795 VSS.t1166 0.521213
R18094 VSS.n6194 VSS.n6181 0.512117
R18095 VSS.n171 VSS.n154 0.512117
R18096 VSS.n4732 VSS.n4230 0.512117
R18097 VSS.t2891 VSS.n2134 0.505324
R18098 VSS.n2146 VSS.t2890 0.505324
R18099 VSS.n2114 VSS.n1910 0.504946
R18100 VSS.n4671 VSS.n4638 0.495465
R18101 VSS.n3564 VSS.n3562 0.495376
R18102 VSS.n3561 VSS.n2118 0.486213
R18103 VSS.n1974 VSS.n1970 0.481206
R18104 VSS.n3597 VSS.t2298 0.481192
R18105 VSS.n3581 VSS.n1953 0.48048
R18106 VSS.n6230 VSS.n16 0.460429
R18107 VSS.t1119 VSS.n1215 0.448618
R18108 VSS.n1245 VSS.t1118 0.448618
R18109 VSS.t1223 VSS.n745 0.448618
R18110 VSS.n765 VSS.t1222 0.448618
R18111 VSS.t1215 VSS.n671 0.448618
R18112 VSS.n692 VSS.t1214 0.448618
R18113 VSS.t1207 VSS.n502 0.448618
R18114 VSS.n570 VSS.t1206 0.448618
R18115 VSS.t1172 VSS.n1294 0.448618
R18116 VSS.n1315 VSS.t1171 0.448618
R18117 VSS.n3563 VSS.n1953 0.443256
R18118 VSS.n2112 VSS.n1970 0.439914
R18119 VSS.n6218 VSS.n137 0.432678
R18120 VSS VSS.n6248 0.430286
R18121 VSS.n3571 VSS.n3569 0.42425
R18122 VSS.n4748 VSS.n597 0.4229
R18123 VSS.n5914 VSS.n5908 0.4229
R18124 VSS.n5697 VSS.n5634 0.4229
R18125 VSS.n6245 VSS.n2 0.4229
R18126 VSS.n4527 VSS.n4356 0.4229
R18127 VSS.n4484 VSS.n4364 0.4229
R18128 VSS.n6162 VSS.n307 0.4229
R18129 VSS.n5819 VSS.n717 0.4229
R18130 VSS.n5317 VSS.n5311 0.4229
R18131 VSS.n734 VSS.n664 0.4229
R18132 VSS.n5335 VSS.n4896 0.4229
R18133 VSS.n5610 VSS.n791 0.4229
R18134 VSS.n5576 VSS.n814 0.4229
R18135 VSS.n1053 VSS.n820 0.4229
R18136 VSS.n5455 VSS.n738 0.4229
R18137 VSS.n4202 VSS.n1184 0.4229
R18138 VSS.n4115 VSS.n4109 0.4229
R18139 VSS.n1610 VSS.n1376 0.4229
R18140 VSS.n1690 VSS.n1684 0.4229
R18141 VSS.n4153 VSS.n1340 0.4229
R18142 VSS.n1362 VSS.n1361 0.4229
R18143 VSS.n3161 VSS.n3160 0.4229
R18144 VSS.n3090 VSS.n2854 0.4229
R18145 VSS.n3548 VSS.n2131 0.4229
R18146 VSS.n3978 VSS.n1768 0.4229
R18147 VSS.n4017 VSS.n1820 0.4229
R18148 VSS.n3997 VSS.n3996 0.4229
R18149 VSS.n2443 VSS.n2376 0.4229
R18150 VSS.n3409 VSS.n3403 0.4229
R18151 VSS.n2523 VSS.n2517 0.4229
R18152 VSS.n5729 VSS.n5723 0.422607
R18153 VSS.n2010 VSS.n2007 0.420912
R18154 VSS VSS.n6218 0.418989
R18155 VSS.n4571 VSS.n4560 0.408086
R18156 VSS.n4320 VSS.n4309 0.408086
R18157 VSS.n4411 VSS.n4400 0.408086
R18158 VSS.n4447 VSS.n4436 0.408086
R18159 VSS.n207 VSS.n197 0.408086
R18160 VSS.n283 VSS.n273 0.408086
R18161 VSS.n115 VSS.n110 0.408086
R18162 VSS.n4261 VSS.n4260 0.408086
R18163 VSS.n3925 VSS.n3924 0.408086
R18164 VSS.n3858 VSS.n3857 0.408086
R18165 VSS.n3651 VSS.n3650 0.408086
R18166 VSS.n3791 VSS.n3790 0.408086
R18167 VSS.n3743 VSS.n3742 0.408086
R18168 VSS.n3695 VSS.n3694 0.408086
R18169 VSS.n2319 VSS.n2318 0.408086
R18170 VSS.n2550 VSS.n2549 0.408086
R18171 VSS.n2287 VSS.n2274 0.408086
R18172 VSS.n4785 VSS.n4778 0.408086
R18173 VSS.n4826 VSS.n4815 0.408086
R18174 VSS.n5409 VSS.n1157 0.408086
R18175 VSS.n3047 VSS.n3035 0.408086
R18176 VSS.n2244 VSS.n2237 0.408086
R18177 VSS.n5958 VSS.n5948 0.408086
R18178 VSS.n5888 VSS.n5878 0.408086
R18179 VSS.n641 VSS.n631 0.408086
R18180 VSS.n5679 VSS.n5669 0.408086
R18181 VSS.n5773 VSS.n5763 0.408086
R18182 VSS.n470 VSS.n460 0.408086
R18183 VSS.n430 VSS.n419 0.408086
R18184 VSS.n544 VSS.n534 0.408086
R18185 VSS.n5197 VSS.n5196 0.408086
R18186 VSS.n5149 VSS.n5148 0.408086
R18187 VSS.n5082 VSS.n5081 0.408086
R18188 VSS.n4924 VSS.n4923 0.408086
R18189 VSS.n5015 VSS.n5014 0.408086
R18190 VSS.n5271 VSS.n5270 0.408086
R18191 VSS.n5523 VSS.n5522 0.408086
R18192 VSS.n848 VSS.n847 0.408086
R18193 VSS.n5475 VSS.n5474 0.408086
R18194 VSS.n1073 VSS.n1072 0.408086
R18195 VSS.n1005 VSS.n1004 0.408086
R18196 VSS.n938 VSS.n937 0.408086
R18197 VSS.n1712 VSS.n1711 0.408086
R18198 VSS.n1404 VSS.n1403 0.408086
R18199 VSS.n1497 VSS.n1496 0.408086
R18200 VSS.n1645 VSS.n1644 0.408086
R18201 VSS.n1570 VSS.n1569 0.408086
R18202 VSS.n4070 VSS.n4069 0.408086
R18203 VSS.n1278 VSS.n1277 0.408086
R18204 VSS.n2912 VSS.n2911 0.408086
R18205 VSS.n2886 VSS.n2885 0.408086
R18206 VSS.n2976 VSS.n2975 0.408086
R18207 VSS.n3130 VSS.n3129 0.408086
R18208 VSS.n3201 VSS.n3200 0.408086
R18209 VSS.n3265 VSS.n3264 0.408086
R18210 VSS.n1454 VSS.n1453 0.408086
R18211 VSS.n898 VSS.n897 0.408086
R18212 VSS.n4974 VSS.n4973 0.408086
R18213 VSS.n2478 VSS.n2477 0.408086
R18214 VSS.n3364 VSS.n3363 0.408086
R18215 VSS.n2404 VSS.n2403 0.408086
R18216 VSS.n3436 VSS.n3435 0.408086
R18217 VSS.n2185 VSS.n2184 0.408086
R18218 VSS.n4724 VSS 0.40425
R18219 VSS.n4216 VSS 0.402898
R18220 VSS.n5634 VSS.n661 0.399727
R18221 VSS.n5793 VSS.n5729 0.399727
R18222 VSS.n5980 VSS.n597 0.399433
R18223 VSS.n5978 VSS.n5914 0.399433
R18224 VSS.n5908 VSS.n5844 0.399433
R18225 VSS.n5703 VSS.n5697 0.399433
R18226 VSS.n5723 VSS.n384 0.399433
R18227 VSS.n6148 VSS.n2 0.399433
R18228 VSS.n4356 VSS.n326 0.399433
R18229 VSS.n4527 VSS.n4526 0.399433
R18230 VSS.n4517 VSS.n4364 0.399433
R18231 VSS.n4484 VSS.n4483 0.399433
R18232 VSS.n6163 VSS.n6162 0.399433
R18233 VSS.n315 VSS.n307 0.399433
R18234 VSS.n5318 VSS.n5317 0.399433
R18235 VSS.n5311 VSS.n663 0.399433
R18236 VSS.n5834 VSS.n664 0.399433
R18237 VSS.n5798 VSS.n734 0.399433
R18238 VSS.n4896 VSS.n735 0.399433
R18239 VSS.n5341 VSS.n5335 0.399433
R18240 VSS.n5610 VSS.n5609 0.399433
R18241 VSS.n5577 VSS.n5576 0.399433
R18242 VSS.n5595 VSS.n814 0.399433
R18243 VSS.n5593 VSS.n820 0.399433
R18244 VSS.n1053 VSS.n737 0.399433
R18245 VSS.n5626 VSS.n738 0.399433
R18246 VSS.n5455 VSS.n5454 0.399433
R18247 VSS.n1765 VSS.n1184 0.399433
R18248 VSS.n4116 VSS.n4115 0.399433
R18249 VSS.n4109 VSS.n1370 0.399433
R18250 VSS.n4133 VSS.n1376 0.399433
R18251 VSS.n1616 VSS.n1610 0.399433
R18252 VSS.n1691 VSS.n1690 0.399433
R18253 VSS.n1684 VSS.n1123 0.399433
R18254 VSS.n4153 VSS.n4152 0.399433
R18255 VSS.n1361 VSS.n1355 0.399433
R18256 VSS.n4138 VSS.n1362 0.399433
R18257 VSS.n3160 VSS.n1363 0.399433
R18258 VSS.n3318 VSS.n2854 0.399433
R18259 VSS.n3090 VSS.n3089 0.399433
R18260 VSS.n2131 VSS.n1767 0.399433
R18261 VSS.n4035 VSS.n1768 0.399433
R18262 VSS.n3978 VSS.n3977 0.399433
R18263 VSS.n4018 VSS.n4017 0.399433
R18264 VSS.n3326 VSS.n1820 0.399433
R18265 VSS.n3997 VSS.n1830 0.399433
R18266 VSS.n3996 VSS.n3623 0.399433
R18267 VSS.n2376 VSS.n2370 0.399433
R18268 VSS.n2449 VSS.n2443 0.399433
R18269 VSS.n3410 VSS.n3409 0.399433
R18270 VSS.n3403 VSS.n3336 0.399433
R18271 VSS.n2589 VSS.n2523 0.399433
R18272 VSS.n2517 VSS.n1833 0.399433
R18273 VSS.n5819 VSS.n5818 0.39914
R18274 VSS.n3161 VSS.n2848 0.39914
R18275 VSS.n4606 VSS.n4604 0.3955
R18276 VSS.n4534 VSS.n4532 0.3955
R18277 VSS.n4513 VSS.n4512 0.3955
R18278 VSS.n4490 VSS.n4488 0.3955
R18279 VSS.n6170 VSS.n6168 0.3955
R18280 VSS.n302 VSS.n301 0.3955
R18281 VSS.n6228 VSS.n6226 0.3955
R18282 VSS.n4271 VSS.n23 0.3955
R18283 VSS.n3985 VSS.n3983 0.3955
R18284 VSS.n3911 VSS.n3909 0.3955
R18285 VSS.n3992 VSS.n3991 0.3955
R18286 VSS.n3844 VSS.n3842 0.3955
R18287 VSS.n3777 VSS.n1817 0.3955
R18288 VSS.n3729 VSS.n1786 0.3955
R18289 VSS.n3416 VSS.n3414 0.3955
R18290 VSS.n2585 VSS.n2584 0.3955
R18291 VSS.n2303 VSS.n1851 0.3955
R18292 VSS.n4889 VSS.n4796 0.3955
R18293 VSS.n4856 VSS.n4842 0.3955
R18294 VSS.n5425 VSS.n1138 0.3955
R18295 VSS.n3063 VSS.n3016 0.3955
R18296 VSS.n3481 VSS.n2255 0.3955
R18297 VSS.n5973 VSS.n5972 0.3955
R18298 VSS.n5903 VSS.n5902 0.3955
R18299 VSS.n656 VSS.n655 0.3955
R18300 VSS.n5694 VSS.n5693 0.3955
R18301 VSS.n5788 VSS.n5787 0.3955
R18302 VSS.n5718 VSS.n485 0.3955
R18303 VSS.n6008 VSS.n399 0.3955
R18304 VSS.n559 VSS.n558 0.3955
R18305 VSS.n5324 VSS.n5322 0.3955
R18306 VSS.n5183 VSS.n681 0.3955
R18307 VSS.n5135 VSS.n5133 0.3955
R18308 VSS.n5331 VSS.n5330 0.3955
R18309 VSS.n5068 VSS.n5066 0.3955
R18310 VSS.n5306 VSS.n5305 0.3955
R18311 VSS.n5583 VSS.n5581 0.3955
R18312 VSS.n5590 VSS.n5589 0.3955
R18313 VSS.n5509 VSS.n756 0.3955
R18314 VSS.n5461 VSS.n5459 0.3955
R18315 VSS.n1059 VSS.n1057 0.3955
R18316 VSS.n991 VSS.n989 0.3955
R18317 VSS.n4122 VSS.n4120 0.3955
R18318 VSS.n4129 VSS.n4128 0.3955
R18319 VSS.n1698 VSS.n1696 0.3955
R18320 VSS.n1680 VSS.n1679 0.3955
R18321 VSS.n1605 VSS.n1604 0.3955
R18322 VSS.n4105 VSS.n4104 0.3955
R18323 VSS.n4168 VSS.n4167 0.3955
R18324 VSS.n2941 VSS.n2940 0.3955
R18325 VSS.n3313 VSS.n3312 0.3955
R18326 VSS.n3095 VSS.n3094 0.3955
R18327 VSS.n3166 VSS.n3165 0.3955
R18328 VSS.n3230 VSS.n3229 0.3955
R18329 VSS.n3275 VSS.n1338 0.3955
R18330 VSS.n1464 VSS.n1228 0.3955
R18331 VSS.n908 VSS.n788 0.3955
R18332 VSS.n4984 VSS.n715 0.3955
R18333 VSS.n2513 VSS.n2512 0.3955
R18334 VSS.n3399 VSS.n3398 0.3955
R18335 VSS.n2439 VSS.n2438 0.3955
R18336 VSS.n3446 VSS.n1884 0.3955
R18337 VSS.n2195 VSS.n2167 0.3955
R18338 VSS.n4137 VSS.n1363 0.386527
R18339 VSS.n5627 VSS.n5626 0.381247
R18340 VSS.n5797 VSS.n735 0.379193
R18341 VSS.n3319 VSS.n3318 0.379193
R18342 VSS.n5794 VSS.n5793 0.378313
R18343 VSS.n6163 VSS.n238 0.375673
R18344 VSS.n5835 VSS.n5834 0.374207
R18345 VSS.n1691 VSS.n1617 0.374207
R18346 VSS.n3330 VSS.n2589 0.373327
R18347 VSS.n3327 VSS.n1830 0.372153
R18348 VSS.n3614 VSS.n3613 0.3701
R18349 VSS.n4560 VSS.n4559 0.36834
R18350 VSS.n4309 VSS.n4308 0.36834
R18351 VSS.n4400 VSS.n4399 0.36834
R18352 VSS.n4436 VSS.n4435 0.36834
R18353 VSS.n197 VSS.n196 0.36834
R18354 VSS.n273 VSS.n272 0.36834
R18355 VSS.n110 VSS.n109 0.36834
R18356 VSS.n4263 VSS.n4261 0.36834
R18357 VSS.n3926 VSS.n3925 0.36834
R18358 VSS.n3859 VSS.n3858 0.36834
R18359 VSS.n3652 VSS.n3651 0.36834
R18360 VSS.n3792 VSS.n3791 0.36834
R18361 VSS.n3744 VSS.n3743 0.36834
R18362 VSS.n3696 VSS.n3695 0.36834
R18363 VSS.n2320 VSS.n2319 0.36834
R18364 VSS.n2551 VSS.n2550 0.36834
R18365 VSS.n2274 VSS.n2273 0.36834
R18366 VSS.n4778 VSS.n4777 0.36834
R18367 VSS.n4815 VSS.n4814 0.36834
R18368 VSS.n1157 VSS.n1156 0.36834
R18369 VSS.n3035 VSS.n3034 0.36834
R18370 VSS.n2237 VSS.n2236 0.36834
R18371 VSS.n5948 VSS.n5947 0.36834
R18372 VSS.n5878 VSS.n5877 0.36834
R18373 VSS.n631 VSS.n630 0.36834
R18374 VSS.n5669 VSS.n5668 0.36834
R18375 VSS.n5763 VSS.n5762 0.36834
R18376 VSS.n460 VSS.n459 0.36834
R18377 VSS.n419 VSS.n418 0.36834
R18378 VSS.n534 VSS.n533 0.36834
R18379 VSS.n5198 VSS.n5197 0.36834
R18380 VSS.n5150 VSS.n5149 0.36834
R18381 VSS.n5083 VSS.n5082 0.36834
R18382 VSS.n4925 VSS.n4924 0.36834
R18383 VSS.n5016 VSS.n5015 0.36834
R18384 VSS.n5272 VSS.n5271 0.36834
R18385 VSS.n5524 VSS.n5523 0.36834
R18386 VSS.n849 VSS.n848 0.36834
R18387 VSS.n5476 VSS.n5475 0.36834
R18388 VSS.n1074 VSS.n1073 0.36834
R18389 VSS.n1006 VSS.n1005 0.36834
R18390 VSS.n939 VSS.n938 0.36834
R18391 VSS.n1713 VSS.n1712 0.36834
R18392 VSS.n1405 VSS.n1404 0.36834
R18393 VSS.n1498 VSS.n1497 0.36834
R18394 VSS.n1646 VSS.n1645 0.36834
R18395 VSS.n1571 VSS.n1570 0.36834
R18396 VSS.n4071 VSS.n4070 0.36834
R18397 VSS.n1280 VSS.n1278 0.36834
R18398 VSS.n2914 VSS.n2912 0.36834
R18399 VSS.n2888 VSS.n2886 0.36834
R18400 VSS.n2978 VSS.n2976 0.36834
R18401 VSS.n3132 VSS.n3130 0.36834
R18402 VSS.n3203 VSS.n3201 0.36834
R18403 VSS.n3267 VSS.n3265 0.36834
R18404 VSS.n1456 VSS.n1454 0.36834
R18405 VSS.n900 VSS.n898 0.36834
R18406 VSS.n4976 VSS.n4974 0.36834
R18407 VSS.n2479 VSS.n2478 0.36834
R18408 VSS.n3365 VSS.n3364 0.36834
R18409 VSS.n2405 VSS.n2404 0.36834
R18410 VSS.n3438 VSS.n3436 0.36834
R18411 VSS.n2187 VSS.n2185 0.36834
R18412 VSS.n6221 VSS.n134 0.365407
R18413 VSS.n4134 VSS.n4133 0.365113
R18414 VSS.n3617 VSS.n1831 0.365113
R18415 VSS.n5577 VSS.n792 0.364233
R18416 VSS.n3410 VSS.n2450 0.363647
R18417 VSS.n5318 VSS.n718 0.3613
R18418 VSS.n6203 VSS.n6201 0.360429
R18419 VSS.n6203 VSS.n141 0.360429
R18420 VSS.n4018 VSS.n1819 0.360127
R18421 VSS.n3083 VSS.n3082 0.359247
R18422 VSS.n6027 VSS.n6026 0.35866
R18423 VSS.n5445 VSS.n5444 0.35778
R18424 VSS.n5448 VSS.n1121 0.3569
R18425 VSS.n4518 VSS.n4517 0.35602
R18426 VSS.n5345 VSS.n5342 0.35602
R18427 VSS.n4116 VSS.n4042 0.355727
R18428 VSS.n2058 VSS.n2057 0.353135
R18429 VSS.n5979 VSS.n5978 0.353087
R18430 VSS.n1355 VSS.n1341 0.353087
R18431 VSS.n5838 VSS.n661 0.351033
R18432 VSS.n4036 VSS.n4035 0.350153
R18433 VSS.n2370 VSS.n2367 0.350153
R18434 VSS.n5594 VSS.n5593 0.349273
R18435 VSS.n6147 VSS.n326 0.348687
R18436 VSS.n2047 VSS.n2046 0.347633
R18437 VSS.n4211 VSS.n1 0.32962
R18438 VSS.t1199 VSS.n8 0.317268
R18439 VSS.n6234 VSS.t1198 0.317268
R18440 VSS.n2091 VSS.n2090 0.31675
R18441 VSS.n2101 VSS.n2100 0.31675
R18442 VSS.n2082 VSS.n2081 0.31675
R18443 VSS.n2073 VSS.n2072 0.31675
R18444 VSS.n167 VSS.n137 0.307522
R18445 VSS.n3589 VSS.n3586 0.307167
R18446 VSS.n6106 VSS.n6030 0.293912
R18447 VSS.t3330 VSS.n1869 0.288915
R18448 VSS.t3329 VSS.n1873 0.288915
R18449 VSS.t93 VSS.n1841 0.288915
R18450 VSS.t92 VSS.n1861 0.288915
R18451 VSS.n4748 VSS.n4747 0.286793
R18452 VSS.n6246 VSS.n6245 0.286793
R18453 VSS.n4743 VSS.n717 0.286793
R18454 VSS.n4207 VSS.n791 0.286793
R18455 VSS.n4203 VSS.n4202 0.286793
R18456 VSS.n2125 VSS.n1340 0.286793
R18457 VSS.n3549 VSS.n3548 0.286793
R18458 VSS.n2047 VSS.n2044 0.283937
R18459 VSS.n6203 VSS.n6202 0.28195
R18460 VSS.n2093 VSS.n2090 0.268286
R18461 VSS.n2084 VSS.n2081 0.265179
R18462 VSS.n2004 VSS.n2003 0.241078
R18463 VSS.n2005 VSS.n2004 0.241078
R18464 VSS.n2006 VSS.n2005 0.241078
R18465 VSS.n2106 VSS.n2105 0.23675
R18466 VSS.n2059 VSS.n2058 0.228
R18467 VSS.n2092 VSS.n2091 0.227833
R18468 VSS.n2102 VSS.n2101 0.227833
R18469 VSS.n2100 VSS.n2097 0.227833
R18470 VSS.n2083 VSS.n2082 0.227833
R18471 VSS.n2077 VSS.n2072 0.227833
R18472 VSS.n2075 VSS.n2073 0.227833
R18473 VSS.n6220 VSS.n6219 0.221049
R18474 VSS.n4698 VSS.n329 0.217687
R18475 VSS.n2703 VSS.n2699 0.217687
R18476 VSS.n4595 VSS.n4594 0.217394
R18477 VSS.n4344 VSS.n4343 0.217394
R18478 VSS.n4373 VSS.n4372 0.217394
R18479 VSS.n4471 VSS.n4470 0.217394
R18480 VSS.n233 VSS.n232 0.217394
R18481 VSS.n247 VSS.n246 0.217394
R18482 VSS.n129 VSS.n128 0.217394
R18483 VSS.n42 VSS.n41 0.217394
R18484 VSS.n3967 VSS.n3966 0.217011
R18485 VSS.n3900 VSS.n3899 0.217011
R18486 VSS.n3632 VSS.n3631 0.217011
R18487 VSS.n3833 VSS.n3832 0.217011
R18488 VSS.n4022 VSS.n1811 0.217011
R18489 VSS.n1793 VSS.n1778 0.217011
R18490 VSS.n2361 VSS.n2360 0.217011
R18491 VSS.n2532 VSS.n2531 0.217011
R18492 VSS.n1859 VSS.n1844 0.217011
R18493 VSS.n5349 VSS.n4880 0.217011
R18494 VSS.n4862 VSS.n4847 0.217011
R18495 VSS.n5431 VSS.n1132 0.217011
R18496 VSS.n3069 VSS.n3010 0.217011
R18497 VSS.n3487 VSS.n3472 0.217011
R18498 VSS.n5923 VSS.n5922 0.217011
R18499 VSS.n5853 VSS.n5852 0.217011
R18500 VSS.n606 VSS.n605 0.217011
R18501 VSS.n5643 VSS.n5642 0.217011
R18502 VSS.n5738 VSS.n5737 0.217011
R18503 VSS.n5712 VSS.n5711 0.217011
R18504 VSS.n6012 VSS.n392 0.217011
R18505 VSS.n568 VSS.n505 0.217011
R18506 VSS.n5239 VSS.n5238 0.217011
R18507 VSS.n690 VSS.n674 0.217011
R18508 VSS.n5124 VSS.n5123 0.217011
R18509 VSS.n4905 VSS.n4904 0.217011
R18510 VSS.n5057 VSS.n5056 0.217011
R18511 VSS.n5253 VSS.n5252 0.217011
R18512 VSS.n5565 VSS.n5564 0.217011
R18513 VSS.n829 VSS.n828 0.217011
R18514 VSS.n763 VSS.n748 0.217011
R18515 VSS.n1115 VSS.n1114 0.217011
R18516 VSS.n1047 VSS.n1046 0.217011
R18517 VSS.n980 VSS.n979 0.217011
R18518 VSS.n1754 VSS.n1753 0.217011
R18519 VSS.n1385 VSS.n1384 0.217011
R18520 VSS.n1539 VSS.n1538 0.217011
R18521 VSS.n1626 VSS.n1625 0.217011
R18522 VSS.n1552 VSS.n1551 0.217011
R18523 VSS.n4051 VSS.n4050 0.217011
R18524 VSS.n1313 VSS.n1297 0.217011
R18525 VSS.n2931 VSS.n2930 0.217011
R18526 VSS.n2863 VSS.n2862 0.217011
R18527 VSS.n2995 VSS.n2994 0.217011
R18528 VSS.n3149 VSS.n3148 0.217011
R18529 VSS.n3220 VSS.n3219 0.217011
R18530 VSS.n4157 VSS.n1332 0.217011
R18531 VSS.n1242 VSS.n1218 0.217011
R18532 VSS.n5613 VSS.n782 0.217011
R18533 VSS.n5823 VSS.n709 0.217011
R18534 VSS.n2459 VSS.n2458 0.217011
R18535 VSS.n3345 VSS.n3344 0.217011
R18536 VSS.n2385 VSS.n2384 0.217011
R18537 VSS.n3601 VSS.n1877 0.217011
R18538 VSS.n3531 VSS.n2159 0.217011
R18539 VSS.n170 VSS 0.215486
R18540 VSS.n3964 VSS.n3963 0.213244
R18541 VSS.n3897 VSS.n3896 0.213244
R18542 VSS.n3629 VSS.n3628 0.213244
R18543 VSS.n3830 VSS.n3829 0.213244
R18544 VSS.n4028 VSS.n4024 0.213244
R18545 VSS.n1801 VSS.n1797 0.213244
R18546 VSS.n2358 VSS.n2357 0.213244
R18547 VSS.n2529 VSS.n2528 0.213244
R18548 VSS.n1867 VSS.n1863 0.213244
R18549 VSS.n5357 VSS.n5353 0.213244
R18550 VSS.n4870 VSS.n4866 0.213244
R18551 VSS.n5439 VSS.n5435 0.213244
R18552 VSS.n3077 VSS.n3073 0.213244
R18553 VSS.n3495 VSS.n3491 0.213244
R18554 VSS.n5920 VSS.n5919 0.213244
R18555 VSS.n5850 VSS.n5849 0.213244
R18556 VSS.n603 VSS.n602 0.213244
R18557 VSS.n5640 VSS.n5639 0.213244
R18558 VSS.n5735 VSS.n5734 0.213244
R18559 VSS.n5709 VSS.n5708 0.213244
R18560 VSS.n6020 VSS.n6016 0.213244
R18561 VSS.n576 VSS.n572 0.213244
R18562 VSS.n5236 VSS.n5235 0.213244
R18563 VSS.n698 VSS.n694 0.213244
R18564 VSS.n5121 VSS.n5120 0.213244
R18565 VSS.n4902 VSS.n4901 0.213244
R18566 VSS.n5054 VSS.n5053 0.213244
R18567 VSS.n5250 VSS.n5249 0.213244
R18568 VSS.n5562 VSS.n5561 0.213244
R18569 VSS.n826 VSS.n825 0.213244
R18570 VSS.n771 VSS.n767 0.213244
R18571 VSS.n1112 VSS.n1111 0.213244
R18572 VSS.n1044 VSS.n1043 0.213244
R18573 VSS.n977 VSS.n976 0.213244
R18574 VSS.n1751 VSS.n1750 0.213244
R18575 VSS.n1382 VSS.n1381 0.213244
R18576 VSS.n1536 VSS.n1535 0.213244
R18577 VSS.n1623 VSS.n1622 0.213244
R18578 VSS.n1549 VSS.n1548 0.213244
R18579 VSS.n4048 VSS.n4047 0.213244
R18580 VSS.n1321 VSS.n1317 0.213244
R18581 VSS.n2928 VSS.n2927 0.213244
R18582 VSS.n2860 VSS.n2859 0.213244
R18583 VSS.n2992 VSS.n2991 0.213244
R18584 VSS.n3146 VSS.n3145 0.213244
R18585 VSS.n3217 VSS.n3216 0.213244
R18586 VSS.n4163 VSS.n4159 0.213244
R18587 VSS.n1252 VSS.n1248 0.213244
R18588 VSS.n5619 VSS.n5615 0.213244
R18589 VSS.n5829 VSS.n5825 0.213244
R18590 VSS.n2456 VSS.n2455 0.213244
R18591 VSS.n3342 VSS.n3341 0.213244
R18592 VSS.n2382 VSS.n2381 0.213244
R18593 VSS.n3607 VSS.n3603 0.213244
R18594 VSS.n3537 VSS.n3533 0.213244
R18595 VSS.n4593 VSS.n4592 0.212986
R18596 VSS.n4342 VSS.n4341 0.212986
R18597 VSS.n4371 VSS.n4370 0.212986
R18598 VSS.n4469 VSS.n4468 0.212986
R18599 VSS.n231 VSS.n230 0.212986
R18600 VSS.n245 VSS.n244 0.212986
R18601 VSS.n127 VSS.n126 0.212986
R18602 VSS.n37 VSS.n36 0.212986
R18603 VSS.n3965 VSS.n3964 0.212986
R18604 VSS.n3898 VSS.n3897 0.212986
R18605 VSS.n3630 VSS.n3629 0.212986
R18606 VSS.n3831 VSS.n3830 0.212986
R18607 VSS.n4024 VSS.n4023 0.212986
R18608 VSS.n1797 VSS.n1794 0.212986
R18609 VSS.n2359 VSS.n2358 0.212986
R18610 VSS.n2530 VSS.n2529 0.212986
R18611 VSS.n1863 VSS.n1860 0.212986
R18612 VSS.n5353 VSS.n5350 0.212986
R18613 VSS.n4866 VSS.n4863 0.212986
R18614 VSS.n5435 VSS.n5432 0.212986
R18615 VSS.n3073 VSS.n3070 0.212986
R18616 VSS.n3491 VSS.n3488 0.212986
R18617 VSS.n5921 VSS.n5920 0.212986
R18618 VSS.n5851 VSS.n5850 0.212986
R18619 VSS.n604 VSS.n603 0.212986
R18620 VSS.n5641 VSS.n5640 0.212986
R18621 VSS.n5736 VSS.n5735 0.212986
R18622 VSS.n5710 VSS.n5709 0.212986
R18623 VSS.n6016 VSS.n6013 0.212986
R18624 VSS.n572 VSS.n569 0.212986
R18625 VSS.n5237 VSS.n5236 0.212986
R18626 VSS.n694 VSS.n691 0.212986
R18627 VSS.n5122 VSS.n5121 0.212986
R18628 VSS.n4903 VSS.n4902 0.212986
R18629 VSS.n5055 VSS.n5054 0.212986
R18630 VSS.n5251 VSS.n5250 0.212986
R18631 VSS.n5563 VSS.n5562 0.212986
R18632 VSS.n827 VSS.n826 0.212986
R18633 VSS.n767 VSS.n764 0.212986
R18634 VSS.n1113 VSS.n1112 0.212986
R18635 VSS.n1045 VSS.n1044 0.212986
R18636 VSS.n978 VSS.n977 0.212986
R18637 VSS.n1752 VSS.n1751 0.212986
R18638 VSS.n1383 VSS.n1382 0.212986
R18639 VSS.n1537 VSS.n1536 0.212986
R18640 VSS.n1624 VSS.n1623 0.212986
R18641 VSS.n1550 VSS.n1549 0.212986
R18642 VSS.n4049 VSS.n4048 0.212986
R18643 VSS.n1317 VSS.n1314 0.212986
R18644 VSS.n2929 VSS.n2928 0.212986
R18645 VSS.n2861 VSS.n2860 0.212986
R18646 VSS.n2993 VSS.n2992 0.212986
R18647 VSS.n3147 VSS.n3146 0.212986
R18648 VSS.n3218 VSS.n3217 0.212986
R18649 VSS.n4159 VSS.n4158 0.212986
R18650 VSS.n1248 VSS.n1243 0.212986
R18651 VSS.n5615 VSS.n5614 0.212986
R18652 VSS.n5825 VSS.n5824 0.212986
R18653 VSS.n2457 VSS.n2456 0.212986
R18654 VSS.n3343 VSS.n3342 0.212986
R18655 VSS.n2383 VSS.n2382 0.212986
R18656 VSS.n3603 VSS.n3602 0.212986
R18657 VSS.n3533 VSS.n3532 0.212986
R18658 VSS.n4592 VSS.n4591 0.212725
R18659 VSS.n4341 VSS.n4340 0.212725
R18660 VSS.n4370 VSS.n4369 0.212725
R18661 VSS.n4468 VSS.n4467 0.212725
R18662 VSS.n230 VSS.n229 0.212725
R18663 VSS.n244 VSS.n243 0.212725
R18664 VSS.n126 VSS.n125 0.212725
R18665 VSS.n36 VSS.n35 0.212725
R18666 VSS.n4597 VSS.n4596 0.212655
R18667 VSS.n4346 VSS.n4345 0.212655
R18668 VSS.n4375 VSS.n4374 0.212655
R18669 VSS.n4473 VSS.n4472 0.212655
R18670 VSS.n235 VSS.n234 0.212655
R18671 VSS.n249 VSS.n248 0.212655
R18672 VSS.n131 VSS.n130 0.212655
R18673 VSS.n48 VSS.n47 0.212655
R18674 VSS.n3969 VSS.n3968 0.212316
R18675 VSS.n3902 VSS.n3901 0.212316
R18676 VSS.n3634 VSS.n3633 0.212316
R18677 VSS.n3835 VSS.n3834 0.212316
R18678 VSS.n1813 VSS.n1812 0.212316
R18679 VSS.n1783 VSS.n1782 0.212316
R18680 VSS.n2363 VSS.n2362 0.212316
R18681 VSS.n2534 VSS.n2533 0.212316
R18682 VSS.n1848 VSS.n1847 0.212316
R18683 VSS.n4884 VSS.n4883 0.212316
R18684 VSS.n4851 VSS.n4850 0.212316
R18685 VSS.n1136 VSS.n1135 0.212316
R18686 VSS.n3014 VSS.n3013 0.212316
R18687 VSS.n3476 VSS.n3475 0.212316
R18688 VSS.n5925 VSS.n5924 0.212316
R18689 VSS.n5855 VSS.n5854 0.212316
R18690 VSS.n608 VSS.n607 0.212316
R18691 VSS.n5645 VSS.n5644 0.212316
R18692 VSS.n5740 VSS.n5739 0.212316
R18693 VSS.n5714 VSS.n5713 0.212316
R18694 VSS.n397 VSS.n396 0.212316
R18695 VSS.n509 VSS.n508 0.212316
R18696 VSS.n5241 VSS.n5240 0.212316
R18697 VSS.n678 VSS.n677 0.212316
R18698 VSS.n5126 VSS.n5125 0.212316
R18699 VSS.n4907 VSS.n4906 0.212316
R18700 VSS.n5059 VSS.n5058 0.212316
R18701 VSS.n5255 VSS.n5254 0.212316
R18702 VSS.n5567 VSS.n5566 0.212316
R18703 VSS.n831 VSS.n830 0.212316
R18704 VSS.n753 VSS.n752 0.212316
R18705 VSS.n1117 VSS.n1116 0.212316
R18706 VSS.n1049 VSS.n1048 0.212316
R18707 VSS.n982 VSS.n981 0.212316
R18708 VSS.n1756 VSS.n1755 0.212316
R18709 VSS.n1387 VSS.n1386 0.212316
R18710 VSS.n1541 VSS.n1540 0.212316
R18711 VSS.n1628 VSS.n1627 0.212316
R18712 VSS.n1554 VSS.n1553 0.212316
R18713 VSS.n4053 VSS.n4052 0.212316
R18714 VSS.n1301 VSS.n1300 0.212316
R18715 VSS.n2933 VSS.n2932 0.212316
R18716 VSS.n2865 VSS.n2864 0.212316
R18717 VSS.n2997 VSS.n2996 0.212316
R18718 VSS.n3151 VSS.n3150 0.212316
R18719 VSS.n3222 VSS.n3221 0.212316
R18720 VSS.n1334 VSS.n1333 0.212316
R18721 VSS.n1222 VSS.n1221 0.212316
R18722 VSS.n784 VSS.n783 0.212316
R18723 VSS.n711 VSS.n710 0.212316
R18724 VSS.n2461 VSS.n2460 0.212316
R18725 VSS.n3347 VSS.n3346 0.212316
R18726 VSS.n2387 VSS.n2386 0.212316
R18727 VSS.n1879 VSS.n1878 0.212316
R18728 VSS.n2161 VSS.n2160 0.212316
R18729 VSS.n2107 VSS.n2106 0.21175
R18730 VSS.n2112 VSS.n1980 0.208325
R18731 VSS.n2111 VSS.n2110 0.20675
R18732 VSS.n3568 VSS.n3567 0.20675
R18733 VSS.n3001 VSS.n1834 0.205959
R18734 VSS.n3002 VSS.n1124 0.205959
R18735 VSS.n5344 VSS.n5343 0.205959
R18736 VSS.n6220 VSS.n135 0.205959
R18737 VSS.n3563 VSS.n1962 0.205486
R18738 VSS.n2129 VSS.n2120 0.205049
R18739 VSS.n2128 VSS.n2123 0.205049
R18740 VSS.n1181 VSS.n1179 0.205049
R18741 VSS.n2129 VSS.n2128 0.204735
R18742 VSS.n4638 VSS.n1179 0.204735
R18743 VSS.n3002 VSS.n3001 0.204453
R18744 VSS.n5343 VSS.n1124 0.204453
R18745 VSS.n5344 VSS.n135 0.204453
R18746 VSS.n2123 VSS.n1181 0.204422
R18747 VSS.n3970 VSS.n3969 0.204409
R18748 VSS.n3903 VSS.n3902 0.204409
R18749 VSS.n3635 VSS.n3634 0.204409
R18750 VSS.n3836 VSS.n3835 0.204409
R18751 VSS.n1818 VSS.n1813 0.204409
R18752 VSS.n1783 VSS.n1781 0.204409
R18753 VSS.n2364 VSS.n2363 0.204409
R18754 VSS.n2535 VSS.n2534 0.204409
R18755 VSS.n1853 VSS.n1848 0.204409
R18756 VSS.n4890 VSS.n4884 0.204409
R18757 VSS.n4857 VSS.n4851 0.204409
R18758 VSS.n5428 VSS.n1136 0.204409
R18759 VSS.n3066 VSS.n3014 0.204409
R18760 VSS.n3482 VSS.n3476 0.204409
R18761 VSS.n5926 VSS.n5925 0.204409
R18762 VSS.n5856 VSS.n5855 0.204409
R18763 VSS.n609 VSS.n608 0.204409
R18764 VSS.n5646 VSS.n5645 0.204409
R18765 VSS.n5741 VSS.n5740 0.204409
R18766 VSS.n5715 VSS.n5714 0.204409
R18767 VSS.n397 VSS.n395 0.204409
R18768 VSS.n560 VSS.n509 0.204409
R18769 VSS.n5242 VSS.n5241 0.204409
R18770 VSS.n683 VSS.n678 0.204409
R18771 VSS.n5127 VSS.n5126 0.204409
R18772 VSS.n4908 VSS.n4907 0.204409
R18773 VSS.n5060 VSS.n5059 0.204409
R18774 VSS.n5256 VSS.n5255 0.204409
R18775 VSS.n5568 VSS.n5567 0.204409
R18776 VSS.n832 VSS.n831 0.204409
R18777 VSS.n753 VSS.n751 0.204409
R18778 VSS.n1118 VSS.n1117 0.204409
R18779 VSS.n1050 VSS.n1049 0.204409
R18780 VSS.n983 VSS.n982 0.204409
R18781 VSS.n1757 VSS.n1756 0.204409
R18782 VSS.n1388 VSS.n1387 0.204409
R18783 VSS.n1542 VSS.n1541 0.204409
R18784 VSS.n1629 VSS.n1628 0.204409
R18785 VSS.n1555 VSS.n1554 0.204409
R18786 VSS.n4054 VSS.n4053 0.204409
R18787 VSS.n1306 VSS.n1301 0.204409
R18788 VSS.n2934 VSS.n2933 0.204409
R18789 VSS.n2866 VSS.n2865 0.204409
R18790 VSS.n2998 VSS.n2997 0.204409
R18791 VSS.n3152 VSS.n3151 0.204409
R18792 VSS.n3223 VSS.n3222 0.204409
R18793 VSS.n1339 VSS.n1334 0.204409
R18794 VSS.n1231 VSS.n1222 0.204409
R18795 VSS.n789 VSS.n784 0.204409
R18796 VSS.n716 VSS.n711 0.204409
R18797 VSS.n2462 VSS.n2461 0.204409
R18798 VSS.n3348 VSS.n3347 0.204409
R18799 VSS.n2388 VSS.n2387 0.204409
R18800 VSS.n1885 VSS.n1879 0.204409
R18801 VSS.n3526 VSS.n2161 0.204409
R18802 VSS.n4598 VSS.n4597 0.204071
R18803 VSS.n4347 VSS.n4346 0.204071
R18804 VSS.n4376 VSS.n4375 0.204071
R18805 VSS.n4474 VSS.n4473 0.204071
R18806 VSS.n236 VSS.n235 0.204071
R18807 VSS.n250 VSS.n249 0.204071
R18808 VSS.n132 VSS.n131 0.204071
R18809 VSS.n52 VSS.n48 0.204071
R18810 VSS.n4594 VSS.n4593 0.203325
R18811 VSS.n4343 VSS.n4342 0.203325
R18812 VSS.n4372 VSS.n4371 0.203325
R18813 VSS.n4470 VSS.n4469 0.203325
R18814 VSS.n232 VSS.n231 0.203325
R18815 VSS.n246 VSS.n245 0.203325
R18816 VSS.n128 VSS.n127 0.203325
R18817 VSS.n41 VSS.n37 0.203325
R18818 VSS.n3966 VSS.n3965 0.203325
R18819 VSS.n3899 VSS.n3898 0.203325
R18820 VSS.n3631 VSS.n3630 0.203325
R18821 VSS.n3832 VSS.n3831 0.203325
R18822 VSS.n4023 VSS.n4022 0.203325
R18823 VSS.n1794 VSS.n1793 0.203325
R18824 VSS.n2360 VSS.n2359 0.203325
R18825 VSS.n2531 VSS.n2530 0.203325
R18826 VSS.n1860 VSS.n1859 0.203325
R18827 VSS.n5350 VSS.n5349 0.203325
R18828 VSS.n4863 VSS.n4862 0.203325
R18829 VSS.n5432 VSS.n5431 0.203325
R18830 VSS.n3070 VSS.n3069 0.203325
R18831 VSS.n3488 VSS.n3487 0.203325
R18832 VSS.n5922 VSS.n5921 0.203325
R18833 VSS.n5852 VSS.n5851 0.203325
R18834 VSS.n605 VSS.n604 0.203325
R18835 VSS.n5642 VSS.n5641 0.203325
R18836 VSS.n5737 VSS.n5736 0.203325
R18837 VSS.n5711 VSS.n5710 0.203325
R18838 VSS.n6013 VSS.n6012 0.203325
R18839 VSS.n569 VSS.n568 0.203325
R18840 VSS.n5238 VSS.n5237 0.203325
R18841 VSS.n691 VSS.n690 0.203325
R18842 VSS.n5123 VSS.n5122 0.203325
R18843 VSS.n4904 VSS.n4903 0.203325
R18844 VSS.n5056 VSS.n5055 0.203325
R18845 VSS.n5252 VSS.n5251 0.203325
R18846 VSS.n5564 VSS.n5563 0.203325
R18847 VSS.n828 VSS.n827 0.203325
R18848 VSS.n764 VSS.n763 0.203325
R18849 VSS.n1114 VSS.n1113 0.203325
R18850 VSS.n1046 VSS.n1045 0.203325
R18851 VSS.n979 VSS.n978 0.203325
R18852 VSS.n1753 VSS.n1752 0.203325
R18853 VSS.n1384 VSS.n1383 0.203325
R18854 VSS.n1538 VSS.n1537 0.203325
R18855 VSS.n1625 VSS.n1624 0.203325
R18856 VSS.n1551 VSS.n1550 0.203325
R18857 VSS.n4050 VSS.n4049 0.203325
R18858 VSS.n1314 VSS.n1313 0.203325
R18859 VSS.n2930 VSS.n2929 0.203325
R18860 VSS.n2862 VSS.n2861 0.203325
R18861 VSS.n2994 VSS.n2993 0.203325
R18862 VSS.n3148 VSS.n3147 0.203325
R18863 VSS.n3219 VSS.n3218 0.203325
R18864 VSS.n4158 VSS.n4157 0.203325
R18865 VSS.n1243 VSS.n1242 0.203325
R18866 VSS.n5614 VSS.n5613 0.203325
R18867 VSS.n5824 VSS.n5823 0.203325
R18868 VSS.n2458 VSS.n2457 0.203325
R18869 VSS.n3344 VSS.n3343 0.203325
R18870 VSS.n2384 VSS.n2383 0.203325
R18871 VSS.n3602 VSS.n3601 0.203325
R18872 VSS.n3532 VSS.n3531 0.203325
R18873 VSS.n4591 VSS.n4590 0.201588
R18874 VSS.n4340 VSS.n4339 0.201588
R18875 VSS.n4369 VSS.n4368 0.201588
R18876 VSS.n4467 VSS.n4466 0.201588
R18877 VSS.n229 VSS.n228 0.201588
R18878 VSS.n243 VSS.n242 0.201588
R18879 VSS.n125 VSS.n124 0.201588
R18880 VSS.n35 VSS.n34 0.201588
R18881 VSS.n2061 VSS.n2060 0.201569
R18882 VSS.n3963 VSS.n3962 0.201076
R18883 VSS.n3896 VSS.n3895 0.201076
R18884 VSS.n3628 VSS.n3627 0.201076
R18885 VSS.n3829 VSS.n3828 0.201076
R18886 VSS.n4028 VSS.n4027 0.201076
R18887 VSS.n1801 VSS.n1800 0.201076
R18888 VSS.n2357 VSS.n2356 0.201076
R18889 VSS.n2528 VSS.n2527 0.201076
R18890 VSS.n1867 VSS.n1866 0.201076
R18891 VSS.n5357 VSS.n5356 0.201076
R18892 VSS.n4870 VSS.n4869 0.201076
R18893 VSS.n5439 VSS.n5438 0.201076
R18894 VSS.n3077 VSS.n3076 0.201076
R18895 VSS.n3495 VSS.n3494 0.201076
R18896 VSS.n5919 VSS.n5918 0.201076
R18897 VSS.n5849 VSS.n5848 0.201076
R18898 VSS.n602 VSS.n601 0.201076
R18899 VSS.n5639 VSS.n5638 0.201076
R18900 VSS.n5734 VSS.n5733 0.201076
R18901 VSS.n5708 VSS.n5707 0.201076
R18902 VSS.n6020 VSS.n6019 0.201076
R18903 VSS.n576 VSS.n575 0.201076
R18904 VSS.n5235 VSS.n5234 0.201076
R18905 VSS.n698 VSS.n697 0.201076
R18906 VSS.n5120 VSS.n5119 0.201076
R18907 VSS.n4901 VSS.n4900 0.201076
R18908 VSS.n5053 VSS.n5052 0.201076
R18909 VSS.n5249 VSS.n5248 0.201076
R18910 VSS.n5561 VSS.n5560 0.201076
R18911 VSS.n825 VSS.n824 0.201076
R18912 VSS.n771 VSS.n770 0.201076
R18913 VSS.n1111 VSS.n1110 0.201076
R18914 VSS.n1043 VSS.n1042 0.201076
R18915 VSS.n976 VSS.n975 0.201076
R18916 VSS.n1750 VSS.n1749 0.201076
R18917 VSS.n1381 VSS.n1380 0.201076
R18918 VSS.n1535 VSS.n1534 0.201076
R18919 VSS.n1622 VSS.n1621 0.201076
R18920 VSS.n1548 VSS.n1547 0.201076
R18921 VSS.n4047 VSS.n4046 0.201076
R18922 VSS.n1321 VSS.n1320 0.201076
R18923 VSS.n2927 VSS.n2926 0.201076
R18924 VSS.n2859 VSS.n2858 0.201076
R18925 VSS.n2991 VSS.n2990 0.201076
R18926 VSS.n3145 VSS.n3144 0.201076
R18927 VSS.n3216 VSS.n3215 0.201076
R18928 VSS.n4163 VSS.n4162 0.201076
R18929 VSS.n1252 VSS.n1251 0.201076
R18930 VSS.n5619 VSS.n5618 0.201076
R18931 VSS.n5829 VSS.n5828 0.201076
R18932 VSS.n2455 VSS.n2454 0.201076
R18933 VSS.n3341 VSS.n3340 0.201076
R18934 VSS.n2381 VSS.n2380 0.201076
R18935 VSS.n3607 VSS.n3606 0.201076
R18936 VSS.n3537 VSS.n3536 0.201076
R18937 VSS.n3569 VSS.n2078 0.199539
R18938 VSS.t3635 VSS.n4249 0.199266
R18939 VSS.t3635 VSS.n4245 0.199266
R18940 VSS.t3249 VSS.n5960 0.199266
R18941 VSS.t3249 VSS.n5964 0.199266
R18942 VSS.t3649 VSS.n5890 0.199266
R18943 VSS.t3649 VSS.n5894 0.199266
R18944 VSS.t2447 VSS.n643 0.199266
R18945 VSS.t2447 VSS.n647 0.199266
R18946 VSS.t1318 VSS.n5681 0.199266
R18947 VSS.t1318 VSS.n5685 0.199266
R18948 VSS.t1567 VSS.n5775 0.199266
R18949 VSS.t1567 VSS.n5779 0.199266
R18950 VSS.t1828 VSS.n472 0.199266
R18951 VSS.t1828 VSS.n476 0.199266
R18952 VSS.t2423 VSS.n546 0.199266
R18953 VSS.t2423 VSS.n550 0.199266
R18954 VSS.t2555 VSS.n3253 0.199266
R18955 VSS.t2555 VSS.n3249 0.199266
R18956 VSS.t3653 VSS.n3189 0.199266
R18957 VSS.t3653 VSS.n3185 0.199266
R18958 VSS.t1421 VSS.n3118 0.199266
R18959 VSS.t1421 VSS.n3114 0.199266
R18960 VSS.t1936 VSS.n2964 0.199266
R18961 VSS.t1936 VSS.n2960 0.199266
R18962 VSS.t1676 VSS.n2874 0.199266
R18963 VSS.t1676 VSS.n2870 0.199266
R18964 VSS.t1104 VSS.n2900 0.199266
R18965 VSS.t1104 VSS.n2896 0.199266
R18966 VSS.t3279 VSS.n1266 0.199266
R18967 VSS.t3279 VSS.n1262 0.199266
R18968 VSS.t2958 VSS.n1441 0.199266
R18969 VSS.t2958 VSS.n1437 0.199266
R18970 VSS.n4084 VSS.t2945 0.199266
R18971 VSS.n4091 VSS.t2945 0.199266
R18972 VSS.n1584 VSS.t1395 0.199266
R18973 VSS.n1591 VSS.t1395 0.199266
R18974 VSS.n1659 VSS.t1909 0.199266
R18975 VSS.n1666 VSS.t1909 0.199266
R18976 VSS.n1511 VSS.t1648 0.199266
R18977 VSS.n1518 VSS.t1648 0.199266
R18978 VSS.n1418 VSS.t74 0.199266
R18979 VSS.n1425 VSS.t74 0.199266
R18980 VSS.n1726 VSS.t2295 0.199266
R18981 VSS.n1733 VSS.t2295 0.199266
R18982 VSS.t3118 VSS.n885 0.199266
R18983 VSS.t3118 VSS.n881 0.199266
R18984 VSS.n952 VSS.t3457 0.199266
R18985 VSS.n959 VSS.t3457 0.199266
R18986 VSS.n1019 VSS.t1367 0.199266
R18987 VSS.n1026 VSS.t1367 0.199266
R18988 VSS.n1087 VSS.t1881 0.199266
R18989 VSS.n1094 VSS.t1881 0.199266
R18990 VSS.n5489 VSS.t1622 0.199266
R18991 VSS.n5496 VSS.t1622 0.199266
R18992 VSS.n862 VSS.t46 0.199266
R18993 VSS.n869 VSS.t46 0.199266
R18994 VSS.n5537 VSS.t3645 0.199266
R18995 VSS.n5544 VSS.t3645 0.199266
R18996 VSS.t2612 VSS.n4961 0.199266
R18997 VSS.t2612 VSS.n4957 0.199266
R18998 VSS.n5285 VSS.t2770 0.199266
R18999 VSS.n5292 VSS.t2770 0.199266
R19000 VSS.n5029 VSS.t1343 0.199266
R19001 VSS.n5036 VSS.t1343 0.199266
R19002 VSS.n4938 VSS.t1855 0.199266
R19003 VSS.n4945 VSS.t1855 0.199266
R19004 VSS.n5096 VSS.t1595 0.199266
R19005 VSS.n5103 VSS.t1595 0.199266
R19006 VSS.n5163 VSS.t3402 0.199266
R19007 VSS.n5170 VSS.t3402 0.199266
R19008 VSS.n5211 VSS.t3353 0.199266
R19009 VSS.n5218 VSS.t3353 0.199266
R19010 VSS.t3237 VSS.n3423 0.199266
R19011 VSS.t3237 VSS.n3419 0.199266
R19012 VSS.n2333 VSS.t1184 0.199266
R19013 VSS.n2340 VSS.t1184 0.199266
R19014 VSS.n2564 VSS.t1730 0.199266
R19015 VSS.n2571 VSS.t1730 0.199266
R19016 VSS.n2492 VSS.t1994 0.199266
R19017 VSS.n2499 VSS.t1994 0.199266
R19018 VSS.n3378 VSS.t1479 0.199266
R19019 VSS.n3385 VSS.t1479 0.199266
R19020 VSS.n2418 VSS.t2256 0.199266
R19021 VSS.n2425 VSS.t2256 0.199266
R19022 VSS.t2627 VSS.n2172 0.199266
R19023 VSS.t2627 VSS.n2168 0.199266
R19024 VSS.n3939 VSS.t2658 0.199266
R19025 VSS.n3946 VSS.t2658 0.199266
R19026 VSS.n3872 VSS.t1449 0.199266
R19027 VSS.n3879 VSS.t1449 0.199266
R19028 VSS.n3665 VSS.t1963 0.199266
R19029 VSS.n3672 VSS.t1963 0.199266
R19030 VSS.n3805 VSS.t1704 0.199266
R19031 VSS.n3812 VSS.t1704 0.199266
R19032 VSS.n3757 VSS.t1148 0.199266
R19033 VSS.n3764 VSS.t1148 0.199266
R19034 VSS.n3709 VSS.t3263 0.199266
R19035 VSS.n3716 VSS.t3263 0.199266
R19036 VSS.n4094 VSS.t2945 0.199181
R19037 VSS.n1594 VSS.t1395 0.199181
R19038 VSS.n1669 VSS.t1909 0.199181
R19039 VSS.n1521 VSS.t1648 0.199181
R19040 VSS.n1428 VSS.t74 0.199181
R19041 VSS.n1736 VSS.t2295 0.199181
R19042 VSS.n962 VSS.t3457 0.199181
R19043 VSS.n1029 VSS.t1367 0.199181
R19044 VSS.n1097 VSS.t1881 0.199181
R19045 VSS.n5499 VSS.t1622 0.199181
R19046 VSS.n872 VSS.t46 0.199181
R19047 VSS.n5547 VSS.t3645 0.199181
R19048 VSS.n5295 VSS.t2770 0.199181
R19049 VSS.n5039 VSS.t1343 0.199181
R19050 VSS.n4948 VSS.t1855 0.199181
R19051 VSS.n5106 VSS.t1595 0.199181
R19052 VSS.n5173 VSS.t3402 0.199181
R19053 VSS.n5221 VSS.t3353 0.199181
R19054 VSS.n2343 VSS.t1184 0.199181
R19055 VSS.n2574 VSS.t1730 0.199181
R19056 VSS.n2502 VSS.t1994 0.199181
R19057 VSS.n3388 VSS.t1479 0.199181
R19058 VSS.n2428 VSS.t2256 0.199181
R19059 VSS.n3949 VSS.t2658 0.199181
R19060 VSS.n3882 VSS.t1449 0.199181
R19061 VSS.n3675 VSS.t1963 0.199181
R19062 VSS.n3815 VSS.t1704 0.199181
R19063 VSS.n3767 VSS.t1148 0.199181
R19064 VSS.n3719 VSS.t3263 0.199181
R19065 VSS.t3635 VSS.n4288 0.199181
R19066 VSS.t3249 VSS.n5965 0.199181
R19067 VSS.t3649 VSS.n5895 0.199181
R19068 VSS.t2447 VSS.n648 0.199181
R19069 VSS.t1318 VSS.n5686 0.199181
R19070 VSS.t1567 VSS.n5780 0.199181
R19071 VSS.t1828 VSS.n477 0.199181
R19072 VSS.t2423 VSS.n551 0.199181
R19073 VSS.t3279 VSS.n4185 0.199181
R19074 VSS.t1104 VSS.n2958 0.199181
R19075 VSS.t1676 VSS.n3311 0.199181
R19076 VSS.t1936 VSS.n3112 0.199181
R19077 VSS.t1421 VSS.n3183 0.199181
R19078 VSS.t3653 VSS.n3247 0.199181
R19079 VSS.t2555 VSS.n3292 0.199181
R19080 VSS.t2958 VSS.n1481 0.199181
R19081 VSS.t3118 VSS.n925 0.199181
R19082 VSS.t2612 VSS.n5001 0.199181
R19083 VSS.t3237 VSS.n3463 0.199181
R19084 VSS.t2627 VSS.n2212 0.199181
R19085 VSS.t3635 VSS.n4284 0.198994
R19086 VSS.n3953 VSS.t2658 0.198994
R19087 VSS.n3886 VSS.t1449 0.198994
R19088 VSS.n3679 VSS.t1963 0.198994
R19089 VSS.n3819 VSS.t1704 0.198994
R19090 VSS.n3771 VSS.t1148 0.198994
R19091 VSS.n3723 VSS.t3263 0.198994
R19092 VSS.n2347 VSS.t1184 0.198994
R19093 VSS.n2578 VSS.t1730 0.198994
R19094 VSS.t3249 VSS.n5969 0.198994
R19095 VSS.t3649 VSS.n5899 0.198994
R19096 VSS.t2447 VSS.n652 0.198994
R19097 VSS.t1318 VSS.n5690 0.198994
R19098 VSS.t1567 VSS.n5784 0.198994
R19099 VSS.t1828 VSS.n481 0.198994
R19100 VSS.t2423 VSS.n555 0.198994
R19101 VSS.n5225 VSS.t3353 0.198994
R19102 VSS.n5177 VSS.t3402 0.198994
R19103 VSS.n5110 VSS.t1595 0.198994
R19104 VSS.n4952 VSS.t1855 0.198994
R19105 VSS.n5043 VSS.t1343 0.198994
R19106 VSS.n5299 VSS.t2770 0.198994
R19107 VSS.n5551 VSS.t3645 0.198994
R19108 VSS.n876 VSS.t46 0.198994
R19109 VSS.n5503 VSS.t1622 0.198994
R19110 VSS.n1101 VSS.t1881 0.198994
R19111 VSS.n1033 VSS.t1367 0.198994
R19112 VSS.n966 VSS.t3457 0.198994
R19113 VSS.n1740 VSS.t2295 0.198994
R19114 VSS.n1432 VSS.t74 0.198994
R19115 VSS.n1525 VSS.t1648 0.198994
R19116 VSS.n1673 VSS.t1909 0.198994
R19117 VSS.n1598 VSS.t1395 0.198994
R19118 VSS.n4098 VSS.t2945 0.198994
R19119 VSS.t3279 VSS.n4181 0.198994
R19120 VSS.t1104 VSS.n2954 0.198994
R19121 VSS.t1676 VSS.n3307 0.198994
R19122 VSS.t1936 VSS.n3108 0.198994
R19123 VSS.t1421 VSS.n3179 0.198994
R19124 VSS.t3653 VSS.n3243 0.198994
R19125 VSS.t2555 VSS.n3288 0.198994
R19126 VSS.t2958 VSS.n1477 0.198994
R19127 VSS.t3118 VSS.n921 0.198994
R19128 VSS.t2612 VSS.n4997 0.198994
R19129 VSS.n2506 VSS.t1994 0.198994
R19130 VSS.n3392 VSS.t1479 0.198994
R19131 VSS.n2432 VSS.t2256 0.198994
R19132 VSS.t3237 VSS.n3459 0.198994
R19133 VSS.t2627 VSS.n2208 0.198994
R19134 VSS.n3968 VSS.n3967 0.19778
R19135 VSS.n3901 VSS.n3900 0.19778
R19136 VSS.n3633 VSS.n3632 0.19778
R19137 VSS.n3834 VSS.n3833 0.19778
R19138 VSS.n1812 VSS.n1811 0.19778
R19139 VSS.n1782 VSS.n1778 0.19778
R19140 VSS.n2362 VSS.n2361 0.19778
R19141 VSS.n2533 VSS.n2532 0.19778
R19142 VSS.n1847 VSS.n1844 0.19778
R19143 VSS.n4883 VSS.n4880 0.19778
R19144 VSS.n4850 VSS.n4847 0.19778
R19145 VSS.n1135 VSS.n1132 0.19778
R19146 VSS.n3013 VSS.n3010 0.19778
R19147 VSS.n3475 VSS.n3472 0.19778
R19148 VSS.n5924 VSS.n5923 0.19778
R19149 VSS.n5854 VSS.n5853 0.19778
R19150 VSS.n607 VSS.n606 0.19778
R19151 VSS.n5644 VSS.n5643 0.19778
R19152 VSS.n5739 VSS.n5738 0.19778
R19153 VSS.n5713 VSS.n5712 0.19778
R19154 VSS.n396 VSS.n392 0.19778
R19155 VSS.n508 VSS.n505 0.19778
R19156 VSS.n5240 VSS.n5239 0.19778
R19157 VSS.n677 VSS.n674 0.19778
R19158 VSS.n5125 VSS.n5124 0.19778
R19159 VSS.n4906 VSS.n4905 0.19778
R19160 VSS.n5058 VSS.n5057 0.19778
R19161 VSS.n5254 VSS.n5253 0.19778
R19162 VSS.n5566 VSS.n5565 0.19778
R19163 VSS.n830 VSS.n829 0.19778
R19164 VSS.n752 VSS.n748 0.19778
R19165 VSS.n1116 VSS.n1115 0.19778
R19166 VSS.n1048 VSS.n1047 0.19778
R19167 VSS.n981 VSS.n980 0.19778
R19168 VSS.n1755 VSS.n1754 0.19778
R19169 VSS.n1386 VSS.n1385 0.19778
R19170 VSS.n1540 VSS.n1539 0.19778
R19171 VSS.n1627 VSS.n1626 0.19778
R19172 VSS.n1553 VSS.n1552 0.19778
R19173 VSS.n4052 VSS.n4051 0.19778
R19174 VSS.n1300 VSS.n1297 0.19778
R19175 VSS.n2932 VSS.n2931 0.19778
R19176 VSS.n2864 VSS.n2863 0.19778
R19177 VSS.n2996 VSS.n2995 0.19778
R19178 VSS.n3150 VSS.n3149 0.19778
R19179 VSS.n3221 VSS.n3220 0.19778
R19180 VSS.n1333 VSS.n1332 0.19778
R19181 VSS.n1221 VSS.n1218 0.19778
R19182 VSS.n783 VSS.n782 0.19778
R19183 VSS.n710 VSS.n709 0.19778
R19184 VSS.n2460 VSS.n2459 0.19778
R19185 VSS.n3346 VSS.n3345 0.19778
R19186 VSS.n2386 VSS.n2385 0.19778
R19187 VSS.n1878 VSS.n1877 0.19778
R19188 VSS.n2160 VSS.n2159 0.19778
R19189 VSS.n4596 VSS.n4595 0.197394
R19190 VSS.n4345 VSS.n4344 0.197394
R19191 VSS.n4374 VSS.n4373 0.197394
R19192 VSS.n4472 VSS.n4471 0.197394
R19193 VSS.n234 VSS.n233 0.197394
R19194 VSS.n248 VSS.n247 0.197394
R19195 VSS.n130 VSS.n129 0.197394
R19196 VSS.n47 VSS.n42 0.197394
R19197 VSS.t1798 VSS.n285 0.196551
R19198 VSS.t1798 VSS.n291 0.196551
R19199 VSS.t1798 VSS.n295 0.196551
R19200 VSS.t1538 VSS.n209 0.196551
R19201 VSS.t1538 VSS.n216 0.196551
R19202 VSS.t1538 VSS.n220 0.196551
R19203 VSS.t1280 VSS.n4449 0.196551
R19204 VSS.t1280 VSS.n4454 0.196551
R19205 VSS.t1280 VSS.n4458 0.196551
R19206 VSS.t3387 VSS.n4413 0.196551
R19207 VSS.t3387 VSS.n4502 0.196551
R19208 VSS.t3387 VSS.n4506 0.196551
R19209 VSS.t2858 VSS.n4322 0.196551
R19210 VSS.t2858 VSS.n4327 0.196551
R19211 VSS.t2858 VSS.n4331 0.196551
R19212 VSS.t2981 VSS.n4573 0.196551
R19213 VSS.t2981 VSS.n4578 0.196551
R19214 VSS.t2981 VSS.n4582 0.196551
R19215 VSS.n6116 VSS.n6107 0.193343
R19216 VSS.n2841 VSS.n2822 0.193343
R19217 VSS.n2114 VSS.n1915 0.192986
R19218 VSS.t2977 VSS.n2035 0.192645
R19219 VSS.n2048 VSS.t2977 0.192645
R19220 VSS.n6144 VSS.n6129 0.192405
R19221 VSS.n2720 VSS.n2716 0.192405
R19222 VSS.n6127 VSS.n6118 0.18988
R19223 VSS.n2734 VSS.n2733 0.18988
R19224 VSS.n4572 VSS.n4571 0.185486
R19225 VSS.n4321 VSS.n4320 0.185486
R19226 VSS.n4412 VSS.n4411 0.185486
R19227 VSS.n4448 VSS.n4447 0.185486
R19228 VSS.n208 VSS.n207 0.185486
R19229 VSS.n284 VSS.n283 0.185486
R19230 VSS.n116 VSS.n115 0.185486
R19231 VSS.n4260 VSS.n4250 0.185486
R19232 VSS.n3924 VSS.n3919 0.185486
R19233 VSS.n3857 VSS.n3852 0.185486
R19234 VSS.n3650 VSS.n3645 0.185486
R19235 VSS.n3790 VSS.n3785 0.185486
R19236 VSS.n3742 VSS.n3737 0.185486
R19237 VSS.n3694 VSS.n3689 0.185486
R19238 VSS.n2318 VSS.n2313 0.185486
R19239 VSS.n2549 VSS.n2544 0.185486
R19240 VSS.n2288 VSS.n2287 0.185486
R19241 VSS.n4786 VSS.n4785 0.185486
R19242 VSS.n4827 VSS.n4826 0.185486
R19243 VSS.n5410 VSS.n5409 0.185486
R19244 VSS.n3048 VSS.n3047 0.185486
R19245 VSS.n2245 VSS.n2244 0.185486
R19246 VSS.n5959 VSS.n5958 0.185486
R19247 VSS.n5889 VSS.n5888 0.185486
R19248 VSS.n642 VSS.n641 0.185486
R19249 VSS.n5680 VSS.n5679 0.185486
R19250 VSS.n5774 VSS.n5773 0.185486
R19251 VSS.n471 VSS.n470 0.185486
R19252 VSS.n431 VSS.n430 0.185486
R19253 VSS.n545 VSS.n544 0.185486
R19254 VSS.n5196 VSS.n5191 0.185486
R19255 VSS.n5148 VSS.n5143 0.185486
R19256 VSS.n5081 VSS.n5076 0.185486
R19257 VSS.n4923 VSS.n4918 0.185486
R19258 VSS.n5014 VSS.n5009 0.185486
R19259 VSS.n5270 VSS.n5265 0.185486
R19260 VSS.n5522 VSS.n5517 0.185486
R19261 VSS.n847 VSS.n842 0.185486
R19262 VSS.n5474 VSS.n5469 0.185486
R19263 VSS.n1072 VSS.n1067 0.185486
R19264 VSS.n1004 VSS.n999 0.185486
R19265 VSS.n937 VSS.n932 0.185486
R19266 VSS.n1711 VSS.n1706 0.185486
R19267 VSS.n1403 VSS.n1398 0.185486
R19268 VSS.n1496 VSS.n1491 0.185486
R19269 VSS.n1644 VSS.n1639 0.185486
R19270 VSS.n1569 VSS.n1564 0.185486
R19271 VSS.n4069 VSS.n4064 0.185486
R19272 VSS.n1277 VSS.n1267 0.185486
R19273 VSS.n2911 VSS.n2901 0.185486
R19274 VSS.n2885 VSS.n2875 0.185486
R19275 VSS.n2975 VSS.n2965 0.185486
R19276 VSS.n3129 VSS.n3119 0.185486
R19277 VSS.n3200 VSS.n3190 0.185486
R19278 VSS.n3264 VSS.n3254 0.185486
R19279 VSS.n1453 VSS.n1442 0.185486
R19280 VSS.n897 VSS.n886 0.185486
R19281 VSS.n4973 VSS.n4962 0.185486
R19282 VSS.n2477 VSS.n2472 0.185486
R19283 VSS.n3363 VSS.n3358 0.185486
R19284 VSS.n2403 VSS.n2398 0.185486
R19285 VSS.n3435 VSS.n3424 0.185486
R19286 VSS.n2184 VSS.n2173 0.185486
R19287 VSS.n2056 VSS.n2021 0.183474
R19288 VSS.n159 VSS 0.180825
R19289 VSS.n4726 VSS.n4725 0.180789
R19290 VSS.n1997 VSS 0.180486
R19291 VSS.n1369 VSS.n1368 0.178583
R19292 VSS.n4269 VSS.n4268 0.178325
R19293 VSS.n3931 VSS.n3930 0.178325
R19294 VSS.n3864 VSS.n3863 0.178325
R19295 VSS.n3657 VSS.n3656 0.178325
R19296 VSS.n3797 VSS.n3796 0.178325
R19297 VSS.n3749 VSS.n3748 0.178325
R19298 VSS.n3701 VSS.n3700 0.178325
R19299 VSS.n2325 VSS.n2324 0.178325
R19300 VSS.n2556 VSS.n2555 0.178325
R19301 VSS.n525 VSS.n524 0.178325
R19302 VSS.n5203 VSS.n5202 0.178325
R19303 VSS.n5155 VSS.n5154 0.178325
R19304 VSS.n5088 VSS.n5087 0.178325
R19305 VSS.n4930 VSS.n4929 0.178325
R19306 VSS.n5021 VSS.n5020 0.178325
R19307 VSS.n5277 VSS.n5276 0.178325
R19308 VSS.n5529 VSS.n5528 0.178325
R19309 VSS.n854 VSS.n853 0.178325
R19310 VSS.n5481 VSS.n5480 0.178325
R19311 VSS.n1079 VSS.n1078 0.178325
R19312 VSS.n1011 VSS.n1010 0.178325
R19313 VSS.n944 VSS.n943 0.178325
R19314 VSS.n1718 VSS.n1717 0.178325
R19315 VSS.n1410 VSS.n1409 0.178325
R19316 VSS.n1503 VSS.n1502 0.178325
R19317 VSS.n1651 VSS.n1650 0.178325
R19318 VSS.n1576 VSS.n1575 0.178325
R19319 VSS.n4076 VSS.n4075 0.178325
R19320 VSS.n1286 VSS.n1285 0.178325
R19321 VSS.n2920 VSS.n2919 0.178325
R19322 VSS.n2894 VSS.n2893 0.178325
R19323 VSS.n2984 VSS.n2983 0.178325
R19324 VSS.n3138 VSS.n3137 0.178325
R19325 VSS.n3209 VSS.n3208 0.178325
R19326 VSS.n3273 VSS.n3272 0.178325
R19327 VSS.n1462 VSS.n1461 0.178325
R19328 VSS.n906 VSS.n905 0.178325
R19329 VSS.n4982 VSS.n4981 0.178325
R19330 VSS.n2484 VSS.n2483 0.178325
R19331 VSS.n3370 VSS.n3369 0.178325
R19332 VSS.n2410 VSS.n2409 0.178325
R19333 VSS.n3444 VSS.n3443 0.178325
R19334 VSS.n2193 VSS.n2192 0.178325
R19335 VSS.n4700 VSS.n4210 0.178154
R19336 VSS.n4552 VSS.n4551 0.177986
R19337 VSS.n4301 VSS.n4300 0.177986
R19338 VSS.n4389 VSS.n4388 0.177986
R19339 VSS.n4428 VSS.n4427 0.177986
R19340 VSS.n186 VSS.n185 0.177986
R19341 VSS.n262 VSS.n261 0.177986
R19342 VSS.n107 VSS.n106 0.177986
R19343 VSS.n2264 VSS.n2263 0.177986
R19344 VSS.n4771 VSS.n4770 0.177986
R19345 VSS.n4805 VSS.n4804 0.177986
R19346 VSS.n1147 VSS.n1146 0.177986
R19347 VSS.n3025 VSS.n3024 0.177986
R19348 VSS.n2230 VSS.n2229 0.177986
R19349 VSS.n5938 VSS.n5937 0.177986
R19350 VSS.n5868 VSS.n5867 0.177986
R19351 VSS.n621 VSS.n620 0.177986
R19352 VSS.n5659 VSS.n5658 0.177986
R19353 VSS.n5753 VSS.n5752 0.177986
R19354 VSS.n450 VSS.n449 0.177986
R19355 VSS.n408 VSS.n407 0.177986
R19356 VSS.n1991 VSS.n1990 0.177986
R19357 VSS.n4738 VSS.n4210 0.1765
R19358 VSS.n2056 VSS.n2027 0.174261
R19359 VSS.n2056 VSS.n2024 0.174261
R19360 VSS.t2404 VSS.n1780 0.174071
R19361 VSS.t2403 VSS.n1784 0.174071
R19362 VSS.n5608 VSS.n5607 0.17398
R19363 VSS.n5598 VSS.n5596 0.173673
R19364 VSS.n1172 VSS.n1170 0.173366
R19365 VSS.n727 VSS.n725 0.173059
R19366 VSS.n1889 VSS.n1887 0.172752
R19367 VSS.n5807 VSS.n5805 0.172752
R19368 VSS.n2522 VSS.n2521 0.172445
R19369 VSS.n802 VSS.n800 0.172445
R19370 VSS.n2216 VSS.n2214 0.172138
R19371 VSS.n3408 VSS.n3407 0.172138
R19372 VSS.n4895 VSS.n4894 0.172138
R19373 VSS.n1764 VSS.n1763 0.172138
R19374 VSS.n5397 VSS.n5392 0.171831
R19375 VSS.n4201 VSS.n4200 0.171524
R19376 VSS.n5575 VSS.n5574 0.171524
R19377 VSS.n3159 VSS.n3158 0.171217
R19378 VSS.n3547 VSS.n3546 0.171217
R19379 VSS.n1375 VSS.n1374 0.171217
R19380 VSS.n4525 VSS.n4524 0.171063
R19381 VSS.n2375 VSS.n2374 0.17091
R19382 VSS.n1689 VSS.n1688 0.17091
R19383 VSS.n3622 VSS.n3621 0.170604
R19384 VSS.n2853 VSS.n2852 0.170297
R19385 VSS.n1905 VSS.n1903 0.170297
R19386 VSS.n3335 VSS.n3334 0.170297
R19387 VSS.n5817 VSS.n5816 0.170297
R19388 VSS.n819 VSS.n818 0.170297
R19389 VSS.n5801 VSS.n5799 0.16999
R19390 VSS.n2448 VSS.n2447 0.169683
R19391 VSS.n5340 VSS.n5339 0.169683
R19392 VSS.n5453 VSS.n5452 0.169683
R19393 VSS.n170 VSS.n169 0.169575
R19394 VSS.n5316 VSS.n5315 0.169376
R19395 VSS.n810 VSS.n808 0.169376
R19396 VSS.n4114 VSS.n4113 0.169376
R19397 VSS.n1202 VSS.n1200 0.169376
R19398 VSS.n161 VSS.n159 0.169236
R19399 VSS.n4141 VSS.n4139 0.169069
R19400 VSS.t3155 VSS.n2138 0.168775
R19401 VSS.n3088 VSS.n3087 0.168762
R19402 VSS.n2847 VSS.n2846 0.168455
R19403 VSS.n4006 VSS.n4004 0.168455
R19404 VSS.n3976 VSS.n3975 0.168148
R19405 VSS.n4363 VSS.n4362 0.167994
R19406 VSS.n4151 VSS.n4150 0.167841
R19407 VSS.n5843 VSS.n5842 0.167841
R19408 VSS.n1360 VSS.n1359 0.167534
R19409 VSS.n5728 VSS.n5727 0.167228
R19410 VSS.n4673 VSS.n4672 0.167087
R19411 VSS.n2153 VSS.n2151 0.166921
R19412 VSS.n5913 VSS.n5912 0.166921
R19413 VSS.n1615 VSS.n1614 0.166921
R19414 VSS.n4355 VSS.n4354 0.166766
R19415 VSS.n4000 VSS.n3998 0.166614
R19416 VSS.n317 VSS.n316 0.166459
R19417 VSS.n585 VSS.n583 0.166307
R19418 VSS.n6244 VSS.n6243 0.165538
R19419 VSS.n4482 VSS.n4481 0.165538
R19420 VSS.n6150 VSS.n6149 0.165538
R19421 VSS.n4751 VSS.n4749 0.165386
R19422 VSS.n5983 VSS.n5981 0.165386
R19423 VSS.n3325 VSS.n3324 0.165079
R19424 VSS.n6161 VSS.n6160 0.164924
R19425 VSS.n5633 VSS.n5632 0.164465
R19426 VSS.n5702 VSS.n5701 0.164465
R19427 VSS.n2687 VSS.n2683 0.163516
R19428 VSS.n4559 VSS.n4557 0.163289
R19429 VSS.n4308 VSS.n4306 0.163289
R19430 VSS.n4399 VSS.n4397 0.163289
R19431 VSS.n4435 VSS.n4433 0.163289
R19432 VSS.n196 VSS.n194 0.163289
R19433 VSS.n272 VSS.n270 0.163289
R19434 VSS.n109 VSS.n108 0.163289
R19435 VSS.n4264 VSS.n4263 0.163289
R19436 VSS.n3927 VSS.n3926 0.163289
R19437 VSS.n3860 VSS.n3859 0.163289
R19438 VSS.n3653 VSS.n3652 0.163289
R19439 VSS.n3793 VSS.n3792 0.163289
R19440 VSS.n3745 VSS.n3744 0.163289
R19441 VSS.n3697 VSS.n3696 0.163289
R19442 VSS.n2321 VSS.n2320 0.163289
R19443 VSS.n2552 VSS.n2551 0.163289
R19444 VSS.n2273 VSS.n2271 0.163289
R19445 VSS.n4777 VSS.n4776 0.163289
R19446 VSS.n4814 VSS.n4812 0.163289
R19447 VSS.n1156 VSS.n1154 0.163289
R19448 VSS.n3034 VSS.n3032 0.163289
R19449 VSS.n2236 VSS.n2235 0.163289
R19450 VSS.n5947 VSS.n5945 0.163289
R19451 VSS.n5877 VSS.n5875 0.163289
R19452 VSS.n630 VSS.n628 0.163289
R19453 VSS.n5668 VSS.n5666 0.163289
R19454 VSS.n5762 VSS.n5760 0.163289
R19455 VSS.n459 VSS.n457 0.163289
R19456 VSS.n418 VSS.n416 0.163289
R19457 VSS.n533 VSS.n531 0.163289
R19458 VSS.n5199 VSS.n5198 0.163289
R19459 VSS.n5151 VSS.n5150 0.163289
R19460 VSS.n5084 VSS.n5083 0.163289
R19461 VSS.n4926 VSS.n4925 0.163289
R19462 VSS.n5017 VSS.n5016 0.163289
R19463 VSS.n5273 VSS.n5272 0.163289
R19464 VSS.n5525 VSS.n5524 0.163289
R19465 VSS.n850 VSS.n849 0.163289
R19466 VSS.n5477 VSS.n5476 0.163289
R19467 VSS.n1075 VSS.n1074 0.163289
R19468 VSS.n1007 VSS.n1006 0.163289
R19469 VSS.n940 VSS.n939 0.163289
R19470 VSS.n1714 VSS.n1713 0.163289
R19471 VSS.n1406 VSS.n1405 0.163289
R19472 VSS.n1499 VSS.n1498 0.163289
R19473 VSS.n1647 VSS.n1646 0.163289
R19474 VSS.n1572 VSS.n1571 0.163289
R19475 VSS.n4072 VSS.n4071 0.163289
R19476 VSS.n1281 VSS.n1280 0.163289
R19477 VSS.n2915 VSS.n2914 0.163289
R19478 VSS.n2889 VSS.n2888 0.163289
R19479 VSS.n2979 VSS.n2978 0.163289
R19480 VSS.n3133 VSS.n3132 0.163289
R19481 VSS.n3204 VSS.n3203 0.163289
R19482 VSS.n3268 VSS.n3267 0.163289
R19483 VSS.n1457 VSS.n1456 0.163289
R19484 VSS.n901 VSS.n900 0.163289
R19485 VSS.n4977 VSS.n4976 0.163289
R19486 VSS.n2480 VSS.n2479 0.163289
R19487 VSS.n3366 VSS.n3365 0.163289
R19488 VSS.n2406 VSS.n2405 0.163289
R19489 VSS.n2012 VSS.n2011 0.163289
R19490 VSS.n3439 VSS.n3438 0.163289
R19491 VSS.n2188 VSS.n2187 0.163289
R19492 VSS.n4566 VSS.n4565 0.162655
R19493 VSS.n4315 VSS.n4314 0.162655
R19494 VSS.n4406 VSS.n4405 0.162655
R19495 VSS.n4442 VSS.n4441 0.162655
R19496 VSS.n203 VSS.n202 0.162655
R19497 VSS.n279 VSS.n278 0.162655
R19498 VSS.n113 VSS.n112 0.162655
R19499 VSS.n4255 VSS.n4253 0.162655
R19500 VSS.n4224 VSS.n4223 0.162655
R19501 VSS.n3921 VSS.n3920 0.162655
R19502 VSS.n3854 VSS.n3853 0.162655
R19503 VSS.n3647 VSS.n3646 0.162655
R19504 VSS.n3787 VSS.n3786 0.162655
R19505 VSS.n3739 VSS.n3738 0.162655
R19506 VSS.n3691 VSS.n3690 0.162655
R19507 VSS.n2315 VSS.n2314 0.162655
R19508 VSS.n2546 VSS.n2545 0.162655
R19509 VSS.n2280 VSS.n2279 0.162655
R19510 VSS.n4781 VSS.n4780 0.162655
R19511 VSS.n4821 VSS.n4820 0.162655
R19512 VSS.n1163 VSS.n1162 0.162655
R19513 VSS.n3041 VSS.n3040 0.162655
R19514 VSS.n2240 VSS.n2239 0.162655
R19515 VSS.n5954 VSS.n5953 0.162655
R19516 VSS.n5884 VSS.n5883 0.162655
R19517 VSS.n637 VSS.n636 0.162655
R19518 VSS.n5675 VSS.n5674 0.162655
R19519 VSS.n5769 VSS.n5768 0.162655
R19520 VSS.n466 VSS.n465 0.162655
R19521 VSS.n425 VSS.n424 0.162655
R19522 VSS.n540 VSS.n539 0.162655
R19523 VSS.n5193 VSS.n5192 0.162655
R19524 VSS.n5145 VSS.n5144 0.162655
R19525 VSS.n5078 VSS.n5077 0.162655
R19526 VSS.n4920 VSS.n4919 0.162655
R19527 VSS.n5011 VSS.n5010 0.162655
R19528 VSS.n5267 VSS.n5266 0.162655
R19529 VSS.n5519 VSS.n5518 0.162655
R19530 VSS.n844 VSS.n843 0.162655
R19531 VSS.n5471 VSS.n5470 0.162655
R19532 VSS.n1069 VSS.n1068 0.162655
R19533 VSS.n1001 VSS.n1000 0.162655
R19534 VSS.n934 VSS.n933 0.162655
R19535 VSS.n1708 VSS.n1707 0.162655
R19536 VSS.n1400 VSS.n1399 0.162655
R19537 VSS.n1493 VSS.n1492 0.162655
R19538 VSS.n1641 VSS.n1640 0.162655
R19539 VSS.n1566 VSS.n1565 0.162655
R19540 VSS.n4066 VSS.n4065 0.162655
R19541 VSS.n1272 VSS.n1270 0.162655
R19542 VSS.n2906 VSS.n2904 0.162655
R19543 VSS.n2880 VSS.n2878 0.162655
R19544 VSS.n2970 VSS.n2968 0.162655
R19545 VSS.n3124 VSS.n3122 0.162655
R19546 VSS.n3195 VSS.n3193 0.162655
R19547 VSS.n3259 VSS.n3257 0.162655
R19548 VSS.n1448 VSS.n1446 0.162655
R19549 VSS.n892 VSS.n890 0.162655
R19550 VSS.n4968 VSS.n4966 0.162655
R19551 VSS.n2474 VSS.n2473 0.162655
R19552 VSS.n3360 VSS.n3359 0.162655
R19553 VSS.n2400 VSS.n2399 0.162655
R19554 VSS.n3430 VSS.n3428 0.162655
R19555 VSS.n2179 VSS.n2177 0.162655
R19556 VSS.n3562 VSS.n2117 0.160185
R19557 VSS.n4016 VSS.n4015 0.158941
R19558 VSS.n4580 VSS.n4552 0.158325
R19559 VSS.n4329 VSS.n4301 0.158325
R19560 VSS.n4504 VSS.n4389 0.158325
R19561 VSS.n4456 VSS.n4428 0.158325
R19562 VSS.n218 VSS.n186 0.158325
R19563 VSS.n293 VSS.n262 0.158325
R19564 VSS.n118 VSS.n107 0.158325
R19565 VSS.n2296 VSS.n2264 0.158325
R19566 VSS.n4789 VSS.n4771 0.158325
R19567 VSS.n4835 VSS.n4805 0.158325
R19568 VSS.n5418 VSS.n1147 0.158325
R19569 VSS.n3056 VSS.n3025 0.158325
R19570 VSS.n2248 VSS.n2230 0.158325
R19571 VSS.n5967 VSS.n5938 0.158325
R19572 VSS.n5897 VSS.n5868 0.158325
R19573 VSS.n650 VSS.n621 0.158325
R19574 VSS.n5688 VSS.n5659 0.158325
R19575 VSS.n5782 VSS.n5753 0.158325
R19576 VSS.n479 VSS.n450 0.158325
R19577 VSS.n6001 VSS.n408 0.158325
R19578 VSS.n2002 VSS.n1991 0.158325
R19579 VSS.n4605 VSS.n4545 0.158289
R19580 VSS.n4533 VSS.n4294 0.158289
R19581 VSS.n4382 VSS.n4380 0.158289
R19582 VSS.n4489 VSS.n4421 0.158289
R19583 VSS.n6169 VSS.n179 0.158289
R19584 VSS.n255 VSS.n253 0.158289
R19585 VSS.n6227 VSS.n101 0.158289
R19586 VSS.n4273 VSS.n4272 0.158289
R19587 VSS.n3984 VSS.n3915 0.158289
R19588 VSS.n3910 VSS.n3848 0.158289
R19589 VSS.n3641 VSS.n3639 0.158289
R19590 VSS.n3843 VSS.n3781 0.158289
R19591 VSS.n3776 VSS.n3733 0.158289
R19592 VSS.n3728 VSS.n3685 0.158289
R19593 VSS.n3415 VSS.n2309 0.158289
R19594 VSS.n2540 VSS.n2538 0.158289
R19595 VSS.n2302 VSS.n2257 0.158289
R19596 VSS.n4795 VSS.n4764 0.158289
R19597 VSS.n4841 VSS.n4798 0.158289
R19598 VSS.n5424 VSS.n1140 0.158289
R19599 VSS.n3062 VSS.n3018 0.158289
R19600 VSS.n2254 VSS.n2223 0.158289
R19601 VSS.n5931 VSS.n5929 0.158289
R19602 VSS.n5861 VSS.n5859 0.158289
R19603 VSS.n614 VSS.n612 0.158289
R19604 VSS.n5652 VSS.n5650 0.158289
R19605 VSS.n5746 VSS.n5744 0.158289
R19606 VSS.n484 VSS.n443 0.158289
R19607 VSS.n6007 VSS.n401 0.158289
R19608 VSS.n517 VSS.n515 0.158289
R19609 VSS.n5323 VSS.n5187 0.158289
R19610 VSS.n5182 VSS.n5139 0.158289
R19611 VSS.n5134 VSS.n5072 0.158289
R19612 VSS.n4914 VSS.n4912 0.158289
R19613 VSS.n5067 VSS.n5005 0.158289
R19614 VSS.n5261 VSS.n5259 0.158289
R19615 VSS.n5582 VSS.n5513 0.158289
R19616 VSS.n838 VSS.n836 0.158289
R19617 VSS.n5508 VSS.n5465 0.158289
R19618 VSS.n5460 VSS.n1063 0.158289
R19619 VSS.n1058 VSS.n995 0.158289
R19620 VSS.n990 VSS.n928 0.158289
R19621 VSS.n4121 VSS.n1702 0.158289
R19622 VSS.n1394 VSS.n1392 0.158289
R19623 VSS.n1697 VSS.n1487 0.158289
R19624 VSS.n1635 VSS.n1633 0.158289
R19625 VSS.n1560 VSS.n1558 0.158289
R19626 VSS.n4060 VSS.n4058 0.158289
R19627 VSS.n4170 VSS.n4169 0.158289
R19628 VSS.n2943 VSS.n2942 0.158289
R19629 VSS.n3296 VSS.n2869 0.158289
R19630 VSS.n3097 VSS.n3096 0.158289
R19631 VSS.n3168 VSS.n3167 0.158289
R19632 VSS.n3232 VSS.n3231 0.158289
R19633 VSS.n3277 VSS.n3276 0.158289
R19634 VSS.n1466 VSS.n1465 0.158289
R19635 VSS.n910 VSS.n909 0.158289
R19636 VSS.n4986 VSS.n4985 0.158289
R19637 VSS.n2468 VSS.n2466 0.158289
R19638 VSS.n3354 VSS.n3352 0.158289
R19639 VSS.n2394 VSS.n2392 0.158289
R19640 VSS.n3570 VSS.n1984 0.158289
R19641 VSS.n3448 VSS.n3447 0.158289
R19642 VSS.n2197 VSS.n2196 0.158289
R19643 VSS.n4281 VSS.n4268 0.157986
R19644 VSS.n3932 VSS.n3931 0.157986
R19645 VSS.n3865 VSS.n3864 0.157986
R19646 VSS.n3658 VSS.n3657 0.157986
R19647 VSS.n3798 VSS.n3797 0.157986
R19648 VSS.n3750 VSS.n3749 0.157986
R19649 VSS.n3702 VSS.n3701 0.157986
R19650 VSS.n2326 VSS.n2325 0.157986
R19651 VSS.n2557 VSS.n2556 0.157986
R19652 VSS.n553 VSS.n525 0.157986
R19653 VSS.n5204 VSS.n5203 0.157986
R19654 VSS.n5156 VSS.n5155 0.157986
R19655 VSS.n5089 VSS.n5088 0.157986
R19656 VSS.n4931 VSS.n4930 0.157986
R19657 VSS.n5022 VSS.n5021 0.157986
R19658 VSS.n5278 VSS.n5277 0.157986
R19659 VSS.n5530 VSS.n5529 0.157986
R19660 VSS.n855 VSS.n854 0.157986
R19661 VSS.n5482 VSS.n5481 0.157986
R19662 VSS.n1080 VSS.n1079 0.157986
R19663 VSS.n1012 VSS.n1011 0.157986
R19664 VSS.n945 VSS.n944 0.157986
R19665 VSS.n1719 VSS.n1718 0.157986
R19666 VSS.n1411 VSS.n1410 0.157986
R19667 VSS.n1504 VSS.n1503 0.157986
R19668 VSS.n1652 VSS.n1651 0.157986
R19669 VSS.n1577 VSS.n1576 0.157986
R19670 VSS.n4077 VSS.n4076 0.157986
R19671 VSS.n4178 VSS.n1285 0.157986
R19672 VSS.n2951 VSS.n2919 0.157986
R19673 VSS.n3304 VSS.n2893 0.157986
R19674 VSS.n3105 VSS.n2983 0.157986
R19675 VSS.n3176 VSS.n3137 0.157986
R19676 VSS.n3240 VSS.n3208 0.157986
R19677 VSS.n3285 VSS.n3272 0.157986
R19678 VSS.n1474 VSS.n1461 0.157986
R19679 VSS.n918 VSS.n905 0.157986
R19680 VSS.n4994 VSS.n4981 0.157986
R19681 VSS.n2485 VSS.n2484 0.157986
R19682 VSS.n3371 VSS.n3370 0.157986
R19683 VSS.n2411 VSS.n2410 0.157986
R19684 VSS.n3456 VSS.n3443 0.157986
R19685 VSS.n2205 VSS.n2192 0.157986
R19686 VSS.n3586 VSS.n1922 0.156789
R19687 VSS.n1979 VSS 0.15675
R19688 VSS.n4726 VSS 0.155789
R19689 VSS.n4570 VSS.n4563 0.154539
R19690 VSS.n4319 VSS.n4312 0.154539
R19691 VSS.n4410 VSS.n4403 0.154539
R19692 VSS.n4446 VSS.n4439 0.154539
R19693 VSS.n206 VSS.n200 0.154539
R19694 VSS.n282 VSS.n276 0.154539
R19695 VSS.n114 VSS.n111 0.154539
R19696 VSS.n4257 VSS.n4256 0.154539
R19697 VSS.n6191 VSS.n6190 0.154539
R19698 VSS.n4228 VSS.n4220 0.154539
R19699 VSS.n4626 VSS.n4625 0.154539
R19700 VSS.n3923 VSS.n3922 0.154539
R19701 VSS.n3856 VSS.n3855 0.154539
R19702 VSS.n3649 VSS.n3648 0.154539
R19703 VSS.n3789 VSS.n3788 0.154539
R19704 VSS.n3741 VSS.n3740 0.154539
R19705 VSS.n3693 VSS.n3692 0.154539
R19706 VSS.n2317 VSS.n2316 0.154539
R19707 VSS.n2548 VSS.n2547 0.154539
R19708 VSS.n2286 VSS.n2277 0.154539
R19709 VSS.n4784 VSS.n4779 0.154539
R19710 VSS.n4825 VSS.n4818 0.154539
R19711 VSS.n5408 VSS.n1160 0.154539
R19712 VSS.n3046 VSS.n3038 0.154539
R19713 VSS.n2243 VSS.n2238 0.154539
R19714 VSS.n5957 VSS.n5951 0.154539
R19715 VSS.n5887 VSS.n5881 0.154539
R19716 VSS.n640 VSS.n634 0.154539
R19717 VSS.n5678 VSS.n5672 0.154539
R19718 VSS.n5772 VSS.n5766 0.154539
R19719 VSS.n469 VSS.n463 0.154539
R19720 VSS.n429 VSS.n422 0.154539
R19721 VSS.n543 VSS.n537 0.154539
R19722 VSS.n5195 VSS.n5194 0.154539
R19723 VSS.n5147 VSS.n5146 0.154539
R19724 VSS.n5080 VSS.n5079 0.154539
R19725 VSS.n4922 VSS.n4921 0.154539
R19726 VSS.n5013 VSS.n5012 0.154539
R19727 VSS.n5269 VSS.n5268 0.154539
R19728 VSS.n5521 VSS.n5520 0.154539
R19729 VSS.n846 VSS.n845 0.154539
R19730 VSS.n5473 VSS.n5472 0.154539
R19731 VSS.n1071 VSS.n1070 0.154539
R19732 VSS.n1003 VSS.n1002 0.154539
R19733 VSS.n936 VSS.n935 0.154539
R19734 VSS.n1710 VSS.n1709 0.154539
R19735 VSS.n1402 VSS.n1401 0.154539
R19736 VSS.n1495 VSS.n1494 0.154539
R19737 VSS.n1643 VSS.n1642 0.154539
R19738 VSS.n1568 VSS.n1567 0.154539
R19739 VSS.n4068 VSS.n4067 0.154539
R19740 VSS.n1274 VSS.n1273 0.154539
R19741 VSS.n2908 VSS.n2907 0.154539
R19742 VSS.n2882 VSS.n2881 0.154539
R19743 VSS.n2972 VSS.n2971 0.154539
R19744 VSS.n3126 VSS.n3125 0.154539
R19745 VSS.n3197 VSS.n3196 0.154539
R19746 VSS.n3261 VSS.n3260 0.154539
R19747 VSS.n1450 VSS.n1449 0.154539
R19748 VSS.n894 VSS.n893 0.154539
R19749 VSS.n4970 VSS.n4969 0.154539
R19750 VSS.n2476 VSS.n2475 0.154539
R19751 VSS.n3362 VSS.n3361 0.154539
R19752 VSS.n2402 VSS.n2401 0.154539
R19753 VSS.n3432 VSS.n3431 0.154539
R19754 VSS.n2181 VSS.n2180 0.154539
R19755 VSS.n1944 VSS.n1928 0.154288
R19756 VSS.n2084 VSS.n2083 0.153995
R19757 VSS.n6192 VSS.n148 0.153289
R19758 VSS.n6187 VSS.n6186 0.153289
R19759 VSS.n6215 VSS.n6214 0.153289
R19760 VSS.n4218 VSS.n4217 0.153289
R19761 VSS.n4706 VSS.n4705 0.153289
R19762 VSS.n2797 VSS.n1834 0.151747
R19763 VSS.n4213 VSS 0.151469
R19764 VSS.n2093 VSS.n2092 0.150859
R19765 VSS.t2274 VSS.n1220 0.149873
R19766 VSS.t2273 VSS.n1223 0.149873
R19767 VSS.t3120 VSS.n750 0.149873
R19768 VSS.t3119 VSS.n754 0.149873
R19769 VSS.t2258 VSS.n676 0.149873
R19770 VSS.t2257 VSS.n679 0.149873
R19771 VSS.t2349 VSS.n507 0.149873
R19772 VSS.t2348 VSS.n510 0.149873
R19773 VSS.t2333 VSS.n1299 0.149873
R19774 VSS.t2332 VSS.n1302 0.149873
R19775 VSS.n6217 VSS.n138 0.149318
R19776 VSS.n4733 VSS 0.14925
R19777 VSS.n4572 VSS.n4570 0.147075
R19778 VSS.n4321 VSS.n4319 0.147075
R19779 VSS.n4412 VSS.n4410 0.147075
R19780 VSS.n4448 VSS.n4446 0.147075
R19781 VSS.n208 VSS.n206 0.147075
R19782 VSS.n284 VSS.n282 0.147075
R19783 VSS.n116 VSS.n114 0.147075
R19784 VSS.n4256 VSS.n4250 0.147075
R19785 VSS.n3922 VSS.n3919 0.147075
R19786 VSS.n3855 VSS.n3852 0.147075
R19787 VSS.n3648 VSS.n3645 0.147075
R19788 VSS.n3788 VSS.n3785 0.147075
R19789 VSS.n3740 VSS.n3737 0.147075
R19790 VSS.n3692 VSS.n3689 0.147075
R19791 VSS.n2316 VSS.n2313 0.147075
R19792 VSS.n2547 VSS.n2544 0.147075
R19793 VSS.n2288 VSS.n2286 0.147075
R19794 VSS.n4786 VSS.n4784 0.147075
R19795 VSS.n4827 VSS.n4825 0.147075
R19796 VSS.n5410 VSS.n5408 0.147075
R19797 VSS.n3048 VSS.n3046 0.147075
R19798 VSS.n2245 VSS.n2243 0.147075
R19799 VSS.n5959 VSS.n5957 0.147075
R19800 VSS.n5889 VSS.n5887 0.147075
R19801 VSS.n642 VSS.n640 0.147075
R19802 VSS.n5680 VSS.n5678 0.147075
R19803 VSS.n5774 VSS.n5772 0.147075
R19804 VSS.n471 VSS.n469 0.147075
R19805 VSS.n431 VSS.n429 0.147075
R19806 VSS.n545 VSS.n543 0.147075
R19807 VSS.n5194 VSS.n5191 0.147075
R19808 VSS.n5146 VSS.n5143 0.147075
R19809 VSS.n5079 VSS.n5076 0.147075
R19810 VSS.n4921 VSS.n4918 0.147075
R19811 VSS.n5012 VSS.n5009 0.147075
R19812 VSS.n5268 VSS.n5265 0.147075
R19813 VSS.n5520 VSS.n5517 0.147075
R19814 VSS.n845 VSS.n842 0.147075
R19815 VSS.n5472 VSS.n5469 0.147075
R19816 VSS.n1070 VSS.n1067 0.147075
R19817 VSS.n1002 VSS.n999 0.147075
R19818 VSS.n935 VSS.n932 0.147075
R19819 VSS.n1709 VSS.n1706 0.147075
R19820 VSS.n1401 VSS.n1398 0.147075
R19821 VSS.n1494 VSS.n1491 0.147075
R19822 VSS.n1642 VSS.n1639 0.147075
R19823 VSS.n1567 VSS.n1564 0.147075
R19824 VSS.n4067 VSS.n4064 0.147075
R19825 VSS.n1273 VSS.n1267 0.147075
R19826 VSS.n2907 VSS.n2901 0.147075
R19827 VSS.n2881 VSS.n2875 0.147075
R19828 VSS.n2971 VSS.n2965 0.147075
R19829 VSS.n3125 VSS.n3119 0.147075
R19830 VSS.n3196 VSS.n3190 0.147075
R19831 VSS.n3260 VSS.n3254 0.147075
R19832 VSS.n1449 VSS.n1442 0.147075
R19833 VSS.n893 VSS.n886 0.147075
R19834 VSS.n4969 VSS.n4962 0.147075
R19835 VSS.n2475 VSS.n2472 0.147075
R19836 VSS.n3361 VSS.n3358 0.147075
R19837 VSS.n2401 VSS.n2398 0.147075
R19838 VSS.n3431 VSS.n3424 0.147075
R19839 VSS.n2180 VSS.n2173 0.147075
R19840 VSS.n4548 VSS.n4547 0.145789
R19841 VSS.n4297 VSS.n4296 0.145789
R19842 VSS.n4385 VSS.n4384 0.145789
R19843 VSS.n4424 VSS.n4423 0.145789
R19844 VSS.n182 VSS.n181 0.145789
R19845 VSS.n258 VSS.n257 0.145789
R19846 VSS.n103 VSS.n102 0.145789
R19847 VSS.n4278 VSS.n4276 0.145789
R19848 VSS.n3918 VSS.n3917 0.145789
R19849 VSS.n3851 VSS.n3850 0.145789
R19850 VSS.n3644 VSS.n3643 0.145789
R19851 VSS.n3784 VSS.n3783 0.145789
R19852 VSS.n3736 VSS.n3735 0.145789
R19853 VSS.n3688 VSS.n3687 0.145789
R19854 VSS.n2312 VSS.n2311 0.145789
R19855 VSS.n2543 VSS.n2542 0.145789
R19856 VSS.n2260 VSS.n2259 0.145789
R19857 VSS.n4767 VSS.n4766 0.145789
R19858 VSS.n4801 VSS.n4800 0.145789
R19859 VSS.n1143 VSS.n1142 0.145789
R19860 VSS.n3021 VSS.n3020 0.145789
R19861 VSS.n2226 VSS.n2225 0.145789
R19862 VSS.n5934 VSS.n5933 0.145789
R19863 VSS.n5864 VSS.n5863 0.145789
R19864 VSS.n617 VSS.n616 0.145789
R19865 VSS.n5655 VSS.n5654 0.145789
R19866 VSS.n5749 VSS.n5748 0.145789
R19867 VSS.n446 VSS.n445 0.145789
R19868 VSS.n404 VSS.n403 0.145789
R19869 VSS.n520 VSS.n519 0.145789
R19870 VSS.n5190 VSS.n5189 0.145789
R19871 VSS.n5142 VSS.n5141 0.145789
R19872 VSS.n5075 VSS.n5074 0.145789
R19873 VSS.n4917 VSS.n4916 0.145789
R19874 VSS.n5008 VSS.n5007 0.145789
R19875 VSS.n5264 VSS.n5263 0.145789
R19876 VSS.n5516 VSS.n5515 0.145789
R19877 VSS.n841 VSS.n840 0.145789
R19878 VSS.n5468 VSS.n5467 0.145789
R19879 VSS.n1066 VSS.n1065 0.145789
R19880 VSS.n998 VSS.n997 0.145789
R19881 VSS.n931 VSS.n930 0.145789
R19882 VSS.n1705 VSS.n1704 0.145789
R19883 VSS.n1397 VSS.n1396 0.145789
R19884 VSS.n1490 VSS.n1489 0.145789
R19885 VSS.n1638 VSS.n1637 0.145789
R19886 VSS.n1563 VSS.n1562 0.145789
R19887 VSS.n4063 VSS.n4062 0.145789
R19888 VSS.n4175 VSS.n4173 0.145789
R19889 VSS.n2948 VSS.n2946 0.145789
R19890 VSS.n3301 VSS.n3299 0.145789
R19891 VSS.n3102 VSS.n3100 0.145789
R19892 VSS.n3173 VSS.n3171 0.145789
R19893 VSS.n3237 VSS.n3235 0.145789
R19894 VSS.n3282 VSS.n3280 0.145789
R19895 VSS.n1471 VSS.n1469 0.145789
R19896 VSS.n915 VSS.n913 0.145789
R19897 VSS.n4991 VSS.n4989 0.145789
R19898 VSS.n2471 VSS.n2470 0.145789
R19899 VSS.n3357 VSS.n3356 0.145789
R19900 VSS.n2397 VSS.n2396 0.145789
R19901 VSS.n1987 VSS.n1986 0.145789
R19902 VSS.n3453 VSS.n3451 0.145789
R19903 VSS.n2202 VSS.n2200 0.145789
R19904 VSS.n2053 VSS.n2031 0.143904
R19905 VSS.n2046 VSS.n2031 0.143904
R19906 VSS.n2003 VSS.n2002 0.143289
R19907 VSS.n168 VSS.n152 0.140661
R19908 VSS.n2011 VSS.n1997 0.138325
R19909 VSS.n163 VSS.n161 0.132039
R19910 VSS.n4716 VSS.n4714 0.132039
R19911 VSS.n4550 VSS.n4549 0.130789
R19912 VSS.n4299 VSS.n4298 0.130789
R19913 VSS.n4387 VSS.n4386 0.130789
R19914 VSS.n4426 VSS.n4425 0.130789
R19915 VSS.n184 VSS.n183 0.130789
R19916 VSS.n260 VSS.n259 0.130789
R19917 VSS.n105 VSS.n104 0.130789
R19918 VSS.n4277 VSS.n4270 0.130789
R19919 VSS.n3929 VSS.n3928 0.130789
R19920 VSS.n3862 VSS.n3861 0.130789
R19921 VSS.n3655 VSS.n3654 0.130789
R19922 VSS.n3795 VSS.n3794 0.130789
R19923 VSS.n3747 VSS.n3746 0.130789
R19924 VSS.n3699 VSS.n3698 0.130789
R19925 VSS.n2323 VSS.n2322 0.130789
R19926 VSS.n2554 VSS.n2553 0.130789
R19927 VSS.n2262 VSS.n2261 0.130789
R19928 VSS.n4769 VSS.n4768 0.130789
R19929 VSS.n4803 VSS.n4802 0.130789
R19930 VSS.n1145 VSS.n1144 0.130789
R19931 VSS.n3023 VSS.n3022 0.130789
R19932 VSS.n2228 VSS.n2227 0.130789
R19933 VSS.n5936 VSS.n5935 0.130789
R19934 VSS.n5866 VSS.n5865 0.130789
R19935 VSS.n619 VSS.n618 0.130789
R19936 VSS.n5657 VSS.n5656 0.130789
R19937 VSS.n5751 VSS.n5750 0.130789
R19938 VSS.n448 VSS.n447 0.130789
R19939 VSS.n406 VSS.n405 0.130789
R19940 VSS.n522 VSS.n521 0.130789
R19941 VSS.n5201 VSS.n5200 0.130789
R19942 VSS.n5153 VSS.n5152 0.130789
R19943 VSS.n5086 VSS.n5085 0.130789
R19944 VSS.n4928 VSS.n4927 0.130789
R19945 VSS.n5019 VSS.n5018 0.130789
R19946 VSS.n5275 VSS.n5274 0.130789
R19947 VSS.n5527 VSS.n5526 0.130789
R19948 VSS.n852 VSS.n851 0.130789
R19949 VSS.n5479 VSS.n5478 0.130789
R19950 VSS.n1077 VSS.n1076 0.130789
R19951 VSS.n1009 VSS.n1008 0.130789
R19952 VSS.n942 VSS.n941 0.130789
R19953 VSS.n1716 VSS.n1715 0.130789
R19954 VSS.n1408 VSS.n1407 0.130789
R19955 VSS.n1501 VSS.n1500 0.130789
R19956 VSS.n1649 VSS.n1648 0.130789
R19957 VSS.n1574 VSS.n1573 0.130789
R19958 VSS.n4074 VSS.n4073 0.130789
R19959 VSS.n4174 VSS.n1287 0.130789
R19960 VSS.n2947 VSS.n2921 0.130789
R19961 VSS.n3300 VSS.n2895 0.130789
R19962 VSS.n3101 VSS.n2985 0.130789
R19963 VSS.n3172 VSS.n3139 0.130789
R19964 VSS.n3236 VSS.n3210 0.130789
R19965 VSS.n3281 VSS.n3274 0.130789
R19966 VSS.n1470 VSS.n1463 0.130789
R19967 VSS.n914 VSS.n907 0.130789
R19968 VSS.n4990 VSS.n4983 0.130789
R19969 VSS.n2482 VSS.n2481 0.130789
R19970 VSS.n3368 VSS.n3367 0.130789
R19971 VSS.n2408 VSS.n2407 0.130789
R19972 VSS.n1989 VSS.n1988 0.130789
R19973 VSS.n3452 VSS.n3445 0.130789
R19974 VSS.n2201 VSS.n2194 0.130789
R19975 VSS.n4565 VSS.n4563 0.129539
R19976 VSS.n4314 VSS.n4312 0.129539
R19977 VSS.n4405 VSS.n4403 0.129539
R19978 VSS.n4441 VSS.n4439 0.129539
R19979 VSS.n202 VSS.n200 0.129539
R19980 VSS.n278 VSS.n276 0.129539
R19981 VSS.n112 VSS.n111 0.129539
R19982 VSS.n4257 VSS.n4255 0.129539
R19983 VSS.n6191 VSS.n6189 0.129539
R19984 VSS.n4223 VSS.n4220 0.129539
R19985 VSS.n3923 VSS.n3921 0.129539
R19986 VSS.n3856 VSS.n3854 0.129539
R19987 VSS.n3649 VSS.n3647 0.129539
R19988 VSS.n3789 VSS.n3787 0.129539
R19989 VSS.n3741 VSS.n3739 0.129539
R19990 VSS.n3693 VSS.n3691 0.129539
R19991 VSS.n2317 VSS.n2315 0.129539
R19992 VSS.n2548 VSS.n2546 0.129539
R19993 VSS.n2279 VSS.n2277 0.129539
R19994 VSS.n4780 VSS.n4779 0.129539
R19995 VSS.n4820 VSS.n4818 0.129539
R19996 VSS.n1162 VSS.n1160 0.129539
R19997 VSS.n3040 VSS.n3038 0.129539
R19998 VSS.n2239 VSS.n2238 0.129539
R19999 VSS.n5953 VSS.n5951 0.129539
R20000 VSS.n5883 VSS.n5881 0.129539
R20001 VSS.n636 VSS.n634 0.129539
R20002 VSS.n5674 VSS.n5672 0.129539
R20003 VSS.n5768 VSS.n5766 0.129539
R20004 VSS.n465 VSS.n463 0.129539
R20005 VSS.n424 VSS.n422 0.129539
R20006 VSS.n539 VSS.n537 0.129539
R20007 VSS.n5195 VSS.n5193 0.129539
R20008 VSS.n5147 VSS.n5145 0.129539
R20009 VSS.n5080 VSS.n5078 0.129539
R20010 VSS.n4922 VSS.n4920 0.129539
R20011 VSS.n5013 VSS.n5011 0.129539
R20012 VSS.n5269 VSS.n5267 0.129539
R20013 VSS.n5521 VSS.n5519 0.129539
R20014 VSS.n846 VSS.n844 0.129539
R20015 VSS.n5473 VSS.n5471 0.129539
R20016 VSS.n1071 VSS.n1069 0.129539
R20017 VSS.n1003 VSS.n1001 0.129539
R20018 VSS.n936 VSS.n934 0.129539
R20019 VSS.n1710 VSS.n1708 0.129539
R20020 VSS.n1402 VSS.n1400 0.129539
R20021 VSS.n1495 VSS.n1493 0.129539
R20022 VSS.n1643 VSS.n1641 0.129539
R20023 VSS.n1568 VSS.n1566 0.129539
R20024 VSS.n4068 VSS.n4066 0.129539
R20025 VSS.n1274 VSS.n1272 0.129539
R20026 VSS.n2908 VSS.n2906 0.129539
R20027 VSS.n2882 VSS.n2880 0.129539
R20028 VSS.n2972 VSS.n2970 0.129539
R20029 VSS.n3126 VSS.n3124 0.129539
R20030 VSS.n3197 VSS.n3195 0.129539
R20031 VSS.n3261 VSS.n3259 0.129539
R20032 VSS.n1450 VSS.n1448 0.129539
R20033 VSS.n894 VSS.n892 0.129539
R20034 VSS.n4970 VSS.n4968 0.129539
R20035 VSS.n2476 VSS.n2474 0.129539
R20036 VSS.n3362 VSS.n3360 0.129539
R20037 VSS.n2402 VSS.n2400 0.129539
R20038 VSS.n3432 VSS.n3430 0.129539
R20039 VSS.n2181 VSS.n2179 0.129539
R20040 VSS.n4735 VSS.n4734 0.125373
R20041 VSS.n163 VSS.n162 0.124539
R20042 VSS.n6177 VSS.n149 0.124539
R20043 VSS.n4721 VSS.n4720 0.124539
R20044 VSS.n4717 VSS.n4716 0.124539
R20045 VSS.n3561 VSS.n3560 0.124172
R20046 VSS.n4551 VSS.n4550 0.123289
R20047 VSS.n4300 VSS.n4299 0.123289
R20048 VSS.n4388 VSS.n4387 0.123289
R20049 VSS.n4427 VSS.n4426 0.123289
R20050 VSS.n185 VSS.n184 0.123289
R20051 VSS.n261 VSS.n260 0.123289
R20052 VSS.n106 VSS.n105 0.123289
R20053 VSS.n4270 VSS.n4269 0.123289
R20054 VSS.n3930 VSS.n3929 0.123289
R20055 VSS.n3863 VSS.n3862 0.123289
R20056 VSS.n3656 VSS.n3655 0.123289
R20057 VSS.n3796 VSS.n3795 0.123289
R20058 VSS.n3748 VSS.n3747 0.123289
R20059 VSS.n3700 VSS.n3699 0.123289
R20060 VSS.n2324 VSS.n2323 0.123289
R20061 VSS.n2555 VSS.n2554 0.123289
R20062 VSS.n2263 VSS.n2262 0.123289
R20063 VSS.n4770 VSS.n4769 0.123289
R20064 VSS.n4804 VSS.n4803 0.123289
R20065 VSS.n1146 VSS.n1145 0.123289
R20066 VSS.n3024 VSS.n3023 0.123289
R20067 VSS.n2229 VSS.n2228 0.123289
R20068 VSS.n5937 VSS.n5936 0.123289
R20069 VSS.n5867 VSS.n5866 0.123289
R20070 VSS.n620 VSS.n619 0.123289
R20071 VSS.n5658 VSS.n5657 0.123289
R20072 VSS.n5752 VSS.n5751 0.123289
R20073 VSS.n449 VSS.n448 0.123289
R20074 VSS.n407 VSS.n406 0.123289
R20075 VSS.n524 VSS.n522 0.123289
R20076 VSS.n5202 VSS.n5201 0.123289
R20077 VSS.n5154 VSS.n5153 0.123289
R20078 VSS.n5087 VSS.n5086 0.123289
R20079 VSS.n4929 VSS.n4928 0.123289
R20080 VSS.n5020 VSS.n5019 0.123289
R20081 VSS.n5276 VSS.n5275 0.123289
R20082 VSS.n5528 VSS.n5527 0.123289
R20083 VSS.n853 VSS.n852 0.123289
R20084 VSS.n5480 VSS.n5479 0.123289
R20085 VSS.n1078 VSS.n1077 0.123289
R20086 VSS.n1010 VSS.n1009 0.123289
R20087 VSS.n943 VSS.n942 0.123289
R20088 VSS.n1717 VSS.n1716 0.123289
R20089 VSS.n1409 VSS.n1408 0.123289
R20090 VSS.n1502 VSS.n1501 0.123289
R20091 VSS.n1650 VSS.n1649 0.123289
R20092 VSS.n1575 VSS.n1574 0.123289
R20093 VSS.n4075 VSS.n4074 0.123289
R20094 VSS.n1287 VSS.n1286 0.123289
R20095 VSS.n2921 VSS.n2920 0.123289
R20096 VSS.n2895 VSS.n2894 0.123289
R20097 VSS.n2985 VSS.n2984 0.123289
R20098 VSS.n3139 VSS.n3138 0.123289
R20099 VSS.n3210 VSS.n3209 0.123289
R20100 VSS.n3274 VSS.n3273 0.123289
R20101 VSS.n1463 VSS.n1462 0.123289
R20102 VSS.n907 VSS.n906 0.123289
R20103 VSS.n4983 VSS.n4982 0.123289
R20104 VSS.n2483 VSS.n2482 0.123289
R20105 VSS.n3369 VSS.n3368 0.123289
R20106 VSS.n2409 VSS.n2408 0.123289
R20107 VSS.n1990 VSS.n1989 0.123289
R20108 VSS.n3445 VSS.n3444 0.123289
R20109 VSS.n2194 VSS.n2193 0.123289
R20110 VSS.n2634 VSS.n2633 0.121629
R20111 VSS.n1962 VSS.n1961 0.120825
R20112 VSS.n1915 VSS.n1914 0.120825
R20113 VSS.n6204 VSS 0.120789
R20114 VSS.n2096 VSS.n2088 0.1205
R20115 VSS.n2087 VSS.n2079 0.1205
R20116 VSS.n1980 VSS.n1979 0.120486
R20117 VSS.n3568 VSS.n2087 0.11925
R20118 VSS.n1939 VSS.n1928 0.118792
R20119 VSS.n2820 VSS.n2811 0.118687
R20120 VSS.n4619 VSS.n4618 0.118512
R20121 VSS.n2077 VSS.n2076 0.11675
R20122 VSS.n6105 VSS.n6096 0.1149
R20123 VSS.n2106 VSS.n2096 0.113
R20124 VSS.n4579 VSS.n4557 0.112039
R20125 VSS.n4328 VSS.n4306 0.112039
R20126 VSS.n4503 VSS.n4397 0.112039
R20127 VSS.n4455 VSS.n4433 0.112039
R20128 VSS.n217 VSS.n194 0.112039
R20129 VSS.n292 VSS.n270 0.112039
R20130 VSS.n117 VSS.n108 0.112039
R20131 VSS.n4282 VSS.n4264 0.112039
R20132 VSS.n6189 VSS.n6187 0.112039
R20133 VSS.n6216 VSS.n6215 0.112039
R20134 VSS.n4705 VSS.n4704 0.112039
R20135 VSS.n3933 VSS.n3927 0.112039
R20136 VSS.n3866 VSS.n3860 0.112039
R20137 VSS.n3659 VSS.n3653 0.112039
R20138 VSS.n3799 VSS.n3793 0.112039
R20139 VSS.n3751 VSS.n3745 0.112039
R20140 VSS.n3703 VSS.n3697 0.112039
R20141 VSS.n2327 VSS.n2321 0.112039
R20142 VSS.n2558 VSS.n2552 0.112039
R20143 VSS.n2295 VSS.n2271 0.112039
R20144 VSS.n4788 VSS.n4776 0.112039
R20145 VSS.n4834 VSS.n4812 0.112039
R20146 VSS.n5417 VSS.n1154 0.112039
R20147 VSS.n3055 VSS.n3032 0.112039
R20148 VSS.n2247 VSS.n2235 0.112039
R20149 VSS.n5966 VSS.n5945 0.112039
R20150 VSS.n5896 VSS.n5875 0.112039
R20151 VSS.n649 VSS.n628 0.112039
R20152 VSS.n5687 VSS.n5666 0.112039
R20153 VSS.n5781 VSS.n5760 0.112039
R20154 VSS.n478 VSS.n457 0.112039
R20155 VSS.n6000 VSS.n416 0.112039
R20156 VSS.n552 VSS.n531 0.112039
R20157 VSS.n5205 VSS.n5199 0.112039
R20158 VSS.n5157 VSS.n5151 0.112039
R20159 VSS.n5090 VSS.n5084 0.112039
R20160 VSS.n4932 VSS.n4926 0.112039
R20161 VSS.n5023 VSS.n5017 0.112039
R20162 VSS.n5279 VSS.n5273 0.112039
R20163 VSS.n5531 VSS.n5525 0.112039
R20164 VSS.n856 VSS.n850 0.112039
R20165 VSS.n5483 VSS.n5477 0.112039
R20166 VSS.n1081 VSS.n1075 0.112039
R20167 VSS.n1013 VSS.n1007 0.112039
R20168 VSS.n946 VSS.n940 0.112039
R20169 VSS.n1720 VSS.n1714 0.112039
R20170 VSS.n1412 VSS.n1406 0.112039
R20171 VSS.n1505 VSS.n1499 0.112039
R20172 VSS.n1653 VSS.n1647 0.112039
R20173 VSS.n1578 VSS.n1572 0.112039
R20174 VSS.n4078 VSS.n4072 0.112039
R20175 VSS.n4179 VSS.n1281 0.112039
R20176 VSS.n2952 VSS.n2915 0.112039
R20177 VSS.n3305 VSS.n2889 0.112039
R20178 VSS.n3106 VSS.n2979 0.112039
R20179 VSS.n3177 VSS.n3133 0.112039
R20180 VSS.n3241 VSS.n3204 0.112039
R20181 VSS.n3286 VSS.n3268 0.112039
R20182 VSS.n1475 VSS.n1457 0.112039
R20183 VSS.n919 VSS.n901 0.112039
R20184 VSS.n4995 VSS.n4977 0.112039
R20185 VSS.n2486 VSS.n2480 0.112039
R20186 VSS.n3372 VSS.n3366 0.112039
R20187 VSS.n2412 VSS.n2406 0.112039
R20188 VSS.n2012 VSS.n2010 0.112039
R20189 VSS.n3457 VSS.n3439 0.112039
R20190 VSS.n2206 VSS.n2188 0.112039
R20191 VSS.n1950 VSS.n1947 0.111739
R20192 VSS.n2058 VSS 0.111333
R20193 VSS.n4549 VSS.n4548 0.110789
R20194 VSS.n4298 VSS.n4297 0.110789
R20195 VSS.n4386 VSS.n4385 0.110789
R20196 VSS.n4425 VSS.n4424 0.110789
R20197 VSS.n183 VSS.n182 0.110789
R20198 VSS.n259 VSS.n258 0.110789
R20199 VSS.n104 VSS.n103 0.110789
R20200 VSS.n4278 VSS.n4277 0.110789
R20201 VSS.n3928 VSS.n3918 0.110789
R20202 VSS.n3861 VSS.n3851 0.110789
R20203 VSS.n3654 VSS.n3644 0.110789
R20204 VSS.n3794 VSS.n3784 0.110789
R20205 VSS.n3746 VSS.n3736 0.110789
R20206 VSS.n3698 VSS.n3688 0.110789
R20207 VSS.n2322 VSS.n2312 0.110789
R20208 VSS.n2553 VSS.n2543 0.110789
R20209 VSS.n2261 VSS.n2260 0.110789
R20210 VSS.n4768 VSS.n4767 0.110789
R20211 VSS.n4802 VSS.n4801 0.110789
R20212 VSS.n1144 VSS.n1143 0.110789
R20213 VSS.n3022 VSS.n3021 0.110789
R20214 VSS.n2227 VSS.n2226 0.110789
R20215 VSS.n5935 VSS.n5934 0.110789
R20216 VSS.n5865 VSS.n5864 0.110789
R20217 VSS.n618 VSS.n617 0.110789
R20218 VSS.n5656 VSS.n5655 0.110789
R20219 VSS.n5750 VSS.n5749 0.110789
R20220 VSS.n447 VSS.n446 0.110789
R20221 VSS.n405 VSS.n404 0.110789
R20222 VSS.n521 VSS.n520 0.110789
R20223 VSS.n5200 VSS.n5190 0.110789
R20224 VSS.n5152 VSS.n5142 0.110789
R20225 VSS.n5085 VSS.n5075 0.110789
R20226 VSS.n4927 VSS.n4917 0.110789
R20227 VSS.n5018 VSS.n5008 0.110789
R20228 VSS.n5274 VSS.n5264 0.110789
R20229 VSS.n5526 VSS.n5516 0.110789
R20230 VSS.n851 VSS.n841 0.110789
R20231 VSS.n5478 VSS.n5468 0.110789
R20232 VSS.n1076 VSS.n1066 0.110789
R20233 VSS.n1008 VSS.n998 0.110789
R20234 VSS.n941 VSS.n931 0.110789
R20235 VSS.n1715 VSS.n1705 0.110789
R20236 VSS.n1407 VSS.n1397 0.110789
R20237 VSS.n1500 VSS.n1490 0.110789
R20238 VSS.n1648 VSS.n1638 0.110789
R20239 VSS.n1573 VSS.n1563 0.110789
R20240 VSS.n4073 VSS.n4063 0.110789
R20241 VSS.n4175 VSS.n4174 0.110789
R20242 VSS.n2948 VSS.n2947 0.110789
R20243 VSS.n3301 VSS.n3300 0.110789
R20244 VSS.n3102 VSS.n3101 0.110789
R20245 VSS.n3173 VSS.n3172 0.110789
R20246 VSS.n3237 VSS.n3236 0.110789
R20247 VSS.n3282 VSS.n3281 0.110789
R20248 VSS.n1471 VSS.n1470 0.110789
R20249 VSS.n915 VSS.n914 0.110789
R20250 VSS.n4991 VSS.n4990 0.110789
R20251 VSS.n2481 VSS.n2471 0.110789
R20252 VSS.n3367 VSS.n3357 0.110789
R20253 VSS.n2407 VSS.n2397 0.110789
R20254 VSS.n1988 VSS.n1987 0.110789
R20255 VSS.n3453 VSS.n3452 0.110789
R20256 VSS.n2202 VSS.n2201 0.110789
R20257 VSS.n4722 VSS 0.109694
R20258 VSS.n164 VSS.n148 0.109539
R20259 VSS.n2040 VSS 0.108847
R20260 VSS.n2054 VSS.n2053 0.107878
R20261 VSS.n2110 VSS.n2109 0.10675
R20262 VSS.n3569 VSS.n3568 0.10675
R20263 VSS.n2026 VSS.n2025 0.106272
R20264 VSS.t2901 VSS.n46 0.106089
R20265 VSS.t2900 VSS.n51 0.106089
R20266 VSS.n6206 VSS.n6205 0.10425
R20267 VSS.n2108 VSS.n2107 0.10425
R20268 VSS.n4590 VSS.n4589 0.103
R20269 VSS.n4339 VSS.n4338 0.103
R20270 VSS.n4368 VSS.n4367 0.103
R20271 VSS.n4466 VSS.n4465 0.103
R20272 VSS.n228 VSS.n227 0.103
R20273 VSS.n242 VSS.n241 0.103
R20274 VSS.n124 VSS.n123 0.103
R20275 VSS.n34 VSS.n33 0.103
R20276 VSS.n3962 VSS.n3961 0.103
R20277 VSS.n3895 VSS.n3894 0.103
R20278 VSS.n3627 VSS.n3626 0.103
R20279 VSS.n3828 VSS.n3827 0.103
R20280 VSS.n4027 VSS.n4026 0.103
R20281 VSS.n1800 VSS.n1799 0.103
R20282 VSS.n2356 VSS.n2355 0.103
R20283 VSS.n2527 VSS.n2526 0.103
R20284 VSS.n1866 VSS.n1865 0.103
R20285 VSS.n5356 VSS.n5355 0.103
R20286 VSS.n4869 VSS.n4868 0.103
R20287 VSS.n5438 VSS.n5437 0.103
R20288 VSS.n3076 VSS.n3075 0.103
R20289 VSS.n3494 VSS.n3493 0.103
R20290 VSS.n5918 VSS.n5917 0.103
R20291 VSS.n5848 VSS.n5847 0.103
R20292 VSS.n601 VSS.n600 0.103
R20293 VSS.n5638 VSS.n5637 0.103
R20294 VSS.n5733 VSS.n5732 0.103
R20295 VSS.n5707 VSS.n5706 0.103
R20296 VSS.n6019 VSS.n6018 0.103
R20297 VSS.n575 VSS.n574 0.103
R20298 VSS.n5234 VSS.n5233 0.103
R20299 VSS.n697 VSS.n696 0.103
R20300 VSS.n5119 VSS.n5118 0.103
R20301 VSS.n4900 VSS.n4899 0.103
R20302 VSS.n5052 VSS.n5051 0.103
R20303 VSS.n5248 VSS.n5247 0.103
R20304 VSS.n5560 VSS.n5559 0.103
R20305 VSS.n824 VSS.n823 0.103
R20306 VSS.n770 VSS.n769 0.103
R20307 VSS.n1110 VSS.n1109 0.103
R20308 VSS.n1042 VSS.n1041 0.103
R20309 VSS.n975 VSS.n974 0.103
R20310 VSS.n1749 VSS.n1748 0.103
R20311 VSS.n1380 VSS.n1379 0.103
R20312 VSS.n1534 VSS.n1533 0.103
R20313 VSS.n1621 VSS.n1620 0.103
R20314 VSS.n1547 VSS.n1546 0.103
R20315 VSS.n4046 VSS.n4045 0.103
R20316 VSS.n1320 VSS.n1319 0.103
R20317 VSS.n2926 VSS.n2925 0.103
R20318 VSS.n2858 VSS.n2857 0.103
R20319 VSS.n2990 VSS.n2989 0.103
R20320 VSS.n3144 VSS.n3143 0.103
R20321 VSS.n3215 VSS.n3214 0.103
R20322 VSS.n4162 VSS.n4161 0.103
R20323 VSS.n1251 VSS.n1250 0.103
R20324 VSS.n5618 VSS.n5617 0.103
R20325 VSS.n5828 VSS.n5827 0.103
R20326 VSS.n2454 VSS.n2453 0.103
R20327 VSS.n3340 VSS.n3339 0.103
R20328 VSS.n2380 VSS.n2379 0.103
R20329 VSS.n2109 VSS.n2108 0.103
R20330 VSS.n3606 VSS.n3605 0.103
R20331 VSS.n3536 VSS.n3535 0.103
R20332 VSS.n4224 VSS.n4222 0.102762
R20333 VSS.n4378 VSS.n4377 0.10175
R20334 VSS.n4485 VSS.n4475 0.10175
R20335 VSS.n3905 VSS.n3904 0.10175
R20336 VSS.n3637 VSS.n3636 0.10175
R20337 VSS.n4021 VSS.n4020 0.10175
R20338 VSS.n2366 VSS.n2365 0.10175
R20339 VSS.n2588 VSS.n2536 0.10175
R20340 VSS.n1854 VSS.n1835 0.10175
R20341 VSS.n5347 VSS.n5346 0.10175
R20342 VSS.n4860 VSS.n4859 0.10175
R20343 VSS.n5429 VSS.n1125 0.10175
R20344 VSS.n3067 VSS.n3003 0.10175
R20345 VSS.n5648 VSS.n5647 0.10175
R20346 VSS.n5244 VSS.n5243 0.10175
R20347 VSS.n684 VSS.n665 0.10175
R20348 VSS.n5129 VSS.n5128 0.10175
R20349 VSS.n4910 VSS.n4909 0.10175
R20350 VSS.n5062 VSS.n5061 0.10175
R20351 VSS.n5570 VSS.n5569 0.10175
R20352 VSS.n834 VSS.n833 0.10175
R20353 VSS.n1120 VSS.n1119 0.10175
R20354 VSS.n1052 VSS.n1051 0.10175
R20355 VSS.n985 VSS.n984 0.10175
R20356 VSS.n1759 VSS.n1758 0.10175
R20357 VSS.n1390 VSS.n1389 0.10175
R20358 VSS.n1631 VSS.n1630 0.10175
R20359 VSS.n4056 VSS.n4055 0.10175
R20360 VSS.n1353 VSS.n1307 0.10175
R20361 VSS.n2936 VSS.n2935 0.10175
R20362 VSS.n3000 VSS.n2999 0.10175
R20363 VSS.n3154 VSS.n3153 0.10175
R20364 VSS.n3225 VSS.n3224 0.10175
R20365 VSS.n4156 VSS.n4155 0.10175
R20366 VSS.n1234 VSS.n1233 0.10175
R20367 VSS.n5822 VSS.n5821 0.10175
R20368 VSS.n2464 VSS.n2463 0.10175
R20369 VSS.n3350 VSS.n3349 0.10175
R20370 VSS.n2390 VSS.n2389 0.10175
R20371 VSS.n2368 VSS.n1886 0.10175
R20372 VSS.n3529 VSS.n3528 0.10175
R20373 VSS.n5310 VSS.n5257 0.1005
R20374 VSS.n5625 VSS.n739 0.1005
R20375 VSS.n1692 VSS.n1543 0.1005
R20376 VSS.n1609 VSS.n1556 0.1005
R20377 VSS.n3317 VSS.n2867 0.1005
R20378 VSS.n5612 VSS.n5611 0.1005
R20379 VSS.n3566 VSS.n2111 0.1005
R20380 VSS.n4722 VSS.n4721 0.099539
R20381 VSS.n596 VSS.n561 0.09925
R20382 VSS.n4703 VSS.n4626 0.098289
R20383 VSS.n2103 VSS.n2097 0.098289
R20384 VSS.n2042 VSS.n2041 0.0974725
R20385 VSS.n4739 VSS.n4738 0.0968866
R20386 VSS.n3485 VSS.n3484 0.09675
R20387 VSS.n660 VSS.n610 0.09675
R20388 VSS.t2299 VSS.n1898 0.0966384
R20389 VSS.t2365 VSS.n1846 0.0966384
R20390 VSS.t2364 VSS.n1880 0.0966384
R20391 VSS.n4547 VSS.n4545 0.095789
R20392 VSS.n4296 VSS.n4294 0.095789
R20393 VSS.n4384 VSS.n4382 0.095789
R20394 VSS.n4423 VSS.n4421 0.095789
R20395 VSS.n181 VSS.n179 0.095789
R20396 VSS.n257 VSS.n255 0.095789
R20397 VSS.n102 VSS.n101 0.095789
R20398 VSS.n4276 VSS.n4273 0.095789
R20399 VSS.n3917 VSS.n3915 0.095789
R20400 VSS.n3850 VSS.n3848 0.095789
R20401 VSS.n3643 VSS.n3641 0.095789
R20402 VSS.n3783 VSS.n3781 0.095789
R20403 VSS.n3735 VSS.n3733 0.095789
R20404 VSS.n3687 VSS.n3685 0.095789
R20405 VSS.n2311 VSS.n2309 0.095789
R20406 VSS.n2542 VSS.n2540 0.095789
R20407 VSS.n2259 VSS.n2257 0.095789
R20408 VSS.n4766 VSS.n4764 0.095789
R20409 VSS.n4800 VSS.n4798 0.095789
R20410 VSS.n1142 VSS.n1140 0.095789
R20411 VSS.n3020 VSS.n3018 0.095789
R20412 VSS.n2225 VSS.n2223 0.095789
R20413 VSS.n5933 VSS.n5931 0.095789
R20414 VSS.n5863 VSS.n5861 0.095789
R20415 VSS.n616 VSS.n614 0.095789
R20416 VSS.n5654 VSS.n5652 0.095789
R20417 VSS.n5748 VSS.n5746 0.095789
R20418 VSS.n445 VSS.n443 0.095789
R20419 VSS.n403 VSS.n401 0.095789
R20420 VSS.n519 VSS.n517 0.095789
R20421 VSS.n5189 VSS.n5187 0.095789
R20422 VSS.n5141 VSS.n5139 0.095789
R20423 VSS.n5074 VSS.n5072 0.095789
R20424 VSS.n4916 VSS.n4914 0.095789
R20425 VSS.n5007 VSS.n5005 0.095789
R20426 VSS.n5263 VSS.n5261 0.095789
R20427 VSS.n5515 VSS.n5513 0.095789
R20428 VSS.n840 VSS.n838 0.095789
R20429 VSS.n5467 VSS.n5465 0.095789
R20430 VSS.n1065 VSS.n1063 0.095789
R20431 VSS.n997 VSS.n995 0.095789
R20432 VSS.n930 VSS.n928 0.095789
R20433 VSS.n1704 VSS.n1702 0.095789
R20434 VSS.n1396 VSS.n1394 0.095789
R20435 VSS.n1489 VSS.n1487 0.095789
R20436 VSS.n1637 VSS.n1635 0.095789
R20437 VSS.n1562 VSS.n1560 0.095789
R20438 VSS.n4062 VSS.n4060 0.095789
R20439 VSS.n4173 VSS.n4170 0.095789
R20440 VSS.n2946 VSS.n2943 0.095789
R20441 VSS.n3299 VSS.n3296 0.095789
R20442 VSS.n3100 VSS.n3097 0.095789
R20443 VSS.n3171 VSS.n3168 0.095789
R20444 VSS.n3235 VSS.n3232 0.095789
R20445 VSS.n3280 VSS.n3277 0.095789
R20446 VSS.n1469 VSS.n1466 0.095789
R20447 VSS.n913 VSS.n910 0.095789
R20448 VSS.n4989 VSS.n4986 0.095789
R20449 VSS.n2470 VSS.n2468 0.095789
R20450 VSS.n3356 VSS.n3354 0.095789
R20451 VSS.n2396 VSS.n2394 0.095789
R20452 VSS.n1986 VSS.n1984 0.095789
R20453 VSS.n3451 VSS.n3448 0.095789
R20454 VSS.n2200 VSS.n2197 0.095789
R20455 VSS.n6193 VSS 0.0955
R20456 VSS.n6213 VSS 0.0955
R20457 VSS VSS.n4219 0.0955
R20458 VSS.n4707 VSS 0.0955
R20459 VSS.n5907 VSS.n5857 0.0955
R20460 VSS.n6025 VSS.n385 0.0955
R20461 VSS.n2030 VSS.n2026 0.0947209
R20462 VSS.n166 VSS.n149 0.094539
R20463 VSS.n2017 VSS.n2016 0.0944995
R20464 VSS.n4034 VSS.n1769 0.09425
R20465 VSS.n4733 VSS 0.0935769
R20466 VSS.n2103 VSS.n2102 0.093289
R20467 VSS.n3979 VSS.n3971 0.093
R20468 VSS.n5722 VSS.n5716 0.093
R20469 VSS.n6222 VSS.n133 0.0905
R20470 VSS.n6210 VSS.n6209 0.08925
R20471 VSS.n4622 VSS.n4620 0.08925
R20472 VSS.n5977 VSS.n5927 0.08925
R20473 VSS.n2116 VSS.n1931 0.0892394
R20474 VSS.n4702 VSS 0.0889889
R20475 VSS.n56 VSS.n53 0.088
R20476 VSS.n2020 VSS.n2019 0.0870671
R20477 VSS.n306 VSS.n251 0.08675
R20478 VSS.n4600 VSS.n4599 0.08425
R20479 VSS.n6164 VSS.n237 0.08425
R20480 VSS.n4603 VSS.n4602 0.083
R20481 VSS.n4531 VSS.n4530 0.083
R20482 VSS.n4515 VSS.n4514 0.083
R20483 VSS.n4487 VSS.n4486 0.083
R20484 VSS.n6167 VSS.n6166 0.083
R20485 VSS.n304 VSS.n303 0.083
R20486 VSS.n6225 VSS.n6224 0.083
R20487 VSS.n60 VSS.n59 0.083
R20488 VSS.n3982 VSS.n3981 0.083
R20489 VSS.n3908 VSS.n3907 0.083
R20490 VSS.n3994 VSS.n3993 0.083
R20491 VSS.n3841 VSS.n3840 0.083
R20492 VSS.n1816 VSS.n1814 0.083
R20493 VSS.n4032 VSS.n1771 0.083
R20494 VSS.n3413 VSS.n3412 0.083
R20495 VSS.n2587 VSS.n2586 0.083
R20496 VSS.n3611 VSS.n1837 0.083
R20497 VSS.n4888 VSS.n4886 0.083
R20498 VSS.n4855 VSS.n4853 0.083
R20499 VSS.n5442 VSS.n1127 0.083
R20500 VSS.n3080 VSS.n3005 0.083
R20501 VSS.n3480 VSS.n3478 0.083
R20502 VSS.n5975 VSS.n5974 0.083
R20503 VSS.n5905 VSS.n5904 0.083
R20504 VSS.n658 VSS.n657 0.083
R20505 VSS.n5696 VSS.n5695 0.083
R20506 VSS.n5790 VSS.n5789 0.083
R20507 VSS.n5720 VSS.n5719 0.083
R20508 VSS.n6023 VSS.n387 0.083
R20509 VSS.n514 VSS.n512 0.083
R20510 VSS.n5321 VSS.n5320 0.083
R20511 VSS.n5833 VSS.n667 0.083
R20512 VSS.n5132 VSS.n5131 0.083
R20513 VSS.n5333 VSS.n5332 0.083
R20514 VSS.n5065 VSS.n5064 0.083
R20515 VSS.n5308 VSS.n5307 0.083
R20516 VSS.n5580 VSS.n5579 0.083
R20517 VSS.n5592 VSS.n5591 0.083
R20518 VSS.n5623 VSS.n741 0.083
R20519 VSS.n5458 VSS.n5457 0.083
R20520 VSS.n1056 VSS.n1055 0.083
R20521 VSS.n988 VSS.n987 0.083
R20522 VSS.n4119 VSS.n4118 0.083
R20523 VSS.n4131 VSS.n4130 0.083
R20524 VSS.n1695 VSS.n1694 0.083
R20525 VSS.n1682 VSS.n1681 0.083
R20526 VSS.n1607 VSS.n1606 0.083
R20527 VSS.n4107 VSS.n4106 0.083
R20528 VSS.n1304 VSS.n1290 0.083
R20529 VSS.n2939 VSS.n2938 0.083
R20530 VSS.n3315 VSS.n3314 0.083
R20531 VSS.n3093 VSS.n3092 0.083
R20532 VSS.n3164 VSS.n3163 0.083
R20533 VSS.n1337 VSS.n1335 0.083
R20534 VSS.n1227 VSS.n1225 0.083
R20535 VSS.n787 VSS.n785 0.083
R20536 VSS.n714 VSS.n712 0.083
R20537 VSS.n2515 VSS.n2514 0.083
R20538 VSS.n3401 VSS.n3400 0.083
R20539 VSS.n2441 VSS.n2440 0.083
R20540 VSS.n2105 VSS.n2097 0.083
R20541 VSS.n1883 VSS.n1881 0.083
R20542 VSS.n2166 VSS.n2164 0.083
R20543 VSS.n2041 VSS.n2040 0.082732
R20544 VSS.n4528 VSS.n4348 0.08175
R20545 VSS.n3228 VSS.n3227 0.08175
R20546 VSS.n1950 VSS.n1949 0.0817394
R20547 VSS.n3838 VSS.n3837 0.07925
R20548 VSS.n4217 VSS.n4216 0.078289
R20549 VSS.n2023 VSS.n2022 0.0781482
R20550 VSS.n6205 VSS.n6204 0.077039
R20551 VSS.n6148 VSS.n6147 0.0747133
R20552 VSS.n2076 VSS.n2075 0.07425
R20553 VSS.n5595 VSS.n5594 0.0741267
R20554 VSS.n2025 VSS.n2023 0.0736887
R20555 VSS.n4036 VSS.n1767 0.0732467
R20556 VSS.n2367 VSS.n2121 0.0732467
R20557 VSS.n4733 VSS 0.0727388
R20558 VSS.n5844 VSS.n5838 0.0720733
R20559 VSS.n6208 VSS.n6207 0.07175
R20560 VSS.n4618 VSS.n4617 0.07175
R20561 VSS.n5980 VSS.n5979 0.0703133
R20562 VSS.n4152 VSS.n1341 0.0703133
R20563 VSS.n5792 VSS.n5742 0.068
R20564 VSS.n1936 VSS.n1935 0.068
R20565 VSS.n4042 VSS.n1765 0.0676733
R20566 VSS.n6219 VSS.n136 0.0673863
R20567 VSS.n4526 VSS.n4518 0.06738
R20568 VSS.n5342 VSS.n5341 0.06738
R20569 VSS.n2044 VSS.n2042 0.0669995
R20570 VSS.n5454 VSS.n5448 0.0665
R20571 VSS.n2022 VSS.n2020 0.0662563
R20572 VSS.n5445 VSS.n1123 0.06562
R20573 VSS.n6027 VSS.n384 0.06474
R20574 VSS.n2078 VSS.n2077 0.064539
R20575 VSS.n6211 VSS.n6210 0.06425
R20576 VSS.n3089 VSS.n3083 0.0641533
R20577 VSS.n3977 VSS.n1819 0.0632733
R20578 VSS.n5818 VSS.n718 0.0623933
R20579 VSS.n4734 VSS.n4733 0.0618776
R20580 VSS VSS.n155 0.0605
R20581 VSS VSS.n6182 0.0605
R20582 VSS.n6185 VSS 0.0605
R20583 VSS VSS.n6212 0.0605
R20584 VSS.n4229 VSS 0.0605
R20585 VSS.n4622 VSS 0.0605
R20586 VSS VSS.n4616 0.0605
R20587 VSS.n4624 VSS 0.0605
R20588 VSS.n1914 VSS 0.0605
R20589 VSS.n4719 VSS 0.0605
R20590 VSS VSS.n4718 0.0605
R20591 VSS.n2450 VSS.n2449 0.0597533
R20592 VSS.n5609 VSS.n792 0.0591667
R20593 VSS.n4589 VSS.n4588 0.0589841
R20594 VSS.n4338 VSS.n4337 0.0589841
R20595 VSS.n4367 VSS.n4366 0.0589841
R20596 VSS.n4465 VSS.n4464 0.0589841
R20597 VSS.n227 VSS.n226 0.0589841
R20598 VSS.n241 VSS.n240 0.0589841
R20599 VSS.n123 VSS.n122 0.0589841
R20600 VSS.n33 VSS.n25 0.0589841
R20601 VSS.n3961 VSS.n3960 0.0589841
R20602 VSS.n3894 VSS.n3893 0.0589841
R20603 VSS.n3626 VSS.n3625 0.0589841
R20604 VSS.n3827 VSS.n3826 0.0589841
R20605 VSS.n4026 VSS.n1810 0.0589841
R20606 VSS.n1799 VSS.n1773 0.0589841
R20607 VSS.n2355 VSS.n2354 0.0589841
R20608 VSS.n2526 VSS.n2525 0.0589841
R20609 VSS.n1865 VSS.n1839 0.0589841
R20610 VSS.n5355 VSS.n4877 0.0589841
R20611 VSS.n4868 VSS.n4844 0.0589841
R20612 VSS.n5437 VSS.n1129 0.0589841
R20613 VSS.n3075 VSS.n3007 0.0589841
R20614 VSS.n3493 VSS.n3469 0.0589841
R20615 VSS.n5917 VSS.n5916 0.0589841
R20616 VSS.n5847 VSS.n5846 0.0589841
R20617 VSS.n600 VSS.n599 0.0589841
R20618 VSS.n5637 VSS.n5636 0.0589841
R20619 VSS.n5732 VSS.n5731 0.0589841
R20620 VSS.n5706 VSS.n5705 0.0589841
R20621 VSS.n6018 VSS.n389 0.0589841
R20622 VSS.n574 VSS.n500 0.0589841
R20623 VSS.n5233 VSS.n5232 0.0589841
R20624 VSS.n696 VSS.n669 0.0589841
R20625 VSS.n5118 VSS.n5117 0.0589841
R20626 VSS.n4899 VSS.n4898 0.0589841
R20627 VSS.n5051 VSS.n5050 0.0589841
R20628 VSS.n5247 VSS.n5246 0.0589841
R20629 VSS.n5559 VSS.n5558 0.0589841
R20630 VSS.n823 VSS.n822 0.0589841
R20631 VSS.n769 VSS.n743 0.0589841
R20632 VSS.n1109 VSS.n1108 0.0589841
R20633 VSS.n1041 VSS.n1040 0.0589841
R20634 VSS.n974 VSS.n973 0.0589841
R20635 VSS.n1748 VSS.n1747 0.0589841
R20636 VSS.n1379 VSS.n1378 0.0589841
R20637 VSS.n1533 VSS.n1532 0.0589841
R20638 VSS.n1620 VSS.n1619 0.0589841
R20639 VSS.n1546 VSS.n1545 0.0589841
R20640 VSS.n4045 VSS.n4044 0.0589841
R20641 VSS.n1319 VSS.n1292 0.0589841
R20642 VSS.n2925 VSS.n2924 0.0589841
R20643 VSS.n2857 VSS.n2856 0.0589841
R20644 VSS.n2989 VSS.n2988 0.0589841
R20645 VSS.n3143 VSS.n3142 0.0589841
R20646 VSS.n3214 VSS.n3213 0.0589841
R20647 VSS.n4161 VSS.n1331 0.0589841
R20648 VSS.n1250 VSS.n1213 0.0589841
R20649 VSS.n5617 VSS.n781 0.0589841
R20650 VSS.n5827 VSS.n708 0.0589841
R20651 VSS.n2453 VSS.n2452 0.0589841
R20652 VSS.n3339 VSS.n3338 0.0589841
R20653 VSS.n2379 VSS.n2378 0.0589841
R20654 VSS.n3605 VSS.n1876 0.0589841
R20655 VSS.n3535 VSS.n2157 0.0589841
R20656 VSS.n4134 VSS.n1370 0.0582867
R20657 VSS.n3623 VSS.n3617 0.0582867
R20658 VSS.n315 VSS.n134 0.0579933
R20659 VSS.n2019 VSS.n2017 0.0573374
R20660 VSS.n162 VSS.n155 0.05675
R20661 VSS.n6212 VSS.n6211 0.05675
R20662 VSS.n4621 VSS.n4616 0.05675
R20663 VSS.n4720 VSS.n4719 0.05675
R20664 VSS.n4718 VSS.n4717 0.05675
R20665 VSS.n3614 VSS.n1833 0.0533
R20666 VSS.n1934 VSS.n1931 0.0517394
R20667 VSS.n3588 VSS.n1925 0.0513333
R20668 VSS.n3327 VSS.n3326 0.0512467
R20669 VSS.n2115 VSS 0.0504326
R20670 VSS.n3336 VSS.n3330 0.0500733
R20671 VSS.n2054 VSS.n2030 0.0495541
R20672 VSS.n6207 VSS.n6206 0.04925
R20673 VSS.n1960 VSS 0.04925
R20674 VSS.n5835 VSS.n663 0.0491933
R20675 VSS.n1617 VSS.n1616 0.0491933
R20676 VSS.n4483 VSS.n238 0.0477267
R20677 VSS.n5794 VSS.n5703 0.0450867
R20678 VSS.n3319 VSS.n2848 0.0445
R20679 VSS.n5798 VSS.n5797 0.0442067
R20680 VSS.n5627 VSS.n737 0.0421533
R20681 VSS VSS.n1937 0.0405
R20682 VSS.n4604 VSS.n4603 0.038
R20683 VSS.n4532 VSS.n4531 0.038
R20684 VSS.n4514 VSS.n4513 0.038
R20685 VSS.n4488 VSS.n4487 0.038
R20686 VSS.n6168 VSS.n6167 0.038
R20687 VSS.n303 VSS.n302 0.038
R20688 VSS.n6226 VSS.n6225 0.038
R20689 VSS.n59 VSS.n23 0.038
R20690 VSS.n3983 VSS.n3982 0.038
R20691 VSS.n3909 VSS.n3908 0.038
R20692 VSS.n3993 VSS.n3992 0.038
R20693 VSS.n3842 VSS.n3841 0.038
R20694 VSS.n1817 VSS.n1816 0.038
R20695 VSS.n1786 VSS.n1771 0.038
R20696 VSS.n3414 VSS.n3413 0.038
R20697 VSS.n2586 VSS.n2585 0.038
R20698 VSS.n1851 VSS.n1837 0.038
R20699 VSS.n4889 VSS.n4888 0.038
R20700 VSS.n4856 VSS.n4855 0.038
R20701 VSS.n1138 VSS.n1127 0.038
R20702 VSS.n3016 VSS.n3005 0.038
R20703 VSS.n3481 VSS.n3480 0.038
R20704 VSS.n5974 VSS.n5973 0.038
R20705 VSS.n5904 VSS.n5903 0.038
R20706 VSS.n657 VSS.n656 0.038
R20707 VSS.n5695 VSS.n5694 0.038
R20708 VSS.n5789 VSS.n5788 0.038
R20709 VSS.n5719 VSS.n5718 0.038
R20710 VSS.n399 VSS.n387 0.038
R20711 VSS.n559 VSS.n514 0.038
R20712 VSS.n5322 VSS.n5321 0.038
R20713 VSS.n681 VSS.n667 0.038
R20714 VSS.n5133 VSS.n5132 0.038
R20715 VSS.n5332 VSS.n5331 0.038
R20716 VSS.n5066 VSS.n5065 0.038
R20717 VSS.n5307 VSS.n5306 0.038
R20718 VSS.n5581 VSS.n5580 0.038
R20719 VSS.n5591 VSS.n5590 0.038
R20720 VSS.n756 VSS.n741 0.038
R20721 VSS.n5459 VSS.n5458 0.038
R20722 VSS.n1057 VSS.n1056 0.038
R20723 VSS.n989 VSS.n988 0.038
R20724 VSS.n4120 VSS.n4119 0.038
R20725 VSS.n4130 VSS.n4129 0.038
R20726 VSS.n1696 VSS.n1695 0.038
R20727 VSS.n1681 VSS.n1680 0.038
R20728 VSS.n1606 VSS.n1605 0.038
R20729 VSS.n4106 VSS.n4105 0.038
R20730 VSS.n4167 VSS.n1290 0.038
R20731 VSS.n2940 VSS.n2939 0.038
R20732 VSS.n3314 VSS.n3313 0.038
R20733 VSS.n3094 VSS.n3093 0.038
R20734 VSS.n3165 VSS.n3164 0.038
R20735 VSS.n3229 VSS.n3228 0.038
R20736 VSS.n1338 VSS.n1337 0.038
R20737 VSS.n1228 VSS.n1227 0.038
R20738 VSS.n788 VSS.n787 0.038
R20739 VSS.n715 VSS.n714 0.038
R20740 VSS.n2514 VSS.n2513 0.038
R20741 VSS.n3400 VSS.n3399 0.038
R20742 VSS.n2440 VSS.n2439 0.038
R20743 VSS.n1884 VSS.n1883 0.038
R20744 VSS.n2167 VSS.n2166 0.038
R20745 VSS.n1941 VSS.n1940 0.0371667
R20746 VSS.n4138 VSS.n4137 0.0368733
R20747 VSS.n166 VSS.n165 0.0355
R20748 VSS.n5792 VSS.n5791 0.03425
R20749 VSS.n2633 VSS.n2120 0.0340373
R20750 VSS.n169 VSS.n168 0.033
R20751 VSS.n2116 VSS.n1941 0.0321667
R20752 VSS.n6217 VSS.n6216 0.03175
R20753 VSS.n6209 VSS.n6208 0.03175
R20754 VSS.n4620 VSS.n4617 0.03175
R20755 VSS.n4704 VSS.n4703 0.03175
R20756 VSS.n6178 VSS.n6177 0.0305
R20757 VSS.t2940 VSS.n2013 0.0284977
R20758 VSS.n6193 VSS.n6192 0.028
R20759 VSS.n6186 VSS.n6185 0.028
R20760 VSS.n6214 VSS.n6213 0.028
R20761 VSS.n4219 VSS.n4218 0.028
R20762 VSS.n4707 VSS.n4706 0.028
R20763 VSS.n6190 VSS.n6182 0.02675
R20764 VSS.n4229 VSS.n4228 0.02675
R20765 VSS.n4625 VSS.n4624 0.02675
R20766 VSS.n4606 VSS.n4605 0.023
R20767 VSS.n4534 VSS.n4533 0.023
R20768 VSS.n4512 VSS.n4380 0.023
R20769 VSS.n4490 VSS.n4489 0.023
R20770 VSS.n6170 VSS.n6169 0.023
R20771 VSS.n301 VSS.n253 0.023
R20772 VSS.n6228 VSS.n6227 0.023
R20773 VSS.n4272 VSS.n4271 0.023
R20774 VSS.n3985 VSS.n3984 0.023
R20775 VSS.n3911 VSS.n3910 0.023
R20776 VSS.n3991 VSS.n3639 0.023
R20777 VSS.n3839 VSS.n3838 0.023
R20778 VSS.n3844 VSS.n3843 0.023
R20779 VSS.n3777 VSS.n3776 0.023
R20780 VSS.n3729 VSS.n3728 0.023
R20781 VSS.n3416 VSS.n3415 0.023
R20782 VSS.n2584 VSS.n2538 0.023
R20783 VSS.n2303 VSS.n2302 0.023
R20784 VSS.n4796 VSS.n4795 0.023
R20785 VSS.n4842 VSS.n4841 0.023
R20786 VSS.n5425 VSS.n5424 0.023
R20787 VSS.n3063 VSS.n3062 0.023
R20788 VSS.n2255 VSS.n2254 0.023
R20789 VSS.n5972 VSS.n5929 0.023
R20790 VSS.n5902 VSS.n5859 0.023
R20791 VSS.n655 VSS.n612 0.023
R20792 VSS.n5693 VSS.n5650 0.023
R20793 VSS.n5787 VSS.n5744 0.023
R20794 VSS.n485 VSS.n484 0.023
R20795 VSS.n6008 VSS.n6007 0.023
R20796 VSS.n558 VSS.n515 0.023
R20797 VSS.n5324 VSS.n5323 0.023
R20798 VSS.n5183 VSS.n5182 0.023
R20799 VSS.n5135 VSS.n5134 0.023
R20800 VSS.n5330 VSS.n4912 0.023
R20801 VSS.n5068 VSS.n5067 0.023
R20802 VSS.n5305 VSS.n5259 0.023
R20803 VSS.n5583 VSS.n5582 0.023
R20804 VSS.n5589 VSS.n836 0.023
R20805 VSS.n5509 VSS.n5508 0.023
R20806 VSS.n5461 VSS.n5460 0.023
R20807 VSS.n1059 VSS.n1058 0.023
R20808 VSS.n991 VSS.n990 0.023
R20809 VSS.n4122 VSS.n4121 0.023
R20810 VSS.n4128 VSS.n1392 0.023
R20811 VSS.n1698 VSS.n1697 0.023
R20812 VSS.n1679 VSS.n1633 0.023
R20813 VSS.n1604 VSS.n1558 0.023
R20814 VSS.n4104 VSS.n4058 0.023
R20815 VSS.n4169 VSS.n4168 0.023
R20816 VSS.n2942 VSS.n2941 0.023
R20817 VSS.n3312 VSS.n2869 0.023
R20818 VSS.n3096 VSS.n3095 0.023
R20819 VSS.n3167 VSS.n3166 0.023
R20820 VSS.n3231 VSS.n3230 0.023
R20821 VSS.n3276 VSS.n3275 0.023
R20822 VSS.n1465 VSS.n1464 0.023
R20823 VSS.n909 VSS.n908 0.023
R20824 VSS.n4985 VSS.n4984 0.023
R20825 VSS.n2512 VSS.n2466 0.023
R20826 VSS.n3398 VSS.n3352 0.023
R20827 VSS.n2438 VSS.n2392 0.023
R20828 VSS.n3571 VSS.n3570 0.023
R20829 VSS.n3447 VSS.n3446 0.023
R20830 VSS.n2196 VSS.n2195 0.023
R20831 VSS.n1949 VSS.n1948 0.0221667
R20832 VSS.n4529 VSS.n4528 0.0205
R20833 VSS.n2751 VSS.n2741 0.0193892
R20834 VSS.n2754 VSS.n2743 0.0193892
R20835 VSS.n6036 VSS.n377 0.0193892
R20836 VSS.n6039 VSS.n379 0.0193892
R20837 VSS.n6100 VSS.n379 0.0193892
R20838 VSS.n6104 VSS.n377 0.0193892
R20839 VSS.n2833 VSS.n2832 0.0193892
R20840 VSS.n2825 VSS.n2738 0.0193892
R20841 VSS.n371 VSS.n359 0.0193892
R20842 VSS.n374 VSS.n361 0.0193892
R20843 VSS.n6111 VSS.n361 0.0193892
R20844 VSS.n6115 VSS.n359 0.0193892
R20845 VSS.n2724 VSS.n2723 0.0193892
R20846 VSS.n2718 VSS.n2595 0.0193892
R20847 VSS.n353 VSS.n341 0.0193892
R20848 VSS.n356 VSS.n343 0.0193892
R20849 VSS.n6122 VSS.n343 0.0193892
R20850 VSS.n6126 VSS.n341 0.0193892
R20851 VSS.n2707 VSS.n2706 0.0193892
R20852 VSS.n2701 VSS.n2607 0.0193892
R20853 VSS.n6141 VSS.n6140 0.0193892
R20854 VSS.n6133 VSS.n337 0.0193892
R20855 VSS.n6135 VSS.n6133 0.0193892
R20856 VSS.n6143 VSS.n6141 0.0193892
R20857 VSS.n2684 VSS.n2616 0.0193892
R20858 VSS.n2686 VSS.n2618 0.0193892
R20859 VSS.n4695 VSS.n4694 0.0193892
R20860 VSS.n4687 VSS.n4681 0.0193892
R20861 VSS.n4689 VSS.n4687 0.0193892
R20862 VSS.n4697 VSS.n4695 0.0193892
R20863 VSS.n2686 VSS.n2621 0.0193892
R20864 VSS.n2684 VSS.n2623 0.0193892
R20865 VSS.n2701 VSS.n2611 0.0193892
R20866 VSS.n2706 VSS.n2613 0.0193892
R20867 VSS.n2718 VSS.n2600 0.0193892
R20868 VSS.n2723 VSS.n2602 0.0193892
R20869 VSS.n2826 VSS.n2825 0.0193892
R20870 VSS.n2832 VSS.n2829 0.0193892
R20871 VSS.n2815 VSS.n2743 0.0193892
R20872 VSS.n2819 VSS.n2741 0.0193892
R20873 VSS.n4602 VSS.n4601 0.01925
R20874 VSS.n4530 VSS.n4529 0.01925
R20875 VSS.n4486 VSS.n4485 0.01925
R20876 VSS.n6166 VSS.n6165 0.01925
R20877 VSS.n305 VSS.n304 0.01925
R20878 VSS.n6224 VSS.n6223 0.01925
R20879 VSS.n60 VSS.n57 0.01925
R20880 VSS.n3981 VSS.n3980 0.01925
R20881 VSS.n3840 VSS.n3839 0.01925
R20882 VSS.n4033 VSS.n4032 0.01925
R20883 VSS.n2588 VSS.n2587 0.01925
R20884 VSS.n5346 VSS.n4886 0.01925
R20885 VSS.n3483 VSS.n3478 0.01925
R20886 VSS.n5976 VSS.n5975 0.01925
R20887 VSS.n5906 VSS.n5905 0.01925
R20888 VSS.n659 VSS.n658 0.01925
R20889 VSS.n5696 VSS.n5648 0.01925
R20890 VSS.n5791 VSS.n5790 0.01925
R20891 VSS.n5721 VSS.n5720 0.01925
R20892 VSS.n6024 VSS.n6023 0.01925
R20893 VSS.n595 VSS.n512 0.01925
R20894 VSS.n5833 VSS.n665 0.01925
R20895 VSS.n5309 VSS.n5308 0.01925
R20896 VSS.n5592 VSS.n834 0.01925
R20897 VSS.n5624 VSS.n5623 0.01925
R20898 VSS.n1694 VSS.n1693 0.01925
R20899 VSS.n1608 VSS.n1607 0.01925
R20900 VSS.n3316 VSS.n3315 0.01925
R20901 VSS.n3226 VSS.n3225 0.01925
R20902 VSS.n790 VSS.n785 0.01925
R20903 VSS.n4601 VSS.n4600 0.018
R20904 VSS.n6165 VSS.n6164 0.018
R20905 VSS.n5443 VSS.n5442 0.018
R20906 VSS.n3163 VSS.n3162 0.018
R20907 VSS.n3402 VSS.n3350 0.018
R20908 VSS.n3589 VSS.n3588 0.018
R20909 VSS.n1948 VSS.n1925 0.018
R20910 VSS.n987 VSS.n986 0.01675
R20911 VSS.n3091 VSS.n3000 0.01675
R20912 VSS.n3527 VSS.n2164 0.01675
R20913 VSS.n4725 VSS.n4724 0.01675
R20914 VSS.n306 VSS.n305 0.0155
R20915 VSS.n3995 VSS.n3994 0.0155
R20916 VSS.n3612 VSS.n3611 0.0155
R20917 VSS.n3081 VSS.n3080 0.0155
R20918 VSS.n2937 VSS.n2936 0.0155
R20919 VSS.n5820 VSS.n712 0.0155
R20920 VSS.n4215 VSS.n4213 0.0150918
R20921 VSS.n57 VSS.n56 0.01425
R20922 VSS.n4019 VSS.n1814 0.01425
R20923 VSS.n4737 VSS.n4211 0.0141889
R20924 VSS.n2057 VSS.n2016 0.0138784
R20925 VSS.n3906 VSS.n3905 0.013
R20926 VSS.n3412 VSS.n3411 0.013
R20927 VSS.n5977 VSS.n5976 0.013
R20928 VSS.n5063 VSS.n5062 0.013
R20929 VSS.n5578 VSS.n5570 0.013
R20930 VSS.n5457 VSS.n5456 0.013
R20931 VSS.n4118 VSS.n4117 0.013
R20932 VSS.n1683 VSS.n1631 0.013
R20933 VSS.n1354 VSS.n1353 0.013
R20934 VSS.n2060 VSS.n2059 0.013
R20935 VSS.n2369 VSS.n1881 0.013
R20936 VSS.n2821 VSS.n2747 0.0118396
R20937 VSS.n2747 VSS.n2745 0.0118396
R20938 VSS.n6106 VSS.n6032 0.0118396
R20939 VSS.n6032 VSS.n382 0.0118396
R20940 VSS.n2840 VSS.n2830 0.0118396
R20941 VSS.n2838 VSS.n2830 0.0118396
R20942 VSS.n6117 VSS.n367 0.0118396
R20943 VSS.n367 VSS.n364 0.0118396
R20944 VSS.n2732 VSS.n2721 0.0118396
R20945 VSS.n2730 VSS.n2721 0.0118396
R20946 VSS.n6128 VSS.n349 0.0118396
R20947 VSS.n349 VSS.n346 0.0118396
R20948 VSS.n2715 VSS.n2704 0.0118396
R20949 VSS.n2713 VSS.n2704 0.0118396
R20950 VSS.n6145 VSS.n330 0.0118396
R20951 VSS.n334 VSS.n330 0.0118396
R20952 VSS.n2698 VSS.n2688 0.0118396
R20953 VSS.n2688 VSS.n2624 0.0118396
R20954 VSS.n4699 VSS.n4674 0.0118396
R20955 VSS.n4678 VSS.n4674 0.0118396
R20956 VSS.n6223 VSS.n6222 0.01175
R20957 VSS.n4859 VSS.n4858 0.01175
R20958 VSS.n5131 VSS.n5130 0.01175
R20959 VSS.n5334 VSS.n4910 0.01175
R20960 VSS.n1055 VSS.n1054 0.01175
R20961 VSS.n4154 VSS.n1335 0.01175
R20962 VSS.n2516 VSS.n2515 0.01175
R20963 VSS.n2442 VSS.n2441 0.01175
R20964 VSS.n3582 VSS.n3581 0.01175
R20965 VSS.n1961 VSS.n1960 0.01175
R20966 VSS.n4724 VSS.n4723 0.0109762
R20967 VSS.n4723 VSS.n4722 0.0109762
R20968 VSS.n4516 VSS.n4378 0.0105
R20969 VSS.n5320 VSS.n5319 0.0105
R20970 VSS.n4132 VSS.n1390 0.0105
R20971 VSS.n4108 VSS.n4107 0.0105
R20972 VSS.n1233 VSS.n1232 0.0105
R20973 VSS.n2092 VSS.n2088 0.0105
R20974 VSS.n4664 VSS.n4642 0.0102233
R20975 VSS.n4662 VSS.n4640 0.0102233
R20976 VSS.n4664 VSS.n4656 0.0102233
R20977 VSS.n4662 VSS.n4660 0.0102233
R20978 VSS.n4633 VSS 0.00972353
R20979 VSS.n1947 VSS.n1945 0.00966667
R20980 VSS.n4516 VSS.n4515 0.00925
R20981 VSS.n3980 VSS.n3979 0.00925
R20982 VSS.n5722 VSS.n5721 0.00925
R20983 VSS.n5319 VSS.n5244 0.00925
R20984 VSS.n4132 VSS.n4131 0.00925
R20985 VSS.n4108 VSS.n4056 0.00925
R20986 VSS.n1232 VSS.n1225 0.00925
R20987 VSS.n4667 VSS.n4666 0.00902421
R20988 VSS.n4645 VSS.n4631 0.00902421
R20989 VSS.n4645 VSS.n4635 0.00902421
R20990 VSS.n4666 VSS.n4637 0.00902421
R20991 VSS.n6066 VSS.n6053 0.00849539
R20992 VSS.n6086 VSS.n6059 0.00849539
R20993 VSS.n6066 VSS.n6056 0.00849539
R20994 VSS.n6086 VSS.n6051 0.00849539
R20995 VSS.n2665 VSS.n2645 0.00849539
R20996 VSS.n2677 VSS.n2672 0.00849539
R20997 VSS.n2774 VSS.n2768 0.00849539
R20998 VSS.n2788 VSS.n2781 0.00849539
R20999 VSS.n2775 VSS.n2774 0.00849539
R21000 VSS.n2788 VSS.n2766 0.00849539
R21001 VSS.n2666 VSS.n2665 0.00849539
R21002 VSS.n2677 VSS.n2643 0.00849539
R21003 VSS.n4034 VSS.n4033 0.008
R21004 VSS.n4858 VSS.n4853 0.008
R21005 VSS.n5130 VSS.n5129 0.008
R21006 VSS.n5334 VSS.n5333 0.008
R21007 VSS.n1054 VSS.n1052 0.008
R21008 VSS.n4155 VSS.n4154 0.008
R21009 VSS.n2516 VSS.n2464 0.008
R21010 VSS.n2442 VSS.n2390 0.008
R21011 VSS.n2806 VSS.n2792 0.00752076
R21012 VSS.n2794 VSS.n2760 0.00752076
R21013 VSS.n6082 VSS.n6043 0.00752076
R21014 VSS.n6075 VSS.n6070 0.00752076
R21015 VSS.n6068 VSS.n6043 0.00752076
R21016 VSS.n6076 VSS.n6075 0.00752076
R21017 VSS.n2801 VSS.n2760 0.00752076
R21018 VSS.n2807 VSS.n2806 0.00752076
R21019 VSS.n2654 VSS.n2639 0.00752076
R21020 VSS.n2650 VSS.n2630 0.00752076
R21021 VSS.n2654 VSS.n2628 0.00752076
R21022 VSS.n2650 VSS.n2636 0.00752076
R21023 VSS.n1945 VSS.n1944 0.00716667
R21024 VSS.n3907 VSS.n3906 0.00675
R21025 VSS.n3411 VSS.n2366 0.00675
R21026 VSS.n5907 VSS.n5906 0.00675
R21027 VSS.n6025 VSS.n6024 0.00675
R21028 VSS.n5064 VSS.n5063 0.00675
R21029 VSS.n5579 VSS.n5578 0.00675
R21030 VSS.n5456 VSS.n1120 0.00675
R21031 VSS.n4117 VSS.n1759 0.00675
R21032 VSS.n1683 VSS.n1682 0.00675
R21033 VSS.n1354 VSS.n1304 0.00675
R21034 VSS.n3567 VSS.n3566 0.00675
R21035 VSS.n2369 VSS.n2368 0.00675
R21036 VSS.n2752 VSS.n2751 0.00666623
R21037 VSS.n2818 VSS.n2753 0.00666623
R21038 VSS.n2753 VSS.n2742 0.00666623
R21039 VSS.n2816 VSS.n2754 0.00666623
R21040 VSS.n2814 VSS.n2755 0.00666623
R21041 VSS.n2755 VSS.n2744 0.00666623
R21042 VSS.n2812 VSS.n1832 0.00666623
R21043 VSS.n6037 VSS.n6036 0.00666623
R21044 VSS.n6103 VSS.n6038 0.00666623
R21045 VSS.n6038 VSS.n378 0.00666623
R21046 VSS.n6101 VSS.n6039 0.00666623
R21047 VSS.n6099 VSS.n6040 0.00666623
R21048 VSS.n6040 VSS.n380 0.00666623
R21049 VSS.n6097 VSS.n381 0.00666623
R21050 VSS.n6098 VSS.n380 0.00666623
R21051 VSS.n6102 VSS.n378 0.00666623
R21052 VSS.n6098 VSS.n6097 0.00666623
R21053 VSS.n6100 VSS.n6099 0.00666623
R21054 VSS.n6102 VSS.n6101 0.00666623
R21055 VSS.n6104 VSS.n6103 0.00666623
R21056 VSS.n6037 VSS.n382 0.00666623
R21057 VSS.n2833 VSS.n2736 0.00666623
R21058 VSS.n2835 VSS.n2737 0.00666623
R21059 VSS.n2827 VSS.n2737 0.00666623
R21060 VSS.n2836 VSS.n2738 0.00666623
R21061 VSS.n2837 VSS.n2739 0.00666623
R21062 VSS.n2823 VSS.n2739 0.00666623
R21063 VSS.n2842 VSS.n2590 0.00666623
R21064 VSS.n372 VSS.n371 0.00666623
R21065 VSS.n6114 VSS.n373 0.00666623
R21066 VSS.n373 VSS.n360 0.00666623
R21067 VSS.n6112 VSS.n374 0.00666623
R21068 VSS.n6110 VSS.n375 0.00666623
R21069 VSS.n375 VSS.n362 0.00666623
R21070 VSS.n6108 VSS.n363 0.00666623
R21071 VSS.n6109 VSS.n362 0.00666623
R21072 VSS.n6113 VSS.n360 0.00666623
R21073 VSS.n6109 VSS.n6108 0.00666623
R21074 VSS.n6111 VSS.n6110 0.00666623
R21075 VSS.n6113 VSS.n6112 0.00666623
R21076 VSS.n6115 VSS.n6114 0.00666623
R21077 VSS.n372 VSS.n364 0.00666623
R21078 VSS.n2724 VSS.n2593 0.00666623
R21079 VSS.n2726 VSS.n2594 0.00666623
R21080 VSS.n2717 VSS.n2594 0.00666623
R21081 VSS.n2727 VSS.n2595 0.00666623
R21082 VSS.n2728 VSS.n2596 0.00666623
R21083 VSS.n2719 VSS.n2596 0.00666623
R21084 VSS.n2729 VSS.n2598 0.00666623
R21085 VSS.n354 VSS.n353 0.00666623
R21086 VSS.n6125 VSS.n355 0.00666623
R21087 VSS.n355 VSS.n342 0.00666623
R21088 VSS.n6123 VSS.n356 0.00666623
R21089 VSS.n6121 VSS.n357 0.00666623
R21090 VSS.n357 VSS.n344 0.00666623
R21091 VSS.n6119 VSS.n345 0.00666623
R21092 VSS.n6120 VSS.n344 0.00666623
R21093 VSS.n6124 VSS.n342 0.00666623
R21094 VSS.n6120 VSS.n6119 0.00666623
R21095 VSS.n6122 VSS.n6121 0.00666623
R21096 VSS.n6124 VSS.n6123 0.00666623
R21097 VSS.n6126 VSS.n6125 0.00666623
R21098 VSS.n354 VSS.n346 0.00666623
R21099 VSS.n2707 VSS.n2605 0.00666623
R21100 VSS.n2709 VSS.n2606 0.00666623
R21101 VSS.n2700 VSS.n2606 0.00666623
R21102 VSS.n2710 VSS.n2607 0.00666623
R21103 VSS.n2711 VSS.n2608 0.00666623
R21104 VSS.n2702 VSS.n2608 0.00666623
R21105 VSS.n2712 VSS.n2609 0.00666623
R21106 VSS.n6140 VSS.n335 0.00666623
R21107 VSS.n6142 VSS.n336 0.00666623
R21108 VSS.n6136 VSS.n336 0.00666623
R21109 VSS.n6137 VSS.n337 0.00666623
R21110 VSS.n6134 VSS.n338 0.00666623
R21111 VSS.n6130 VSS.n338 0.00666623
R21112 VSS.n6131 VSS.n339 0.00666623
R21113 VSS.n6132 VSS.n6130 0.00666623
R21114 VSS.n6138 VSS.n6136 0.00666623
R21115 VSS.n6132 VSS.n6131 0.00666623
R21116 VSS.n6135 VSS.n6134 0.00666623
R21117 VSS.n6138 VSS.n6137 0.00666623
R21118 VSS.n6143 VSS.n6142 0.00666623
R21119 VSS.n335 VSS.n334 0.00666623
R21120 VSS.n2690 VSS.n2616 0.00666623
R21121 VSS.n2691 VSS.n2617 0.00666623
R21122 VSS.n2685 VSS.n2617 0.00666623
R21123 VSS.n2692 VSS.n2618 0.00666623
R21124 VSS.n2693 VSS.n2619 0.00666623
R21125 VSS.n2695 VSS.n2619 0.00666623
R21126 VSS.n2620 VSS.n2118 0.00666623
R21127 VSS.n4694 VSS.n4679 0.00666623
R21128 VSS.n4696 VSS.n4680 0.00666623
R21129 VSS.n4690 VSS.n4680 0.00666623
R21130 VSS.n4691 VSS.n4681 0.00666623
R21131 VSS.n4688 VSS.n4682 0.00666623
R21132 VSS.n4684 VSS.n4682 0.00666623
R21133 VSS.n4685 VSS.n4683 0.00666623
R21134 VSS.n4686 VSS.n4684 0.00666623
R21135 VSS.n4692 VSS.n4690 0.00666623
R21136 VSS.n4686 VSS.n4685 0.00666623
R21137 VSS.n4689 VSS.n4688 0.00666623
R21138 VSS.n4692 VSS.n4691 0.00666623
R21139 VSS.n4697 VSS.n4696 0.00666623
R21140 VSS.n4679 VSS.n4678 0.00666623
R21141 VSS.n2696 VSS.n2695 0.00666623
R21142 VSS.n2685 VSS.n2622 0.00666623
R21143 VSS.n2693 VSS.n2621 0.00666623
R21144 VSS.n2692 VSS.n2622 0.00666623
R21145 VSS.n2691 VSS.n2623 0.00666623
R21146 VSS.n2690 VSS.n2624 0.00666623
R21147 VSS.n2696 VSS.n2620 0.00666623
R21148 VSS.n2702 VSS.n2610 0.00666623
R21149 VSS.n2700 VSS.n2612 0.00666623
R21150 VSS.n2712 VSS.n2610 0.00666623
R21151 VSS.n2711 VSS.n2611 0.00666623
R21152 VSS.n2710 VSS.n2612 0.00666623
R21153 VSS.n2709 VSS.n2613 0.00666623
R21154 VSS.n2713 VSS.n2605 0.00666623
R21155 VSS.n2719 VSS.n2599 0.00666623
R21156 VSS.n2717 VSS.n2601 0.00666623
R21157 VSS.n2729 VSS.n2599 0.00666623
R21158 VSS.n2728 VSS.n2600 0.00666623
R21159 VSS.n2727 VSS.n2601 0.00666623
R21160 VSS.n2726 VSS.n2602 0.00666623
R21161 VSS.n2730 VSS.n2593 0.00666623
R21162 VSS.n2824 VSS.n2823 0.00666623
R21163 VSS.n2828 VSS.n2827 0.00666623
R21164 VSS.n2824 VSS.n2590 0.00666623
R21165 VSS.n2837 VSS.n2826 0.00666623
R21166 VSS.n2836 VSS.n2828 0.00666623
R21167 VSS.n2835 VSS.n2829 0.00666623
R21168 VSS.n2838 VSS.n2736 0.00666623
R21169 VSS.n2813 VSS.n2744 0.00666623
R21170 VSS.n2817 VSS.n2742 0.00666623
R21171 VSS.n2813 VSS.n2812 0.00666623
R21172 VSS.n2815 VSS.n2814 0.00666623
R21173 VSS.n2817 VSS.n2816 0.00666623
R21174 VSS.n2819 VSS.n2818 0.00666623
R21175 VSS.n2752 VSS.n2745 0.00666623
R21176 VSS.n1940 VSS.n1939 0.00633333
R21177 VSS.n4599 VSS.n4598 0.0055
R21178 VSS.n4348 VSS.n4347 0.0055
R21179 VSS.n4377 VSS.n4376 0.0055
R21180 VSS.n4475 VSS.n4474 0.0055
R21181 VSS.n237 VSS.n236 0.0055
R21182 VSS.n251 VSS.n250 0.0055
R21183 VSS.n133 VSS.n132 0.0055
R21184 VSS.n53 VSS.n52 0.0055
R21185 VSS.n3971 VSS.n3970 0.0055
R21186 VSS.n3904 VSS.n3903 0.0055
R21187 VSS.n3636 VSS.n3635 0.0055
R21188 VSS.n3837 VSS.n3836 0.0055
R21189 VSS.n4021 VSS.n1818 0.0055
R21190 VSS.n4020 VSS.n4019 0.0055
R21191 VSS.n1781 VSS.n1769 0.0055
R21192 VSS.n2365 VSS.n2364 0.0055
R21193 VSS.n2536 VSS.n2535 0.0055
R21194 VSS.n1854 VSS.n1853 0.0055
R21195 VSS.n5347 VSS.n4890 0.0055
R21196 VSS.n4860 VSS.n4857 0.0055
R21197 VSS.n5429 VSS.n5428 0.0055
R21198 VSS.n3067 VSS.n3066 0.0055
R21199 VSS.n3485 VSS.n3482 0.0055
R21200 VSS.n3484 VSS.n3483 0.0055
R21201 VSS.n5927 VSS.n5926 0.0055
R21202 VSS.n5857 VSS.n5856 0.0055
R21203 VSS.n610 VSS.n609 0.0055
R21204 VSS.n660 VSS.n659 0.0055
R21205 VSS.n5647 VSS.n5646 0.0055
R21206 VSS.n5742 VSS.n5741 0.0055
R21207 VSS.n5716 VSS.n5715 0.0055
R21208 VSS.n395 VSS.n385 0.0055
R21209 VSS.n561 VSS.n560 0.0055
R21210 VSS.n5243 VSS.n5242 0.0055
R21211 VSS.n684 VSS.n683 0.0055
R21212 VSS.n5128 VSS.n5127 0.0055
R21213 VSS.n4909 VSS.n4908 0.0055
R21214 VSS.n5061 VSS.n5060 0.0055
R21215 VSS.n5257 VSS.n5256 0.0055
R21216 VSS.n5569 VSS.n5568 0.0055
R21217 VSS.n833 VSS.n832 0.0055
R21218 VSS.n751 VSS.n739 0.0055
R21219 VSS.n1119 VSS.n1118 0.0055
R21220 VSS.n1051 VSS.n1050 0.0055
R21221 VSS.n984 VSS.n983 0.0055
R21222 VSS.n1758 VSS.n1757 0.0055
R21223 VSS.n1389 VSS.n1388 0.0055
R21224 VSS.n1543 VSS.n1542 0.0055
R21225 VSS.n1630 VSS.n1629 0.0055
R21226 VSS.n1556 VSS.n1555 0.0055
R21227 VSS.n4055 VSS.n4054 0.0055
R21228 VSS.n1307 VSS.n1306 0.0055
R21229 VSS.n2935 VSS.n2934 0.0055
R21230 VSS.n2867 VSS.n2866 0.0055
R21231 VSS.n2999 VSS.n2998 0.0055
R21232 VSS.n3153 VSS.n3152 0.0055
R21233 VSS.n3224 VSS.n3223 0.0055
R21234 VSS.n4156 VSS.n1339 0.0055
R21235 VSS.n1234 VSS.n1231 0.0055
R21236 VSS.n5612 VSS.n789 0.0055
R21237 VSS.n5822 VSS.n716 0.0055
R21238 VSS.n2463 VSS.n2462 0.0055
R21239 VSS.n3349 VSS.n3348 0.0055
R21240 VSS.n2389 VSS.n2388 0.0055
R21241 VSS.n1886 VSS.n1885 0.0055
R21242 VSS.n3529 VSS.n3526 0.0055
R21243 VSS.t2977 VSS.n2036 0.00533436
R21244 VSS VSS.n4621 0.00425
R21245 VSS.n3995 VSS.n3637 0.00425
R21246 VSS.n3612 VSS.n1835 0.00425
R21247 VSS.n3081 VSS.n3003 0.00425
R21248 VSS.n2938 VSS.n2937 0.00425
R21249 VSS.n5821 VSS.n5820 0.00425
R21250 VSS.n2083 VSS.n2079 0.00425
R21251 VSS.n2810 VSS.n2771 0.00351176
R21252 VSS.n2790 VSS.n2763 0.00351176
R21253 VSS.n6092 VSS.n6088 0.00351176
R21254 VSS.n2678 VSS.n2640 0.00351176
R21255 VSS.n4671 VSS.n4648 0.00351176
R21256 VSS.n4669 VSS.n4648 0.00351176
R21257 VSS.n4736 VSS.n4212 0.00343333
R21258 VSS.n165 VSS.n164 0.003
R21259 VSS.n4735 VSS.n4213 0.003
R21260 VSS.n596 VSS.n595 0.003
R21261 VSS.n986 VSS.n985 0.003
R21262 VSS.n3092 VSS.n3091 0.003
R21263 VSS.n3528 VSS.n3527 0.003
R21264 VSS.n4654 VSS.n4649 0.00273081
R21265 VSS.n4665 VSS.n4643 0.00273081
R21266 VSS.n4656 VSS.n4655 0.00273081
R21267 VSS.n4658 VSS.n4657 0.00273081
R21268 VSS.n4663 VSS.n4641 0.00273081
R21269 VSS.n4660 VSS.n4659 0.00273081
R21270 VSS.n4670 VSS.n4661 0.00273081
R21271 VSS.n4668 VSS.n4639 0.00273081
R21272 VSS.n4672 VSS.n4628 0.00273081
R21273 VSS.n4676 VSS.n4675 0.00273081
R21274 VSS.n4693 VSS.n4627 0.00273081
R21275 VSS.n4698 VSS.n4677 0.00273081
R21276 VSS.n332 VSS.n331 0.00273081
R21277 VSS.n6139 VSS.n328 0.00273081
R21278 VSS.n6144 VSS.n333 0.00273081
R21279 VSS.n350 VSS.n340 0.00273081
R21280 VSS.n352 VSS.n348 0.00273081
R21281 VSS.n6127 VSS.n351 0.00273081
R21282 VSS.n368 VSS.n358 0.00273081
R21283 VSS.n370 VSS.n366 0.00273081
R21284 VSS.n6116 VSS.n369 0.00273081
R21285 VSS.n6033 VSS.n376 0.00273081
R21286 VSS.n6035 VSS.n6031 0.00273081
R21287 VSS.n6105 VSS.n6034 0.00273081
R21288 VSS.n6096 VSS.n6095 0.00273081
R21289 VSS.n6091 VSS.n6089 0.00273081
R21290 VSS.n6090 VSS.n6054 0.00273081
R21291 VSS.n6083 VSS.n6056 0.00273081
R21292 VSS.n6084 VSS.n6057 0.00273081
R21293 VSS.n6065 VSS.n6052 0.00273081
R21294 VSS.n6085 VSS.n6058 0.00273081
R21295 VSS.n6064 VSS.n6051 0.00273081
R21296 VSS.n6063 VSS.n6050 0.00273081
R21297 VSS.n6087 VSS.n6060 0.00273081
R21298 VSS.n6062 VSS.n6049 0.00273081
R21299 VSS.n6093 VSS.n6061 0.00273081
R21300 VSS.n6095 VSS.n6048 0.00273081
R21301 VSS.n6089 VSS.n6048 0.00273081
R21302 VSS.n6091 VSS.n6090 0.00273081
R21303 VSS.n6083 VSS.n6054 0.00273081
R21304 VSS.n6084 VSS.n6053 0.00273081
R21305 VSS.n6065 VSS.n6057 0.00273081
R21306 VSS.n6085 VSS.n6052 0.00273081
R21307 VSS.n6064 VSS.n6058 0.00273081
R21308 VSS.n6063 VSS.n6059 0.00273081
R21309 VSS.n6087 VSS.n6050 0.00273081
R21310 VSS.n6062 VSS.n6060 0.00273081
R21311 VSS.n6061 VSS.n6049 0.00273081
R21312 VSS.n6107 VSS.n376 0.00273081
R21313 VSS.n6035 VSS.n6033 0.00273081
R21314 VSS.n6034 VSS.n6031 0.00273081
R21315 VSS.n6118 VSS.n358 0.00273081
R21316 VSS.n370 VSS.n368 0.00273081
R21317 VSS.n369 VSS.n366 0.00273081
R21318 VSS.n6129 VSS.n340 0.00273081
R21319 VSS.n352 VSS.n350 0.00273081
R21320 VSS.n351 VSS.n348 0.00273081
R21321 VSS.n331 VSS.n329 0.00273081
R21322 VSS.n6139 VSS.n332 0.00273081
R21323 VSS.n333 VSS.n328 0.00273081
R21324 VSS.n4675 VSS.n4673 0.00273081
R21325 VSS.n4693 VSS.n4676 0.00273081
R21326 VSS.n4677 VSS.n4627 0.00273081
R21327 VSS.n2660 VSS.n2659 0.00273081
R21328 VSS.n2673 VSS.n2664 0.00273081
R21329 VSS.n2662 VSS.n2646 0.00273081
R21330 VSS.n2674 VSS.n2666 0.00273081
R21331 VSS.n2675 VSS.n2668 0.00273081
R21332 VSS.n2667 VSS.n2644 0.00273081
R21333 VSS.n2676 VSS.n2670 0.00273081
R21334 VSS.n2669 VSS.n2643 0.00273081
R21335 VSS.n2671 VSS.n2642 0.00273081
R21336 VSS.n2681 VSS.n2679 0.00273081
R21337 VSS.n2680 VSS.n2641 0.00273081
R21338 VSS.n2683 VSS.n2626 0.00273081
R21339 VSS.n2697 VSS.n2689 0.00273081
R21340 VSS.n2699 VSS.n2615 0.00273081
R21341 VSS.n2714 VSS.n2705 0.00273081
R21342 VSS.n2708 VSS.n2614 0.00273081
R21343 VSS.n2716 VSS.n2604 0.00273081
R21344 VSS.n2731 VSS.n2722 0.00273081
R21345 VSS.n2725 VSS.n2603 0.00273081
R21346 VSS.n2733 VSS.n2592 0.00273081
R21347 VSS.n2839 VSS.n2831 0.00273081
R21348 VSS.n2834 VSS.n2591 0.00273081
R21349 VSS.n2841 VSS.n2735 0.00273081
R21350 VSS.n2748 VSS.n2740 0.00273081
R21351 VSS.n2750 VSS.n2746 0.00273081
R21352 VSS.n2820 VSS.n2749 0.00273081
R21353 VSS.n2770 VSS.n2756 0.00273081
R21354 VSS.n2784 VSS.n2773 0.00273081
R21355 VSS.n2772 VSS.n2769 0.00273081
R21356 VSS.n2785 VSS.n2775 0.00273081
R21357 VSS.n2786 VSS.n2777 0.00273081
R21358 VSS.n2776 VSS.n2767 0.00273081
R21359 VSS.n2787 VSS.n2779 0.00273081
R21360 VSS.n2778 VSS.n2766 0.00273081
R21361 VSS.n2780 VSS.n2765 0.00273081
R21362 VSS.n2789 VSS.n2783 0.00273081
R21363 VSS.n2782 VSS.n2764 0.00273081
R21364 VSS.n2809 VSS.n2791 0.00273081
R21365 VSS.n2689 VSS.n2687 0.00273081
R21366 VSS.n2625 VSS.n2615 0.00273081
R21367 VSS.n2705 VSS.n2703 0.00273081
R21368 VSS.n2714 VSS.n2708 0.00273081
R21369 VSS.n2614 VSS.n2604 0.00273081
R21370 VSS.n2722 VSS.n2720 0.00273081
R21371 VSS.n2731 VSS.n2725 0.00273081
R21372 VSS.n2603 VSS.n2592 0.00273081
R21373 VSS.n2831 VSS.n2734 0.00273081
R21374 VSS.n2839 VSS.n2834 0.00273081
R21375 VSS.n2735 VSS.n2591 0.00273081
R21376 VSS.n2822 VSS.n2740 0.00273081
R21377 VSS.n2750 VSS.n2748 0.00273081
R21378 VSS.n2749 VSS.n2746 0.00273081
R21379 VSS.n2811 VSS.n2756 0.00273081
R21380 VSS.n2784 VSS.n2770 0.00273081
R21381 VSS.n2773 VSS.n2772 0.00273081
R21382 VSS.n2785 VSS.n2769 0.00273081
R21383 VSS.n2786 VSS.n2768 0.00273081
R21384 VSS.n2777 VSS.n2776 0.00273081
R21385 VSS.n2787 VSS.n2767 0.00273081
R21386 VSS.n2779 VSS.n2778 0.00273081
R21387 VSS.n2781 VSS.n2780 0.00273081
R21388 VSS.n2789 VSS.n2765 0.00273081
R21389 VSS.n2783 VSS.n2782 0.00273081
R21390 VSS.n2791 VSS.n2764 0.00273081
R21391 VSS.n2659 VSS.n2652 0.00273081
R21392 VSS.n2673 VSS.n2652 0.00273081
R21393 VSS.n2664 VSS.n2662 0.00273081
R21394 VSS.n2674 VSS.n2646 0.00273081
R21395 VSS.n2675 VSS.n2645 0.00273081
R21396 VSS.n2668 VSS.n2667 0.00273081
R21397 VSS.n2676 VSS.n2644 0.00273081
R21398 VSS.n2670 VSS.n2669 0.00273081
R21399 VSS.n2672 VSS.n2671 0.00273081
R21400 VSS.n2679 VSS.n2642 0.00273081
R21401 VSS.n2681 VSS.n2680 0.00273081
R21402 VSS.n2641 VSS.n2626 0.00273081
R21403 VSS.n4649 VSS.n4647 0.00273081
R21404 VSS.n4665 VSS.n4654 0.00273081
R21405 VSS.n4655 VSS.n4643 0.00273081
R21406 VSS.n4657 VSS.n4642 0.00273081
R21407 VSS.n4663 VSS.n4658 0.00273081
R21408 VSS.n4659 VSS.n4641 0.00273081
R21409 VSS.n4661 VSS.n4640 0.00273081
R21410 VSS.n4670 VSS.n4668 0.00273081
R21411 VSS.n4639 VSS.n4628 0.00273081
R21412 VSS.n2694 VSS.n2625 0.00273081
R21413 VSS.n2697 VSS.n2694 0.00273081
R21414 VSS.n2808 VSS.n2763 0.00250563
R21415 VSS.n2790 VSS.n2757 0.00250563
R21416 VSS.n2792 VSS.n2758 0.00250563
R21417 VSS.n2804 VSS.n2793 0.00250563
R21418 VSS.n2793 VSS.n2759 0.00250563
R21419 VSS.n2802 VSS.n2794 0.00250563
R21420 VSS.n2800 VSS.n2795 0.00250563
R21421 VSS.n2795 VSS.n2761 0.00250563
R21422 VSS.n2798 VSS.n2796 0.00250563
R21423 VSS.n2796 VSS.n2762 0.00250563
R21424 VSS.n6041 VSS.n136 0.00250563
R21425 VSS.n6092 VSS.n6042 0.00250563
R21426 VSS.n6081 VSS.n6067 0.00250563
R21427 VSS.n6079 VSS.n6068 0.00250563
R21428 VSS.n6080 VSS.n6044 0.00250563
R21429 VSS.n6077 VSS.n6069 0.00250563
R21430 VSS.n6078 VSS.n6045 0.00250563
R21431 VSS.n6076 VSS.n6046 0.00250563
R21432 VSS.n6073 VSS.n6071 0.00250563
R21433 VSS.n6074 VSS.n6047 0.00250563
R21434 VSS.n6072 VSS.n6055 0.00250563
R21435 VSS.n6072 VSS.n6047 0.00250563
R21436 VSS.n6071 VSS.n6046 0.00250563
R21437 VSS.n6070 VSS.n6045 0.00250563
R21438 VSS.n6069 VSS.n6044 0.00250563
R21439 VSS.n6067 VSS.n6042 0.00250563
R21440 VSS.n6088 VSS.n6041 0.00250563
R21441 VSS.n6074 VSS.n6073 0.00250563
R21442 VSS.n6078 VSS.n6077 0.00250563
R21443 VSS.n6080 VSS.n6079 0.00250563
R21444 VSS.n6082 VSS.n6081 0.00250563
R21445 VSS.n6094 VSS.n6055 0.00250563
R21446 VSS.n2797 VSS.n2762 0.00250563
R21447 VSS.n2799 VSS.n2761 0.00250563
R21448 VSS.n2803 VSS.n2759 0.00250563
R21449 VSS.n2805 VSS.n2758 0.00250563
R21450 VSS.n2807 VSS.n2757 0.00250563
R21451 VSS.n2799 VSS.n2798 0.00250563
R21452 VSS.n2801 VSS.n2800 0.00250563
R21453 VSS.n2803 VSS.n2802 0.00250563
R21454 VSS.n2805 VSS.n2804 0.00250563
R21455 VSS.n2808 VSS.n2771 0.00250563
R21456 VSS.n2682 VSS.n2661 0.00250563
R21457 VSS.n2653 VSS.n2640 0.00250563
R21458 VSS.n2647 VSS.n2627 0.00250563
R21459 VSS.n2648 VSS.n2628 0.00250563
R21460 VSS.n2655 VSS.n2638 0.00250563
R21461 VSS.n2649 VSS.n2629 0.00250563
R21462 VSS.n2656 VSS.n2637 0.00250563
R21463 VSS.n2657 VSS.n2636 0.00250563
R21464 VSS.n2651 VSS.n2631 0.00250563
R21465 VSS.n2658 VSS.n2635 0.00250563
R21466 VSS.n2663 VSS.n2632 0.00250563
R21467 VSS.n4667 VSS.n4629 0.00250563
R21468 VSS.n4650 VSS.n4630 0.00250563
R21469 VSS.n4644 VSS.n4630 0.00250563
R21470 VSS.n4651 VSS.n4631 0.00250563
R21471 VSS.n4652 VSS.n4632 0.00250563
R21472 VSS.n4646 VSS.n4632 0.00250563
R21473 VSS.n4653 VSS.n4633 0.00250563
R21474 VSS.n2658 VSS.n2632 0.00250563
R21475 VSS.n2657 VSS.n2631 0.00250563
R21476 VSS.n2656 VSS.n2630 0.00250563
R21477 VSS.n2655 VSS.n2629 0.00250563
R21478 VSS.n2653 VSS.n2627 0.00250563
R21479 VSS.n2678 VSS.n2661 0.00250563
R21480 VSS.n2651 VSS.n2635 0.00250563
R21481 VSS.n2649 VSS.n2637 0.00250563
R21482 VSS.n2648 VSS.n2638 0.00250563
R21483 VSS.n2647 VSS.n2639 0.00250563
R21484 VSS.n2663 VSS.n2634 0.00250563
R21485 VSS.n4646 VSS.n4634 0.00250563
R21486 VSS.n4644 VSS.n4636 0.00250563
R21487 VSS.n4653 VSS.n4634 0.00250563
R21488 VSS.n4652 VSS.n4635 0.00250563
R21489 VSS.n4651 VSS.n4636 0.00250563
R21490 VSS.n4650 VSS.n4637 0.00250563
R21491 VSS.n4669 VSS.n4629 0.00250563
R21492 VSS.n5443 VSS.n1125 0.00175
R21493 VSS.n5310 VSS.n5309 0.00175
R21494 VSS.n5625 VSS.n5624 0.00175
R21495 VSS.n1693 VSS.n1692 0.00175
R21496 VSS.n1609 VSS.n1608 0.00175
R21497 VSS.n3317 VSS.n3316 0.00175
R21498 VSS.n3162 VSS.n3154 0.00175
R21499 VSS.n3227 VSS.n3226 0.00175
R21500 VSS.n5611 VSS.n790 0.00175
R21501 VSS.n3402 VSS.n3401 0.00175
R21502 VSS.n4715 VSS.n4710 0.00175
R21503 VSS.n2052 VSS.n2029 0.00166667
R21504 VSS.n2045 VSS.n2034 0.00166667
R21505 VSS.n4715 VSS.n4711 0.00166667
R21506 VSS.n4702 VSS.n4701 0.00147778
R21507 VSS.n1935 VSS.n1934 0.00133333
R21508 VSS.n1937 VSS.n1936 0.00133333
R21509 VSS.t2977 VSS.n2034 0.00133332
R21510 VSS.n2056 VSS.n2029 0.00133332
R21511 VSS.n4727 VSS.n4711 0.00133332
R21512 VSS.n2104 VSS.n2099 0.00124998
R21513 VSS.n2074 VSS.n2071 0.00124998
R21514 VSS.n2095 VSS.n2094 0.00124998
R21515 VSS.n2086 VSS.n2085 0.00124998
R21516 VSS.n4216 VSS.n4215 0.00106122
R21517 VSS.n6229 VSS.t2042 0.00100037
R21518 VSS.n6153 VSS.n9 0.001
R21519 VSS.n6154 VSS.n6153 0.001
R21520 VSS.n4351 VSS.n10 0.001
R21521 VSS.n4351 VSS.n311 0.001
R21522 VSS.n4521 VSS.n11 0.001
R21523 VSS.n4521 VSS.n323 0.001
R21524 VSS.n4359 VSS.n12 0.001
R21525 VSS.n4359 VSS.n312 0.001
R21526 VSS.n4478 VSS.n13 0.001
R21527 VSS.n4478 VSS.n322 0.001
R21528 VSS.n6157 VSS.n14 0.001
R21529 VSS.n6157 VSS.n6156 0.001
R21530 VSS.n320 VSS.n15 0.001
R21531 VSS.n321 VSS.n320 0.001
R21532 VSS.n6240 VSS.n3 0.001
R21533 VSS.n4709 VSS.n4615 0.001
R21534 VSS.n4615 VSS.n4243 0.001
R21535 VSS.n4623 VSS.n4244 0.001
R21536 VSS.n4709 VSS.n4708 0.001
R21537 VSS.n4623 VSS.n4243 0.001
R21538 VSS.n3957 VSS.t2658 0.001
R21539 VSS.n3986 VSS.n3957 0.001
R21540 VSS.n3890 VSS.t1449 0.001
R21541 VSS.n3912 VSS.n3890 0.001
R21542 VSS.n3683 VSS.t1963 0.001
R21543 VSS.n3990 VSS.n3683 0.001
R21544 VSS.n3823 VSS.t1704 0.001
R21545 VSS.n3845 VSS.n3823 0.001
R21546 VSS.n3775 VSS.t1148 0.001
R21547 VSS.n3778 VSS.n3775 0.001
R21548 VSS.n3727 VSS.t3263 0.001
R21549 VSS.n3730 VSS.n3727 0.001
R21550 VSS.n2351 VSS.t1184 0.001
R21551 VSS.n3417 VSS.n2351 0.001
R21552 VSS.n2582 VSS.t1730 0.001
R21553 VSS.n2583 VSS.n2582 0.001
R21554 VSS.n5229 VSS.t3353 0.001
R21555 VSS.n5325 VSS.n5229 0.001
R21556 VSS.n5181 VSS.t3402 0.001
R21557 VSS.n5184 VSS.n5181 0.001
R21558 VSS.n5114 VSS.t1595 0.001
R21559 VSS.n5136 VSS.n5114 0.001
R21560 VSS.n4956 VSS.t1855 0.001
R21561 VSS.n5329 VSS.n4956 0.001
R21562 VSS.n5047 VSS.t1343 0.001
R21563 VSS.n5069 VSS.n5047 0.001
R21564 VSS.n5303 VSS.t2770 0.001
R21565 VSS.n5304 VSS.n5303 0.001
R21566 VSS.n5555 VSS.t3645 0.001
R21567 VSS.n5584 VSS.n5555 0.001
R21568 VSS.n880 VSS.t46 0.001
R21569 VSS.n5588 VSS.n880 0.001
R21570 VSS.n5507 VSS.t1622 0.001
R21571 VSS.n5510 VSS.n5507 0.001
R21572 VSS.n1105 VSS.t1881 0.001
R21573 VSS.n5462 VSS.n1105 0.001
R21574 VSS.n1037 VSS.t1367 0.001
R21575 VSS.n1060 VSS.n1037 0.001
R21576 VSS.n970 VSS.t3457 0.001
R21577 VSS.n992 VSS.n970 0.001
R21578 VSS.n1744 VSS.t2295 0.001
R21579 VSS.n4123 VSS.n1744 0.001
R21580 VSS.n1436 VSS.t74 0.001
R21581 VSS.n4127 VSS.n1436 0.001
R21582 VSS.n1529 VSS.t1648 0.001
R21583 VSS.n1699 VSS.n1529 0.001
R21584 VSS.n1677 VSS.t1909 0.001
R21585 VSS.n1678 VSS.n1677 0.001
R21586 VSS.n1602 VSS.t1395 0.001
R21587 VSS.n1603 VSS.n1602 0.001
R21588 VSS.n4102 VSS.t2945 0.001
R21589 VSS.n4103 VSS.n4102 0.001
R21590 VSS.n2510 VSS.t1994 0.001
R21591 VSS.n2511 VSS.n2510 0.001
R21592 VSS.n3396 VSS.t1479 0.001
R21593 VSS.n3397 VSS.n3396 0.001
R21594 VSS.n2436 VSS.t2256 0.001
R21595 VSS.n2437 VSS.n2436 0.001
R21596 VSS.n3572 VSS.n1992 0.001
R21597 VSS.n2001 VSS.n1993 0.001
R21598 VSS.n2000 VSS.n1994 0.001
R21599 VSS.n1999 VSS.n1995 0.001
R21600 VSS.n1998 VSS.n1996 0.001
R21601 VSS.n2052 VSS.n2051 0.001
R21602 VSS.n2033 VSS.n2032 0.001
R21603 VSS.n2045 VSS.n2033 0.001
R21604 VSS.n2051 VSS.n2032 0.001
R21605 VSS.t2940 VSS.n1996 0.001
R21606 VSS.n1998 VSS.n1995 0.001
R21607 VSS.n1999 VSS.n1994 0.001
R21608 VSS.n2000 VSS.n1993 0.001
R21609 VSS.n2001 VSS.n1992 0.001
R21610 VSS.n3576 VSS.n1975 0.001
R21611 VSS.n4728 VSS.n4713 0.001
R21612 VSS.n4713 VSS.n4712 0.001
R21613 VSS.n4728 VSS.n4727 0.001
R21614 a_50809_690.t3 a_50809_690.n0 8.8328
R21615 a_50809_690.n2 a_50809_690.n3 1.14175
R21616 a_50809_690.n1 a_50809_690.n2 1.14175
R21617 a_50809_690.n0 a_50809_690.n1 1.14175
R21618 a_50809_690.n3 a_50809_690.t0 8.8328
R21619 a_50809_690.n3 a_50809_690.t4 8.8328
R21620 a_50809_690.n2 a_50809_690.t1 8.8328
R21621 a_50809_690.n2 a_50809_690.t5 8.8318
R21622 a_50809_690.n1 a_50809_690.t2 8.8328
R21623 a_50809_690.n1 a_50809_690.t7 8.8318
R21624 a_50809_690.n0 a_50809_690.t6 8.8318
R21625 a_48826_693.t0 a_48826_693.t1 35.1591
R21626 a_47950_629.t0 a_47950_629.t1 35.2643
R21627 a_49721_894.t0 a_49721_894.n0 8.76769
R21628 a_49721_894.n0 a_49721_894.t2 15.0661
R21629 a_49721_894.n0 a_49721_894.t1 5.94842
R21630 a_49148_833.n0 a_49148_833.t1 17.0005
R21631 a_49148_833.t0 a_49148_833.n0 18.2612
R21632 a_49148_833.n0 a_49148_833.t2 15.5529
R21633 a_48920_693.t1 a_48920_693.n0 17.5293
R21634 a_48920_693.n0 a_48920_693.t0 17.726
R21635 a_48920_693.n0 a_48920_693.t2 15.773
R21636 a_46818_617.t1 a_46818_617.n0 8.46601
R21637 a_46818_617.n0 a_46818_617.t2 9.03504
R21638 a_46818_617.n0 a_46818_617.t0 9.14806
R21639 a_48172_960.t0 a_48172_960.n1 17.3368
R21640 a_48172_960.n0 a_48172_960.t1 8.47322
R21641 a_48172_960.n1 a_48172_960.n0 0.103627
R21642 a_48172_960.n0 a_48172_960.t2 17.4516
R21643 a_48172_960.n1 a_48172_960.t3 15.0435
R21644 a_48070_873.n0 a_48070_873.t3 15.0005
R21645 a_48070_873.t0 a_48070_873.n0 17.9114
R21646 a_48070_873.n1 a_48070_873.t1 17.0005
R21647 a_48070_873.n0 a_48070_873.n1 0.655551
R21648 a_48070_873.n1 a_48070_873.t2 15.2176
R21649 a_47661_934.t0 a_47661_934.n2 17.1232
R21650 a_47661_934.n2 a_47661_934.n0 0.498937
R21651 a_47661_934.n2 a_47661_934.t1 18.4279
R21652 a_47661_934.n0 a_47661_934.n1 3.38952
R21653 a_47661_934.n1 a_47661_934.t3 18.3531
R21654 a_47661_934.n1 a_47661_934.t2 17.9378
R21655 a_47661_934.n0 a_47661_934.t4 15.4204
R21656 a_47375_616.n0 a_47375_616.t1 17.0005
R21657 a_47375_616.t0 a_47375_616.n0 18.3191
R21658 a_47375_616.n1 a_47375_616.t2 17.0005
R21659 a_47375_616.n0 a_47375_616.n1 3.28463
R21660 a_47375_616.n1 a_47375_616.t3 18.6222
R21661 a_47635_839.t0 a_47635_839.n1 17.3352
R21662 a_47635_839.n1 a_47635_839.t1 17.2651
R21663 a_47635_839.n1 a_47635_839.n0 0.948441
R21664 a_47635_839.n0 a_47635_839.t2 17.3305
R21665 a_47635_839.n0 a_47635_839.t3 15.4436
R21666 a_46919_914.t1 a_46919_914.n1 17.1443
R21667 a_46919_914.n1 a_46919_914.n0 0.743
R21668 a_46919_914.n0 a_46919_914.t0 8.65706
R21669 a_46919_914.n0 a_46919_914.t2 8.71106
R21670 a_46919_914.n1 a_46919_914.t3 15.731
R21671 a_46530_598.t0 a_46530_598.n0 8.81393
R21672 a_46530_598.n0 a_46530_598.t2 15.4488
R21673 a_46530_598.n0 a_46530_598.t1 6.09623
R21674 a_44289_690.t3 a_44289_690.n0 8.8328
R21675 a_44289_690.n2 a_44289_690.n3 1.14175
R21676 a_44289_690.n1 a_44289_690.n2 1.14175
R21677 a_44289_690.n0 a_44289_690.n1 1.14175
R21678 a_44289_690.n3 a_44289_690.t0 8.8328
R21679 a_44289_690.n3 a_44289_690.t4 8.8328
R21680 a_44289_690.n2 a_44289_690.t1 8.8328
R21681 a_44289_690.n2 a_44289_690.t5 8.8318
R21682 a_44289_690.n1 a_44289_690.t2 8.8328
R21683 a_44289_690.n1 a_44289_690.t7 8.8318
R21684 a_44289_690.n0 a_44289_690.t6 8.8318
R21685 a_42306_693.t0 a_42306_693.t1 35.1591
R21686 a_41430_629.t0 a_41430_629.t1 35.2643
R21687 a_46225_994.t0 a_46225_994.n0 17.1718
R21688 a_46225_994.n0 a_46225_994.t1 9.7433
R21689 a_46225_994.n0 a_46225_994.t2 15.4943
R21690 a_43201_894.t0 a_43201_894.n0 8.76769
R21691 a_43201_894.n0 a_43201_894.t2 15.0661
R21692 a_43201_894.n0 a_43201_894.t1 5.94842
R21693 a_42628_833.n0 a_42628_833.t1 17.0005
R21694 a_42628_833.t0 a_42628_833.n0 18.2612
R21695 a_42628_833.n0 a_42628_833.t2 15.5529
R21696 a_42400_693.t1 a_42400_693.n0 17.5293
R21697 a_42400_693.n0 a_42400_693.t0 17.726
R21698 a_42400_693.n0 a_42400_693.t2 15.773
R21699 a_40298_617.t1 a_40298_617.n0 8.46601
R21700 a_40298_617.n0 a_40298_617.t2 9.03504
R21701 a_40298_617.n0 a_40298_617.t0 9.14806
R21702 a_41652_960.t0 a_41652_960.n1 17.3368
R21703 a_41652_960.n0 a_41652_960.t1 8.47322
R21704 a_41652_960.n1 a_41652_960.n0 0.103627
R21705 a_41652_960.n0 a_41652_960.t2 17.4516
R21706 a_41652_960.n1 a_41652_960.t3 15.0435
R21707 a_41550_873.n0 a_41550_873.t3 15.0005
R21708 a_41550_873.t0 a_41550_873.n0 17.9114
R21709 a_41550_873.n1 a_41550_873.t1 17.0005
R21710 a_41550_873.n0 a_41550_873.n1 0.655551
R21711 a_41550_873.n1 a_41550_873.t2 15.2176
R21712 a_41141_934.t0 a_41141_934.n2 17.1232
R21713 a_41141_934.n2 a_41141_934.n0 0.498937
R21714 a_41141_934.n2 a_41141_934.t1 18.4279
R21715 a_41141_934.n0 a_41141_934.n1 3.38952
R21716 a_41141_934.n1 a_41141_934.t2 18.3531
R21717 a_41141_934.n1 a_41141_934.t3 17.9378
R21718 a_41141_934.n0 a_41141_934.t4 15.4204
R21719 a_40855_616.n0 a_40855_616.t1 17.0005
R21720 a_40855_616.t0 a_40855_616.n0 18.3191
R21721 a_40855_616.n1 a_40855_616.t3 17.0005
R21722 a_40855_616.n0 a_40855_616.n1 3.28463
R21723 a_40855_616.n1 a_40855_616.t2 18.6222
R21724 a_41115_839.t0 a_41115_839.n1 17.3352
R21725 a_41115_839.n1 a_41115_839.t1 17.2651
R21726 a_41115_839.n1 a_41115_839.n0 0.948441
R21727 a_41115_839.n0 a_41115_839.t2 17.3305
R21728 a_41115_839.n0 a_41115_839.t3 15.4436
R21729 a_40399_914.t1 a_40399_914.n1 17.1443
R21730 a_40399_914.n1 a_40399_914.n0 0.743
R21731 a_40399_914.n0 a_40399_914.t0 8.65706
R21732 a_40399_914.n0 a_40399_914.t2 8.71106
R21733 a_40399_914.n1 a_40399_914.t3 15.731
R21734 a_40010_598.t0 a_40010_598.n0 8.81393
R21735 a_40010_598.n0 a_40010_598.t2 15.4488
R21736 a_40010_598.n0 a_40010_598.t1 6.09623
R21737 a_37769_690.t3 a_37769_690.n0 8.8328
R21738 a_37769_690.n2 a_37769_690.n3 1.14175
R21739 a_37769_690.n1 a_37769_690.n2 1.14175
R21740 a_37769_690.n0 a_37769_690.n1 1.14175
R21741 a_37769_690.n3 a_37769_690.t0 8.8328
R21742 a_37769_690.n3 a_37769_690.t4 8.8328
R21743 a_37769_690.n2 a_37769_690.t1 8.8328
R21744 a_37769_690.n2 a_37769_690.t5 8.8318
R21745 a_37769_690.n1 a_37769_690.t2 8.8328
R21746 a_37769_690.n1 a_37769_690.t7 8.8318
R21747 a_37769_690.n0 a_37769_690.t6 8.8318
R21748 a_35786_693.t0 a_35786_693.t1 35.1591
R21749 a_34910_629.t0 a_34910_629.t1 35.2643
R21750 a_39705_994.t0 a_39705_994.n0 17.1718
R21751 a_39705_994.n0 a_39705_994.t1 9.7433
R21752 a_39705_994.n0 a_39705_994.t2 15.4943
R21753 a_36681_894.t0 a_36681_894.n0 8.76769
R21754 a_36681_894.n0 a_36681_894.t2 15.0661
R21755 a_36681_894.n0 a_36681_894.t1 5.94842
R21756 a_36108_833.n0 a_36108_833.t1 17.0005
R21757 a_36108_833.t0 a_36108_833.n0 18.2612
R21758 a_36108_833.n0 a_36108_833.t2 15.5529
R21759 a_35880_693.t1 a_35880_693.n0 17.5293
R21760 a_35880_693.n0 a_35880_693.t0 17.726
R21761 a_35880_693.n0 a_35880_693.t2 15.773
R21762 a_33778_617.t1 a_33778_617.n0 8.46601
R21763 a_33778_617.n0 a_33778_617.t2 9.03504
R21764 a_33778_617.n0 a_33778_617.t0 9.14806
R21765 a_35132_960.t0 a_35132_960.n1 17.3368
R21766 a_35132_960.n0 a_35132_960.t1 8.47322
R21767 a_35132_960.n1 a_35132_960.n0 0.103627
R21768 a_35132_960.n0 a_35132_960.t2 17.4516
R21769 a_35132_960.n1 a_35132_960.t3 15.0435
R21770 a_35030_873.n0 a_35030_873.t3 15.0005
R21771 a_35030_873.t0 a_35030_873.n0 17.9114
R21772 a_35030_873.n1 a_35030_873.t1 17.0005
R21773 a_35030_873.n0 a_35030_873.n1 0.655551
R21774 a_35030_873.n1 a_35030_873.t2 15.2176
R21775 a_34621_934.t0 a_34621_934.n2 17.1232
R21776 a_34621_934.n2 a_34621_934.n0 0.498937
R21777 a_34621_934.n2 a_34621_934.t1 18.4279
R21778 a_34621_934.n0 a_34621_934.n1 3.38952
R21779 a_34621_934.n1 a_34621_934.t3 18.3531
R21780 a_34621_934.n1 a_34621_934.t2 17.9378
R21781 a_34621_934.n0 a_34621_934.t4 15.4204
R21782 a_34335_616.n0 a_34335_616.t1 17.0005
R21783 a_34335_616.t0 a_34335_616.n0 18.3191
R21784 a_34335_616.n1 a_34335_616.t2 17.0005
R21785 a_34335_616.n0 a_34335_616.n1 3.28463
R21786 a_34335_616.n1 a_34335_616.t3 18.6222
R21787 a_34595_839.t0 a_34595_839.n1 17.3352
R21788 a_34595_839.n1 a_34595_839.t1 17.2651
R21789 a_34595_839.n1 a_34595_839.n0 0.948441
R21790 a_34595_839.n0 a_34595_839.t2 17.3305
R21791 a_34595_839.n0 a_34595_839.t3 15.4436
R21792 a_33879_914.t1 a_33879_914.n1 17.1443
R21793 a_33879_914.n1 a_33879_914.n0 0.743
R21794 a_33879_914.n0 a_33879_914.t0 8.65706
R21795 a_33879_914.n0 a_33879_914.t2 8.71106
R21796 a_33879_914.n1 a_33879_914.t3 15.731
R21797 a_33490_598.t0 a_33490_598.n0 8.81393
R21798 a_33490_598.n0 a_33490_598.t2 15.4488
R21799 a_33490_598.n0 a_33490_598.t1 6.09623
R21800 a_31249_690.t3 a_31249_690.n0 8.8328
R21801 a_31249_690.n2 a_31249_690.n3 1.14175
R21802 a_31249_690.n1 a_31249_690.n2 1.14175
R21803 a_31249_690.n0 a_31249_690.n1 1.14175
R21804 a_31249_690.n3 a_31249_690.t0 8.8328
R21805 a_31249_690.n3 a_31249_690.t4 8.8328
R21806 a_31249_690.n2 a_31249_690.t1 8.8328
R21807 a_31249_690.n2 a_31249_690.t5 8.8318
R21808 a_31249_690.n1 a_31249_690.t2 8.8328
R21809 a_31249_690.n1 a_31249_690.t7 8.8318
R21810 a_31249_690.n0 a_31249_690.t6 8.8318
R21811 a_29266_693.t0 a_29266_693.t1 35.1591
R21812 a_28390_629.t0 a_28390_629.t1 35.2643
R21813 a_33185_994.t0 a_33185_994.n0 17.1718
R21814 a_33185_994.n0 a_33185_994.t1 9.7433
R21815 a_33185_994.n0 a_33185_994.t2 15.4943
R21816 a_30161_894.t0 a_30161_894.n0 8.76769
R21817 a_30161_894.n0 a_30161_894.t2 15.0661
R21818 a_30161_894.n0 a_30161_894.t1 5.94842
R21819 a_29588_833.n0 a_29588_833.t1 17.0005
R21820 a_29588_833.t0 a_29588_833.n0 18.2612
R21821 a_29588_833.n0 a_29588_833.t2 15.5529
R21822 a_29360_693.t1 a_29360_693.n0 17.5293
R21823 a_29360_693.n0 a_29360_693.t0 17.726
R21824 a_29360_693.n0 a_29360_693.t2 15.773
R21825 a_27258_617.t1 a_27258_617.n0 8.46601
R21826 a_27258_617.n0 a_27258_617.t2 9.03504
R21827 a_27258_617.n0 a_27258_617.t0 9.14806
R21828 a_28612_960.t0 a_28612_960.n1 17.3368
R21829 a_28612_960.n0 a_28612_960.t1 8.47322
R21830 a_28612_960.n1 a_28612_960.n0 0.103627
R21831 a_28612_960.n0 a_28612_960.t2 17.4516
R21832 a_28612_960.n1 a_28612_960.t3 15.0435
R21833 a_28510_873.n0 a_28510_873.t3 15.0005
R21834 a_28510_873.t0 a_28510_873.n0 17.9114
R21835 a_28510_873.n1 a_28510_873.t1 17.0005
R21836 a_28510_873.n0 a_28510_873.n1 0.655551
R21837 a_28510_873.n1 a_28510_873.t2 15.2176
R21838 a_28101_934.t0 a_28101_934.n2 17.1232
R21839 a_28101_934.n2 a_28101_934.n0 0.498937
R21840 a_28101_934.n2 a_28101_934.t1 18.4279
R21841 a_28101_934.n0 a_28101_934.n1 3.38952
R21842 a_28101_934.n1 a_28101_934.t3 18.3531
R21843 a_28101_934.n1 a_28101_934.t2 17.9378
R21844 a_28101_934.n0 a_28101_934.t4 15.4204
R21845 a_27815_616.n0 a_27815_616.t1 17.0005
R21846 a_27815_616.t0 a_27815_616.n0 18.3191
R21847 a_27815_616.n1 a_27815_616.t2 17.0005
R21848 a_27815_616.n0 a_27815_616.n1 3.28463
R21849 a_27815_616.n1 a_27815_616.t3 18.6222
R21850 a_28075_839.t0 a_28075_839.n1 17.3352
R21851 a_28075_839.n1 a_28075_839.t1 17.2651
R21852 a_28075_839.n1 a_28075_839.n0 0.948441
R21853 a_28075_839.n0 a_28075_839.t2 17.3305
R21854 a_28075_839.n0 a_28075_839.t3 15.4436
R21855 a_27359_914.t1 a_27359_914.n1 17.1443
R21856 a_27359_914.n1 a_27359_914.n0 0.743
R21857 a_27359_914.n0 a_27359_914.t0 8.65706
R21858 a_27359_914.n0 a_27359_914.t2 8.71106
R21859 a_27359_914.n1 a_27359_914.t3 15.731
R21860 a_26970_598.t0 a_26970_598.n0 8.81393
R21861 a_26970_598.n0 a_26970_598.t2 15.4488
R21862 a_26970_598.n0 a_26970_598.t1 6.09623
R21863 a_24729_690.t3 a_24729_690.n0 8.8328
R21864 a_24729_690.n2 a_24729_690.n3 1.14175
R21865 a_24729_690.n1 a_24729_690.n2 1.14175
R21866 a_24729_690.n0 a_24729_690.n1 1.14175
R21867 a_24729_690.n3 a_24729_690.t0 8.8328
R21868 a_24729_690.n3 a_24729_690.t4 8.8328
R21869 a_24729_690.n2 a_24729_690.t1 8.8328
R21870 a_24729_690.n2 a_24729_690.t5 8.8318
R21871 a_24729_690.n1 a_24729_690.t2 8.8328
R21872 a_24729_690.n1 a_24729_690.t7 8.8318
R21873 a_24729_690.n0 a_24729_690.t6 8.8318
R21874 a_22746_693.t0 a_22746_693.t1 35.1591
R21875 a_21870_629.t0 a_21870_629.t1 35.2643
R21876 a_26665_994.t0 a_26665_994.n0 17.1718
R21877 a_26665_994.n0 a_26665_994.t1 9.7433
R21878 a_26665_994.n0 a_26665_994.t2 15.4943
R21879 a_23641_894.t0 a_23641_894.n0 8.76769
R21880 a_23641_894.n0 a_23641_894.t2 15.0661
R21881 a_23641_894.n0 a_23641_894.t1 5.94842
R21882 a_23068_833.n0 a_23068_833.t1 17.0005
R21883 a_23068_833.t0 a_23068_833.n0 18.2612
R21884 a_23068_833.n0 a_23068_833.t2 15.5529
R21885 a_22840_693.t1 a_22840_693.n0 17.5293
R21886 a_22840_693.n0 a_22840_693.t0 17.726
R21887 a_22840_693.n0 a_22840_693.t2 15.773
R21888 a_20738_617.t1 a_20738_617.n0 8.46601
R21889 a_20738_617.n0 a_20738_617.t2 9.03504
R21890 a_20738_617.n0 a_20738_617.t0 9.14806
R21891 a_22092_960.t0 a_22092_960.n1 17.3368
R21892 a_22092_960.n0 a_22092_960.t1 8.47322
R21893 a_22092_960.n1 a_22092_960.n0 0.103627
R21894 a_22092_960.n0 a_22092_960.t2 17.4516
R21895 a_22092_960.n1 a_22092_960.t3 15.0435
R21896 a_21990_873.n0 a_21990_873.t3 15.0005
R21897 a_21990_873.t0 a_21990_873.n0 17.9114
R21898 a_21990_873.n1 a_21990_873.t1 17.0005
R21899 a_21990_873.n0 a_21990_873.n1 0.655551
R21900 a_21990_873.n1 a_21990_873.t2 15.2176
R21901 a_21581_934.t0 a_21581_934.n2 17.1232
R21902 a_21581_934.n2 a_21581_934.n0 0.498937
R21903 a_21581_934.n2 a_21581_934.t1 18.4279
R21904 a_21581_934.n0 a_21581_934.n1 3.38952
R21905 a_21581_934.n1 a_21581_934.t2 18.3531
R21906 a_21581_934.n1 a_21581_934.t3 17.9378
R21907 a_21581_934.n0 a_21581_934.t4 15.4204
R21908 a_21295_616.t0 a_21295_616.n1 17.0005
R21909 a_21295_616.n1 a_21295_616.t1 18.3191
R21910 a_21295_616.n0 a_21295_616.t3 17.0005
R21911 a_21295_616.n1 a_21295_616.n0 3.28463
R21912 a_21295_616.n0 a_21295_616.t2 18.6222
R21913 a_21555_839.t0 a_21555_839.n1 17.2651
R21914 a_21555_839.n1 a_21555_839.t1 17.3352
R21915 a_21555_839.n1 a_21555_839.n0 0.948441
R21916 a_21555_839.n0 a_21555_839.t2 17.3305
R21917 a_21555_839.n0 a_21555_839.t3 15.4436
R21918 a_20839_914.t1 a_20839_914.n1 17.1443
R21919 a_20839_914.n1 a_20839_914.n0 0.743
R21920 a_20839_914.n0 a_20839_914.t0 8.65706
R21921 a_20839_914.n0 a_20839_914.t2 8.71106
R21922 a_20839_914.n1 a_20839_914.t3 15.731
R21923 a_20450_598.t0 a_20450_598.n0 8.81393
R21924 a_20450_598.n0 a_20450_598.t2 15.4488
R21925 a_20450_598.n0 a_20450_598.t1 6.09623
R21926 a_18209_690.t3 a_18209_690.n0 8.8328
R21927 a_18209_690.n2 a_18209_690.n3 1.14175
R21928 a_18209_690.n1 a_18209_690.n2 1.14175
R21929 a_18209_690.n0 a_18209_690.n1 1.14175
R21930 a_18209_690.n3 a_18209_690.t0 8.8328
R21931 a_18209_690.n3 a_18209_690.t4 8.8328
R21932 a_18209_690.n2 a_18209_690.t1 8.8328
R21933 a_18209_690.n2 a_18209_690.t5 8.8318
R21934 a_18209_690.n1 a_18209_690.t2 8.8328
R21935 a_18209_690.n1 a_18209_690.t7 8.8318
R21936 a_18209_690.n0 a_18209_690.t6 8.8318
R21937 a_16226_693.t0 a_16226_693.t1 35.1591
R21938 a_15350_629.t0 a_15350_629.t1 35.2643
R21939 a_20145_994.t0 a_20145_994.n0 17.1718
R21940 a_20145_994.n0 a_20145_994.t1 9.7433
R21941 a_20145_994.n0 a_20145_994.t2 15.4943
R21942 a_17121_894.t0 a_17121_894.n0 8.76769
R21943 a_17121_894.n0 a_17121_894.t2 15.0661
R21944 a_17121_894.n0 a_17121_894.t1 5.94842
R21945 a_16548_833.n0 a_16548_833.t1 17.0005
R21946 a_16548_833.t0 a_16548_833.n0 18.2612
R21947 a_16548_833.n0 a_16548_833.t2 15.5529
R21948 a_16320_693.t1 a_16320_693.n0 17.5293
R21949 a_16320_693.n0 a_16320_693.t0 17.726
R21950 a_16320_693.n0 a_16320_693.t2 15.773
R21951 a_14218_617.t1 a_14218_617.n0 8.46601
R21952 a_14218_617.n0 a_14218_617.t2 9.03504
R21953 a_14218_617.n0 a_14218_617.t0 9.14806
R21954 a_15572_960.t0 a_15572_960.n1 17.3368
R21955 a_15572_960.n0 a_15572_960.t1 8.47322
R21956 a_15572_960.n1 a_15572_960.n0 0.103627
R21957 a_15572_960.n0 a_15572_960.t2 17.4516
R21958 a_15572_960.n1 a_15572_960.t3 15.0435
R21959 a_15470_873.n0 a_15470_873.t3 15.0005
R21960 a_15470_873.t0 a_15470_873.n0 17.9114
R21961 a_15470_873.n1 a_15470_873.t1 17.0005
R21962 a_15470_873.n0 a_15470_873.n1 0.655551
R21963 a_15470_873.n1 a_15470_873.t2 15.2176
R21964 a_15061_934.t0 a_15061_934.n2 17.1232
R21965 a_15061_934.n2 a_15061_934.n0 0.498937
R21966 a_15061_934.n2 a_15061_934.t1 18.4279
R21967 a_15061_934.n0 a_15061_934.n1 3.38952
R21968 a_15061_934.n1 a_15061_934.t3 18.3531
R21969 a_15061_934.n1 a_15061_934.t2 17.9378
R21970 a_15061_934.n0 a_15061_934.t4 15.4204
R21971 a_14775_616.t0 a_14775_616.n1 17.0005
R21972 a_14775_616.n1 a_14775_616.t1 18.3191
R21973 a_14775_616.n0 a_14775_616.t2 17.0005
R21974 a_14775_616.n1 a_14775_616.n0 3.28463
R21975 a_14775_616.n0 a_14775_616.t3 18.6222
R21976 a_15035_839.t0 a_15035_839.n1 17.2651
R21977 a_15035_839.n1 a_15035_839.t1 17.3352
R21978 a_15035_839.n1 a_15035_839.n0 0.948441
R21979 a_15035_839.n0 a_15035_839.t2 17.3305
R21980 a_15035_839.n0 a_15035_839.t3 15.4436
R21981 a_14319_914.t1 a_14319_914.n1 17.1443
R21982 a_14319_914.n1 a_14319_914.n0 0.743
R21983 a_14319_914.n0 a_14319_914.t0 8.65706
R21984 a_14319_914.n0 a_14319_914.t2 8.71106
R21985 a_14319_914.n1 a_14319_914.t3 15.731
R21986 a_13930_598.t0 a_13930_598.n0 8.81393
R21987 a_13930_598.n0 a_13930_598.t2 15.4488
R21988 a_13930_598.n0 a_13930_598.t1 6.09623
R21989 a_11689_690.t3 a_11689_690.n0 8.8328
R21990 a_11689_690.n2 a_11689_690.n3 1.14175
R21991 a_11689_690.n1 a_11689_690.n2 1.14175
R21992 a_11689_690.n0 a_11689_690.n1 1.14175
R21993 a_11689_690.n3 a_11689_690.t0 8.8328
R21994 a_11689_690.n3 a_11689_690.t4 8.8328
R21995 a_11689_690.n2 a_11689_690.t1 8.8328
R21996 a_11689_690.n2 a_11689_690.t5 8.8318
R21997 a_11689_690.n1 a_11689_690.t2 8.8328
R21998 a_11689_690.n1 a_11689_690.t7 8.8318
R21999 a_11689_690.n0 a_11689_690.t6 8.8318
R22000 a_9706_693.t0 a_9706_693.t1 35.1591
R22001 a_8830_629.t0 a_8830_629.t1 35.2643
R22002 a_13625_994.t0 a_13625_994.n0 17.1718
R22003 a_13625_994.n0 a_13625_994.t1 9.7433
R22004 a_13625_994.n0 a_13625_994.t2 15.4943
R22005 a_10601_894.t0 a_10601_894.n0 8.76769
R22006 a_10601_894.n0 a_10601_894.t2 15.0661
R22007 a_10601_894.n0 a_10601_894.t1 5.94842
R22008 a_10028_833.n0 a_10028_833.t1 17.0005
R22009 a_10028_833.t0 a_10028_833.n0 18.2612
R22010 a_10028_833.n0 a_10028_833.t2 15.5529
R22011 a_9800_693.t1 a_9800_693.n0 17.5293
R22012 a_9800_693.n0 a_9800_693.t0 17.726
R22013 a_9800_693.n0 a_9800_693.t2 15.773
R22014 a_7698_617.t1 a_7698_617.n0 8.46601
R22015 a_7698_617.n0 a_7698_617.t2 9.03504
R22016 a_7698_617.n0 a_7698_617.t0 9.14806
R22017 a_9052_960.t0 a_9052_960.n1 17.3368
R22018 a_9052_960.n0 a_9052_960.t1 8.47322
R22019 a_9052_960.n1 a_9052_960.n0 0.103627
R22020 a_9052_960.n0 a_9052_960.t2 17.4516
R22021 a_9052_960.n1 a_9052_960.t3 15.0435
R22022 a_8950_873.n0 a_8950_873.t3 15.0005
R22023 a_8950_873.t0 a_8950_873.n0 17.9114
R22024 a_8950_873.n1 a_8950_873.t1 17.0005
R22025 a_8950_873.n0 a_8950_873.n1 0.655551
R22026 a_8950_873.n1 a_8950_873.t2 15.2176
R22027 a_8541_934.t0 a_8541_934.n2 17.1232
R22028 a_8541_934.n2 a_8541_934.n0 0.498937
R22029 a_8541_934.n2 a_8541_934.t1 18.4279
R22030 a_8541_934.n0 a_8541_934.n1 3.38952
R22031 a_8541_934.n1 a_8541_934.t3 18.3531
R22032 a_8541_934.n1 a_8541_934.t2 17.9378
R22033 a_8541_934.n0 a_8541_934.t4 15.4204
R22034 a_8255_616.n0 a_8255_616.t1 17.0005
R22035 a_8255_616.t0 a_8255_616.n0 18.3191
R22036 a_8255_616.n1 a_8255_616.t2 17.0005
R22037 a_8255_616.n0 a_8255_616.n1 3.28463
R22038 a_8255_616.n1 a_8255_616.t3 18.6222
R22039 a_8515_839.t0 a_8515_839.n1 17.3352
R22040 a_8515_839.n1 a_8515_839.t1 17.2651
R22041 a_8515_839.n1 a_8515_839.n0 0.948441
R22042 a_8515_839.n0 a_8515_839.t2 17.3305
R22043 a_8515_839.n0 a_8515_839.t3 15.4436
R22044 a_7799_914.t1 a_7799_914.n1 17.1443
R22045 a_7799_914.n1 a_7799_914.n0 0.743
R22046 a_7799_914.n0 a_7799_914.t0 8.65706
R22047 a_7799_914.n0 a_7799_914.t2 8.71106
R22048 a_7799_914.n1 a_7799_914.t3 15.731
R22049 a_7410_598.t0 a_7410_598.n0 8.81393
R22050 a_7410_598.n0 a_7410_598.t2 15.4488
R22051 a_7410_598.n0 a_7410_598.t1 6.09623
R22052 a_5169_690.t3 a_5169_690.n0 8.8328
R22053 a_5169_690.n2 a_5169_690.n3 1.14175
R22054 a_5169_690.n1 a_5169_690.n2 1.14175
R22055 a_5169_690.n0 a_5169_690.n1 1.14175
R22056 a_5169_690.n3 a_5169_690.t0 8.8328
R22057 a_5169_690.n3 a_5169_690.t4 8.8328
R22058 a_5169_690.n2 a_5169_690.t1 8.8328
R22059 a_5169_690.n2 a_5169_690.t5 8.8318
R22060 a_5169_690.n1 a_5169_690.t2 8.8328
R22061 a_5169_690.n1 a_5169_690.t7 8.8318
R22062 a_5169_690.n0 a_5169_690.t6 8.8318
R22063 a_3186_693.t0 a_3186_693.t1 35.1591
R22064 a_2310_629.t0 a_2310_629.t1 35.2643
R22065 a_7105_994.t0 a_7105_994.n0 17.1718
R22066 a_7105_994.n0 a_7105_994.t1 9.7433
R22067 a_7105_994.n0 a_7105_994.t2 15.4943
R22068 a_4081_894.t0 a_4081_894.n0 8.76769
R22069 a_4081_894.n0 a_4081_894.t2 15.0661
R22070 a_4081_894.n0 a_4081_894.t1 5.94842
R22071 a_3508_833.t0 a_3508_833.n0 17.0005
R22072 a_3508_833.n0 a_3508_833.t1 18.2612
R22073 a_3508_833.n0 a_3508_833.t2 15.5529
R22074 a_3280_693.t1 a_3280_693.n0 17.5293
R22075 a_3280_693.n0 a_3280_693.t0 17.726
R22076 a_3280_693.n0 a_3280_693.t2 15.773
R22077 a_1178_617.t1 a_1178_617.n0 8.46601
R22078 a_1178_617.n0 a_1178_617.t2 9.03504
R22079 a_1178_617.n0 a_1178_617.t0 9.14806
R22080 a_2532_960.t0 a_2532_960.n1 17.3368
R22081 a_2532_960.n0 a_2532_960.t1 8.47322
R22082 a_2532_960.n1 a_2532_960.n0 0.103627
R22083 a_2532_960.n0 a_2532_960.t2 17.4516
R22084 a_2532_960.n1 a_2532_960.t3 15.0435
R22085 a_2430_873.n0 a_2430_873.t3 15.0005
R22086 a_2430_873.t0 a_2430_873.n0 17.9114
R22087 a_2430_873.n1 a_2430_873.t1 17.0005
R22088 a_2430_873.n0 a_2430_873.n1 0.655551
R22089 a_2430_873.n1 a_2430_873.t2 15.2176
R22090 a_2021_934.t0 a_2021_934.n2 17.1232
R22091 a_2021_934.n2 a_2021_934.n0 0.498937
R22092 a_2021_934.n2 a_2021_934.t1 18.4279
R22093 a_2021_934.n0 a_2021_934.n1 3.38952
R22094 a_2021_934.n1 a_2021_934.t3 18.3531
R22095 a_2021_934.n1 a_2021_934.t2 17.9378
R22096 a_2021_934.n0 a_2021_934.t4 15.4204
R22097 a_1735_616.n0 a_1735_616.t1 17.0005
R22098 a_1735_616.t0 a_1735_616.n0 18.3191
R22099 a_1735_616.n1 a_1735_616.t2 17.0005
R22100 a_1735_616.n0 a_1735_616.n1 3.28463
R22101 a_1735_616.n1 a_1735_616.t3 18.6222
R22102 a_1995_839.t0 a_1995_839.n1 17.2651
R22103 a_1995_839.n1 a_1995_839.t1 17.3352
R22104 a_1995_839.n1 a_1995_839.n0 0.948441
R22105 a_1995_839.n0 a_1995_839.t2 17.3305
R22106 a_1995_839.n0 a_1995_839.t3 15.4436
R22107 a_1279_914.t1 a_1279_914.n1 17.1443
R22108 a_1279_914.n1 a_1279_914.n0 0.743
R22109 a_1279_914.n0 a_1279_914.t0 8.65706
R22110 a_1279_914.n0 a_1279_914.t2 8.71106
R22111 a_1279_914.n1 a_1279_914.t3 15.731
R22112 a_890_598.t0 a_890_598.n0 8.81393
R22113 a_890_598.n0 a_890_598.t2 15.4488
R22114 a_890_598.n0 a_890_598.t1 6.09623
R22115 a_n2966_249.t0 a_n2966_249.n0 9.7443
R22116 a_n2966_249.n0 a_n2966_249.t2 16.0733
R22117 a_n2966_249.n0 a_n2966_249.t1 6.02395
R22118 a_585_994.t0 a_585_994.n0 17.1718
R22119 a_585_994.n0 a_585_994.t1 9.7433
R22120 a_585_994.n0 a_585_994.t2 15.4943
R22121 a_50643_950.t9 a_50643_950.n5 8.90498
R22122 a_50643_950.n5 a_50643_950.t3 10.0462
R22123 a_50643_950.n5 a_50643_950.n0 1.09706
R22124 a_50643_950.n0 a_50643_950.n4 1.09706
R22125 a_50643_950.n4 a_50643_950.t7 8.90498
R22126 a_50643_950.n4 a_50643_950.t2 10.0462
R22127 a_50643_950.n0 a_50643_950.n1 18.263
R22128 a_50643_950.n3 a_50643_950.t5 17.0005
R22129 a_50643_950.n1 a_50643_950.n3 1.37206
R22130 a_50643_950.n3 a_50643_950.t1 18.9255
R22131 a_50643_950.n2 a_50643_950.t4 17.0005
R22132 a_50643_950.n1 a_50643_950.n2 1.37206
R22133 a_50643_950.n2 a_50643_950.t0 18.9255
R22134 a_50643_950.n1 a_50643_950.t6 17.6708
R22135 a_50643_950.n0 a_50643_950.t8 8.81561
R22136 a_44123_950.t9 a_44123_950.n5 8.90498
R22137 a_44123_950.n5 a_44123_950.t3 10.0462
R22138 a_44123_950.n5 a_44123_950.n0 1.09706
R22139 a_44123_950.n0 a_44123_950.n4 1.09706
R22140 a_44123_950.n4 a_44123_950.t7 8.90498
R22141 a_44123_950.n4 a_44123_950.t2 10.0462
R22142 a_44123_950.n0 a_44123_950.n1 18.263
R22143 a_44123_950.n3 a_44123_950.t5 17.0005
R22144 a_44123_950.n1 a_44123_950.n3 1.37206
R22145 a_44123_950.n3 a_44123_950.t1 18.9255
R22146 a_44123_950.n2 a_44123_950.t4 17.0005
R22147 a_44123_950.n1 a_44123_950.n2 1.37206
R22148 a_44123_950.n2 a_44123_950.t0 18.9255
R22149 a_44123_950.n1 a_44123_950.t6 17.6708
R22150 a_44123_950.n0 a_44123_950.t8 8.81561
R22151 a_37603_950.t9 a_37603_950.n5 8.90498
R22152 a_37603_950.n5 a_37603_950.t3 10.0462
R22153 a_37603_950.n5 a_37603_950.n0 1.09706
R22154 a_37603_950.n0 a_37603_950.n4 1.09706
R22155 a_37603_950.n4 a_37603_950.t7 8.90498
R22156 a_37603_950.n4 a_37603_950.t2 10.0462
R22157 a_37603_950.n0 a_37603_950.n1 18.263
R22158 a_37603_950.n3 a_37603_950.t5 17.0005
R22159 a_37603_950.n1 a_37603_950.n3 1.37206
R22160 a_37603_950.n3 a_37603_950.t1 18.9255
R22161 a_37603_950.n2 a_37603_950.t4 17.0005
R22162 a_37603_950.n1 a_37603_950.n2 1.37206
R22163 a_37603_950.n2 a_37603_950.t0 18.9255
R22164 a_37603_950.n1 a_37603_950.t6 17.6708
R22165 a_37603_950.n0 a_37603_950.t8 8.81561
R22166 a_31083_950.t9 a_31083_950.n5 8.90498
R22167 a_31083_950.n5 a_31083_950.t3 10.0462
R22168 a_31083_950.n5 a_31083_950.n0 1.09706
R22169 a_31083_950.n0 a_31083_950.n4 1.09706
R22170 a_31083_950.n4 a_31083_950.t7 8.90498
R22171 a_31083_950.n4 a_31083_950.t2 10.0462
R22172 a_31083_950.n0 a_31083_950.n1 18.263
R22173 a_31083_950.n3 a_31083_950.t5 17.0005
R22174 a_31083_950.n1 a_31083_950.n3 1.37206
R22175 a_31083_950.n3 a_31083_950.t1 18.9255
R22176 a_31083_950.n2 a_31083_950.t4 17.0005
R22177 a_31083_950.n1 a_31083_950.n2 1.37206
R22178 a_31083_950.n2 a_31083_950.t0 18.9255
R22179 a_31083_950.n1 a_31083_950.t6 17.6708
R22180 a_31083_950.n0 a_31083_950.t8 8.81561
R22181 a_24563_950.t9 a_24563_950.n5 8.90498
R22182 a_24563_950.n5 a_24563_950.t3 10.0462
R22183 a_24563_950.n5 a_24563_950.n0 1.09706
R22184 a_24563_950.n0 a_24563_950.n4 1.09706
R22185 a_24563_950.n4 a_24563_950.t7 8.90498
R22186 a_24563_950.n4 a_24563_950.t2 10.0462
R22187 a_24563_950.n0 a_24563_950.n1 18.263
R22188 a_24563_950.n3 a_24563_950.t5 17.0005
R22189 a_24563_950.n1 a_24563_950.n3 1.37206
R22190 a_24563_950.n3 a_24563_950.t1 18.9255
R22191 a_24563_950.n2 a_24563_950.t4 17.0005
R22192 a_24563_950.n1 a_24563_950.n2 1.37206
R22193 a_24563_950.n2 a_24563_950.t0 18.9255
R22194 a_24563_950.n1 a_24563_950.t6 17.6708
R22195 a_24563_950.n0 a_24563_950.t8 8.81561
R22196 a_18043_950.t9 a_18043_950.n5 8.90498
R22197 a_18043_950.n5 a_18043_950.t3 10.0462
R22198 a_18043_950.n5 a_18043_950.n0 1.09706
R22199 a_18043_950.n0 a_18043_950.n4 1.09706
R22200 a_18043_950.n4 a_18043_950.t7 8.90498
R22201 a_18043_950.n4 a_18043_950.t2 10.0462
R22202 a_18043_950.n0 a_18043_950.n1 18.263
R22203 a_18043_950.n3 a_18043_950.t5 17.0005
R22204 a_18043_950.n1 a_18043_950.n3 1.37206
R22205 a_18043_950.n3 a_18043_950.t1 18.9255
R22206 a_18043_950.n2 a_18043_950.t4 17.0005
R22207 a_18043_950.n1 a_18043_950.n2 1.37206
R22208 a_18043_950.n2 a_18043_950.t0 18.9255
R22209 a_18043_950.n1 a_18043_950.t6 17.6708
R22210 a_18043_950.n0 a_18043_950.t8 8.81561
R22211 a_11523_950.t9 a_11523_950.n5 8.90498
R22212 a_11523_950.n5 a_11523_950.t3 10.0462
R22213 a_11523_950.n5 a_11523_950.n0 1.09706
R22214 a_11523_950.n0 a_11523_950.n4 1.09706
R22215 a_11523_950.n4 a_11523_950.t7 8.90498
R22216 a_11523_950.n4 a_11523_950.t2 10.0462
R22217 a_11523_950.n0 a_11523_950.n1 18.263
R22218 a_11523_950.n3 a_11523_950.t5 17.0005
R22219 a_11523_950.n1 a_11523_950.n3 1.37206
R22220 a_11523_950.n3 a_11523_950.t1 18.9255
R22221 a_11523_950.n2 a_11523_950.t4 17.0005
R22222 a_11523_950.n1 a_11523_950.n2 1.37206
R22223 a_11523_950.n2 a_11523_950.t0 18.9255
R22224 a_11523_950.n1 a_11523_950.t6 17.6708
R22225 a_11523_950.n0 a_11523_950.t8 8.81561
R22226 a_5003_950.t9 a_5003_950.n5 8.90498
R22227 a_5003_950.n5 a_5003_950.t3 10.0462
R22228 a_5003_950.n5 a_5003_950.n0 1.09706
R22229 a_5003_950.n0 a_5003_950.n4 1.09706
R22230 a_5003_950.n4 a_5003_950.t7 8.90498
R22231 a_5003_950.n4 a_5003_950.t2 10.0462
R22232 a_5003_950.n0 a_5003_950.n1 18.263
R22233 a_5003_950.n3 a_5003_950.t5 17.0005
R22234 a_5003_950.n1 a_5003_950.n3 1.37206
R22235 a_5003_950.n3 a_5003_950.t1 18.9255
R22236 a_5003_950.n2 a_5003_950.t4 17.0005
R22237 a_5003_950.n1 a_5003_950.n2 1.37206
R22238 a_5003_950.n2 a_5003_950.t0 18.9255
R22239 a_5003_950.n1 a_5003_950.t6 17.6708
R22240 a_5003_950.n0 a_5003_950.t8 8.81561
R22241 a_n2347_1368.t0 a_n2347_1368.n0 17.1718
R22242 a_n2347_1368.n0 a_n2347_1368.t1 9.7433
R22243 a_n2347_1368.n0 a_n2347_1368.t2 15.4943
R22244 a_n2648_1016.t0 a_n2648_1016.n0 8.74253
R22245 a_n2648_1016.n0 a_n2648_1016.t2 33.6729
R22246 a_n2648_1016.n0 a_n2648_1016.t1 5.96776
R22247 a_n2946_1036.t0 a_n2946_1036.n0 17.5197
R22248 a_n2946_1036.n0 a_n2946_1036.t1 8.76789
R22249 a_n2946_1036.n0 a_n2946_1036.t2 15.4262
R22250 a_49938_914.t0 a_49938_914.n0 8.53521
R22251 a_49938_914.n0 a_49938_914.t2 16.6582
R22252 a_49938_914.n0 a_49938_914.t1 6.13582
R22253 a_43418_914.t0 a_43418_914.n0 8.53521
R22254 a_43418_914.n0 a_43418_914.t2 16.6582
R22255 a_43418_914.n0 a_43418_914.t1 6.13582
R22256 a_49517_894.t0 a_49517_894.n0 8.53379
R22257 a_49517_894.n0 a_49517_894.t1 6.23476
R22258 a_49517_894.n0 a_49517_894.t2 35.9286
R22259 a_36898_914.t0 a_36898_914.n0 8.53521
R22260 a_36898_914.n0 a_36898_914.t2 16.6582
R22261 a_36898_914.n0 a_36898_914.t1 6.13582
R22262 a_42997_894.t0 a_42997_894.n0 8.53379
R22263 a_42997_894.n0 a_42997_894.t1 6.23476
R22264 a_42997_894.n0 a_42997_894.t2 35.9286
R22265 a_30378_914.t0 a_30378_914.n0 8.53521
R22266 a_30378_914.n0 a_30378_914.t2 16.6582
R22267 a_30378_914.n0 a_30378_914.t1 6.13582
R22268 a_36477_894.t0 a_36477_894.n0 8.53379
R22269 a_36477_894.n0 a_36477_894.t1 6.23476
R22270 a_36477_894.n0 a_36477_894.t2 35.9286
R22271 a_23858_914.t0 a_23858_914.n0 8.53521
R22272 a_23858_914.n0 a_23858_914.t2 16.6582
R22273 a_23858_914.n0 a_23858_914.t1 6.13582
R22274 a_29957_894.t0 a_29957_894.n0 8.53379
R22275 a_29957_894.n0 a_29957_894.t1 6.23476
R22276 a_29957_894.n0 a_29957_894.t2 35.9286
R22277 a_17338_914.t0 a_17338_914.n0 8.53521
R22278 a_17338_914.n0 a_17338_914.t2 16.6582
R22279 a_17338_914.n0 a_17338_914.t1 6.13582
R22280 a_23437_894.t0 a_23437_894.n0 8.53379
R22281 a_23437_894.n0 a_23437_894.t1 6.23476
R22282 a_23437_894.n0 a_23437_894.t2 35.9286
R22283 a_10818_914.t0 a_10818_914.n0 8.53521
R22284 a_10818_914.n0 a_10818_914.t2 16.6582
R22285 a_10818_914.n0 a_10818_914.t1 6.13582
R22286 a_16917_894.t0 a_16917_894.n0 8.53379
R22287 a_16917_894.n0 a_16917_894.t1 6.23476
R22288 a_16917_894.n0 a_16917_894.t2 35.9286
R22289 a_4298_914.t0 a_4298_914.n0 8.53521
R22290 a_4298_914.n0 a_4298_914.t2 16.6582
R22291 a_4298_914.n0 a_4298_914.t1 6.13582
R22292 a_10397_894.t0 a_10397_894.n0 8.53379
R22293 a_10397_894.n0 a_10397_894.t1 6.23476
R22294 a_10397_894.n0 a_10397_894.t2 35.9286
R22295 a_3877_894.t0 a_3877_894.n0 8.53379
R22296 a_3877_894.n0 a_3877_894.t1 6.23476
R22297 a_3877_894.n0 a_3877_894.t2 35.9286
R22298 a_n2342_2100.t1 a_n2342_2100.n0 17.5197
R22299 a_n2342_2100.n0 a_n2342_2100.t0 8.76789
R22300 a_n2342_2100.n0 a_n2342_2100.t2 15.4262
R22301 a_n2646_1728.t0 a_n2646_1728.n0 8.9656
R22302 a_n2646_1728.n0 a_n2646_1728.t1 6.17123
R22303 a_n2646_1728.n0 a_n2646_1728.t2 33.6161
R22304 a_n2951_1728.t0 a_n2951_1728.n0 17.1718
R22305 a_n2951_1728.n0 a_n2951_1728.t1 9.7433
R22306 a_n2951_1728.n0 a_n2951_1728.t2 15.4943
R22307 a_n2347_2880.t0 a_n2347_2880.n0 17.1718
R22308 a_n2347_2880.n0 a_n2347_2880.t1 9.7433
R22309 a_n2347_2880.n0 a_n2347_2880.t2 15.4943
R22310 a_n2951_2880.t0 a_n2951_2880.n0 17.1718
R22311 a_n2951_2880.n0 a_n2951_2880.t1 9.7433
R22312 a_n2951_2880.n0 a_n2951_2880.t2 15.4943
R22313 a_50809_3490.t3 a_50809_3490.n0 8.8328
R22314 a_50809_3490.n2 a_50809_3490.n3 1.14175
R22315 a_50809_3490.n1 a_50809_3490.n2 1.14175
R22316 a_50809_3490.n0 a_50809_3490.n1 1.14175
R22317 a_50809_3490.n3 a_50809_3490.t0 8.8328
R22318 a_50809_3490.n3 a_50809_3490.t4 8.8328
R22319 a_50809_3490.n2 a_50809_3490.t1 8.8328
R22320 a_50809_3490.n2 a_50809_3490.t5 8.8318
R22321 a_50809_3490.n1 a_50809_3490.t2 8.8328
R22322 a_50809_3490.n1 a_50809_3490.t7 8.8318
R22323 a_50809_3490.n0 a_50809_3490.t6 8.8318
R22324 a_48826_3493.t0 a_48826_3493.t1 35.1591
R22325 a_47950_3429.t0 a_47950_3429.t1 35.2643
R22326 a_49721_3694.t0 a_49721_3694.n0 8.76769
R22327 a_49721_3694.n0 a_49721_3694.t2 15.0661
R22328 a_49721_3694.n0 a_49721_3694.t1 5.94842
R22329 a_49148_3633.n0 a_49148_3633.t1 17.0005
R22330 a_49148_3633.t0 a_49148_3633.n0 18.2612
R22331 a_49148_3633.n0 a_49148_3633.t2 15.5529
R22332 a_48920_3493.t1 a_48920_3493.n0 17.5293
R22333 a_48920_3493.n0 a_48920_3493.t0 17.726
R22334 a_48920_3493.n0 a_48920_3493.t2 15.773
R22335 a_46818_3417.n0 a_46818_3417.t0 8.46601
R22336 a_46818_3417.t1 a_46818_3417.n0 9.03504
R22337 a_46818_3417.n0 a_46818_3417.t2 9.14806
R22338 a_48172_3760.t0 a_48172_3760.n1 17.3368
R22339 a_48172_3760.n0 a_48172_3760.t1 8.47322
R22340 a_48172_3760.n1 a_48172_3760.n0 0.103627
R22341 a_48172_3760.n0 a_48172_3760.t2 17.4516
R22342 a_48172_3760.n1 a_48172_3760.t3 15.0435
R22343 a_48070_3673.n0 a_48070_3673.t3 15.0005
R22344 a_48070_3673.t0 a_48070_3673.n0 17.9114
R22345 a_48070_3673.n1 a_48070_3673.t1 17.0005
R22346 a_48070_3673.n0 a_48070_3673.n1 0.655551
R22347 a_48070_3673.n1 a_48070_3673.t2 15.2176
R22348 a_47661_3734.t0 a_47661_3734.n2 17.1232
R22349 a_47661_3734.n2 a_47661_3734.n0 0.498937
R22350 a_47661_3734.n2 a_47661_3734.t1 18.4279
R22351 a_47661_3734.n0 a_47661_3734.n1 3.38952
R22352 a_47661_3734.n1 a_47661_3734.t3 18.3531
R22353 a_47661_3734.n1 a_47661_3734.t2 17.9378
R22354 a_47661_3734.n0 a_47661_3734.t4 15.4204
R22355 a_47375_3416.n0 a_47375_3416.t1 17.0005
R22356 a_47375_3416.t0 a_47375_3416.n0 18.3191
R22357 a_47375_3416.n1 a_47375_3416.t2 17.0005
R22358 a_47375_3416.n0 a_47375_3416.n1 3.28463
R22359 a_47375_3416.n1 a_47375_3416.t3 18.6222
R22360 a_47635_3639.t0 a_47635_3639.n1 17.3352
R22361 a_47635_3639.n1 a_47635_3639.t1 17.2651
R22362 a_47635_3639.n1 a_47635_3639.n0 0.948441
R22363 a_47635_3639.n0 a_47635_3639.t2 17.3305
R22364 a_47635_3639.n0 a_47635_3639.t3 15.4436
R22365 a_46919_3714.t0 a_46919_3714.n1 17.1443
R22366 a_46919_3714.n1 a_46919_3714.n0 0.743
R22367 a_46919_3714.n0 a_46919_3714.t2 8.65706
R22368 a_46919_3714.n0 a_46919_3714.t1 8.71106
R22369 a_46919_3714.n1 a_46919_3714.t3 15.731
R22370 a_46530_3398.t0 a_46530_3398.n0 8.81393
R22371 a_46530_3398.n0 a_46530_3398.t2 15.4488
R22372 a_46530_3398.n0 a_46530_3398.t1 6.09623
R22373 a_44289_3490.t3 a_44289_3490.n0 8.8328
R22374 a_44289_3490.n2 a_44289_3490.n3 1.14175
R22375 a_44289_3490.n1 a_44289_3490.n2 1.14175
R22376 a_44289_3490.n0 a_44289_3490.n1 1.14175
R22377 a_44289_3490.n3 a_44289_3490.t0 8.8328
R22378 a_44289_3490.n3 a_44289_3490.t4 8.8328
R22379 a_44289_3490.n2 a_44289_3490.t1 8.8328
R22380 a_44289_3490.n2 a_44289_3490.t5 8.8318
R22381 a_44289_3490.n1 a_44289_3490.t2 8.8328
R22382 a_44289_3490.n1 a_44289_3490.t7 8.8318
R22383 a_44289_3490.n0 a_44289_3490.t6 8.8318
R22384 a_42306_3493.t0 a_42306_3493.t1 35.1591
R22385 a_41430_3429.t0 a_41430_3429.t1 35.2643
R22386 a_46225_3794.t0 a_46225_3794.n0 17.1718
R22387 a_46225_3794.n0 a_46225_3794.t1 9.7433
R22388 a_46225_3794.n0 a_46225_3794.t2 15.4943
R22389 a_43201_3694.t0 a_43201_3694.n0 8.76769
R22390 a_43201_3694.n0 a_43201_3694.t2 15.0661
R22391 a_43201_3694.n0 a_43201_3694.t1 5.94842
R22392 a_42628_3633.n0 a_42628_3633.t1 17.0005
R22393 a_42628_3633.t0 a_42628_3633.n0 18.2612
R22394 a_42628_3633.n0 a_42628_3633.t2 15.5529
R22395 a_42400_3493.t1 a_42400_3493.n0 17.5293
R22396 a_42400_3493.n0 a_42400_3493.t0 17.726
R22397 a_42400_3493.n0 a_42400_3493.t2 15.773
R22398 a_40298_3417.n0 a_40298_3417.t0 8.46601
R22399 a_40298_3417.t1 a_40298_3417.n0 9.03504
R22400 a_40298_3417.n0 a_40298_3417.t2 9.14806
R22401 a_41652_3760.t0 a_41652_3760.n1 17.3368
R22402 a_41652_3760.n0 a_41652_3760.t1 8.47322
R22403 a_41652_3760.n1 a_41652_3760.n0 0.103627
R22404 a_41652_3760.n0 a_41652_3760.t2 17.4516
R22405 a_41652_3760.n1 a_41652_3760.t3 15.0435
R22406 a_41550_3673.n0 a_41550_3673.t3 15.0005
R22407 a_41550_3673.t0 a_41550_3673.n0 17.9114
R22408 a_41550_3673.n1 a_41550_3673.t1 17.0005
R22409 a_41550_3673.n0 a_41550_3673.n1 0.655551
R22410 a_41550_3673.n1 a_41550_3673.t2 15.2176
R22411 a_41141_3734.t0 a_41141_3734.n2 17.1232
R22412 a_41141_3734.n2 a_41141_3734.n0 0.498937
R22413 a_41141_3734.n2 a_41141_3734.t1 18.4279
R22414 a_41141_3734.n0 a_41141_3734.n1 3.38952
R22415 a_41141_3734.n1 a_41141_3734.t3 18.3531
R22416 a_41141_3734.n1 a_41141_3734.t2 17.9378
R22417 a_41141_3734.n0 a_41141_3734.t4 15.4204
R22418 a_40855_3416.n0 a_40855_3416.t1 17.0005
R22419 a_40855_3416.t0 a_40855_3416.n0 18.3191
R22420 a_40855_3416.n1 a_40855_3416.t2 17.0005
R22421 a_40855_3416.n0 a_40855_3416.n1 3.28463
R22422 a_40855_3416.n1 a_40855_3416.t3 18.6222
R22423 a_41115_3639.t0 a_41115_3639.n1 17.3352
R22424 a_41115_3639.n1 a_41115_3639.t1 17.2651
R22425 a_41115_3639.n1 a_41115_3639.n0 0.948441
R22426 a_41115_3639.n0 a_41115_3639.t2 17.3305
R22427 a_41115_3639.n0 a_41115_3639.t3 15.4436
R22428 a_40399_3714.t0 a_40399_3714.n1 17.1443
R22429 a_40399_3714.n1 a_40399_3714.n0 0.743
R22430 a_40399_3714.n0 a_40399_3714.t2 8.65706
R22431 a_40399_3714.n0 a_40399_3714.t1 8.71106
R22432 a_40399_3714.n1 a_40399_3714.t3 15.731
R22433 a_40010_3398.t0 a_40010_3398.n0 8.81393
R22434 a_40010_3398.n0 a_40010_3398.t2 15.4488
R22435 a_40010_3398.n0 a_40010_3398.t1 6.09623
R22436 a_37769_3490.t3 a_37769_3490.n0 8.8328
R22437 a_37769_3490.n2 a_37769_3490.n3 1.14175
R22438 a_37769_3490.n1 a_37769_3490.n2 1.14175
R22439 a_37769_3490.n0 a_37769_3490.n1 1.14175
R22440 a_37769_3490.n3 a_37769_3490.t0 8.8328
R22441 a_37769_3490.n3 a_37769_3490.t4 8.8328
R22442 a_37769_3490.n2 a_37769_3490.t1 8.8328
R22443 a_37769_3490.n2 a_37769_3490.t5 8.8318
R22444 a_37769_3490.n1 a_37769_3490.t2 8.8328
R22445 a_37769_3490.n1 a_37769_3490.t7 8.8318
R22446 a_37769_3490.n0 a_37769_3490.t6 8.8318
R22447 a_35786_3493.t0 a_35786_3493.t1 35.1591
R22448 a_34910_3429.t0 a_34910_3429.t1 35.2643
R22449 a_39705_3794.t0 a_39705_3794.n0 17.1718
R22450 a_39705_3794.n0 a_39705_3794.t1 9.7433
R22451 a_39705_3794.n0 a_39705_3794.t2 15.4943
R22452 a_36681_3694.t0 a_36681_3694.n0 8.76769
R22453 a_36681_3694.n0 a_36681_3694.t2 15.0661
R22454 a_36681_3694.n0 a_36681_3694.t1 5.94842
R22455 a_36108_3633.n0 a_36108_3633.t1 17.0005
R22456 a_36108_3633.t0 a_36108_3633.n0 18.2612
R22457 a_36108_3633.n0 a_36108_3633.t2 15.5529
R22458 a_35880_3493.t1 a_35880_3493.n0 17.5293
R22459 a_35880_3493.n0 a_35880_3493.t0 17.726
R22460 a_35880_3493.n0 a_35880_3493.t2 15.773
R22461 a_33778_3417.n0 a_33778_3417.t0 8.46601
R22462 a_33778_3417.t1 a_33778_3417.n0 9.03504
R22463 a_33778_3417.n0 a_33778_3417.t2 9.14806
R22464 a_35132_3760.t0 a_35132_3760.n1 17.3368
R22465 a_35132_3760.n0 a_35132_3760.t1 8.47322
R22466 a_35132_3760.n1 a_35132_3760.n0 0.103627
R22467 a_35132_3760.n0 a_35132_3760.t2 17.4516
R22468 a_35132_3760.n1 a_35132_3760.t3 15.0435
R22469 a_35030_3673.n0 a_35030_3673.t3 15.0005
R22470 a_35030_3673.t0 a_35030_3673.n0 17.9114
R22471 a_35030_3673.n1 a_35030_3673.t1 17.0005
R22472 a_35030_3673.n0 a_35030_3673.n1 0.655551
R22473 a_35030_3673.n1 a_35030_3673.t2 15.2176
R22474 a_34621_3734.t0 a_34621_3734.n2 17.1232
R22475 a_34621_3734.n2 a_34621_3734.n0 0.498937
R22476 a_34621_3734.n2 a_34621_3734.t1 18.4279
R22477 a_34621_3734.n0 a_34621_3734.n1 3.38952
R22478 a_34621_3734.n1 a_34621_3734.t3 18.3531
R22479 a_34621_3734.n1 a_34621_3734.t2 17.9378
R22480 a_34621_3734.n0 a_34621_3734.t4 15.4204
R22481 a_34335_3416.n0 a_34335_3416.t1 17.0005
R22482 a_34335_3416.t0 a_34335_3416.n0 18.3191
R22483 a_34335_3416.n1 a_34335_3416.t2 17.0005
R22484 a_34335_3416.n0 a_34335_3416.n1 3.28463
R22485 a_34335_3416.n1 a_34335_3416.t3 18.6222
R22486 a_34595_3639.t0 a_34595_3639.n1 17.3352
R22487 a_34595_3639.n1 a_34595_3639.t1 17.2651
R22488 a_34595_3639.n1 a_34595_3639.n0 0.948441
R22489 a_34595_3639.n0 a_34595_3639.t2 17.3305
R22490 a_34595_3639.n0 a_34595_3639.t3 15.4436
R22491 a_33879_3714.t0 a_33879_3714.n1 17.1443
R22492 a_33879_3714.n1 a_33879_3714.n0 0.743
R22493 a_33879_3714.n0 a_33879_3714.t2 8.65706
R22494 a_33879_3714.n0 a_33879_3714.t1 8.71106
R22495 a_33879_3714.n1 a_33879_3714.t3 15.731
R22496 a_33490_3398.t0 a_33490_3398.n0 8.81393
R22497 a_33490_3398.n0 a_33490_3398.t2 15.4488
R22498 a_33490_3398.n0 a_33490_3398.t1 6.09623
R22499 a_31249_3490.t3 a_31249_3490.n0 8.8328
R22500 a_31249_3490.n2 a_31249_3490.n3 1.14175
R22501 a_31249_3490.n1 a_31249_3490.n2 1.14175
R22502 a_31249_3490.n0 a_31249_3490.n1 1.14175
R22503 a_31249_3490.n3 a_31249_3490.t0 8.8328
R22504 a_31249_3490.n3 a_31249_3490.t4 8.8328
R22505 a_31249_3490.n2 a_31249_3490.t1 8.8328
R22506 a_31249_3490.n2 a_31249_3490.t5 8.8318
R22507 a_31249_3490.n1 a_31249_3490.t2 8.8328
R22508 a_31249_3490.n1 a_31249_3490.t7 8.8318
R22509 a_31249_3490.n0 a_31249_3490.t6 8.8318
R22510 a_29266_3493.t0 a_29266_3493.t1 35.1591
R22511 a_28390_3429.t0 a_28390_3429.t1 35.2643
R22512 a_33185_3794.t0 a_33185_3794.n0 17.1718
R22513 a_33185_3794.n0 a_33185_3794.t1 9.7433
R22514 a_33185_3794.n0 a_33185_3794.t2 15.4943
R22515 a_30161_3694.t0 a_30161_3694.n0 8.76769
R22516 a_30161_3694.n0 a_30161_3694.t2 15.0661
R22517 a_30161_3694.n0 a_30161_3694.t1 5.94842
R22518 a_29588_3633.n0 a_29588_3633.t1 17.0005
R22519 a_29588_3633.t0 a_29588_3633.n0 18.2612
R22520 a_29588_3633.n0 a_29588_3633.t2 15.5529
R22521 a_29360_3493.t1 a_29360_3493.n0 17.5293
R22522 a_29360_3493.n0 a_29360_3493.t0 17.726
R22523 a_29360_3493.n0 a_29360_3493.t2 15.773
R22524 a_27258_3417.n0 a_27258_3417.t0 8.46601
R22525 a_27258_3417.t1 a_27258_3417.n0 9.03504
R22526 a_27258_3417.n0 a_27258_3417.t2 9.14806
R22527 a_28612_3760.t0 a_28612_3760.n1 17.3368
R22528 a_28612_3760.n0 a_28612_3760.t1 8.47322
R22529 a_28612_3760.n1 a_28612_3760.n0 0.103627
R22530 a_28612_3760.n0 a_28612_3760.t2 17.4516
R22531 a_28612_3760.n1 a_28612_3760.t3 15.0435
R22532 a_28510_3673.n0 a_28510_3673.t3 15.0005
R22533 a_28510_3673.t0 a_28510_3673.n0 17.9114
R22534 a_28510_3673.n1 a_28510_3673.t1 17.0005
R22535 a_28510_3673.n0 a_28510_3673.n1 0.655551
R22536 a_28510_3673.n1 a_28510_3673.t2 15.2176
R22537 a_28101_3734.t0 a_28101_3734.n2 17.1232
R22538 a_28101_3734.n2 a_28101_3734.n0 0.498937
R22539 a_28101_3734.n2 a_28101_3734.t1 18.4279
R22540 a_28101_3734.n0 a_28101_3734.n1 3.38952
R22541 a_28101_3734.n1 a_28101_3734.t3 18.3531
R22542 a_28101_3734.n1 a_28101_3734.t2 17.9378
R22543 a_28101_3734.n0 a_28101_3734.t4 15.4204
R22544 a_27815_3416.n0 a_27815_3416.t1 17.0005
R22545 a_27815_3416.t0 a_27815_3416.n0 18.3191
R22546 a_27815_3416.n1 a_27815_3416.t2 17.0005
R22547 a_27815_3416.n0 a_27815_3416.n1 3.28463
R22548 a_27815_3416.n1 a_27815_3416.t3 18.6222
R22549 a_28075_3639.t0 a_28075_3639.n1 17.2651
R22550 a_28075_3639.n1 a_28075_3639.t1 17.3352
R22551 a_28075_3639.n1 a_28075_3639.n0 0.948441
R22552 a_28075_3639.n0 a_28075_3639.t2 17.3305
R22553 a_28075_3639.n0 a_28075_3639.t3 15.4436
R22554 a_27359_3714.t1 a_27359_3714.n1 17.1443
R22555 a_27359_3714.n1 a_27359_3714.n0 0.743
R22556 a_27359_3714.n0 a_27359_3714.t2 8.65706
R22557 a_27359_3714.n0 a_27359_3714.t0 8.71106
R22558 a_27359_3714.n1 a_27359_3714.t3 15.731
R22559 a_26970_3398.t0 a_26970_3398.n0 8.81393
R22560 a_26970_3398.n0 a_26970_3398.t2 15.4488
R22561 a_26970_3398.n0 a_26970_3398.t1 6.09623
R22562 a_24729_3490.t3 a_24729_3490.n0 8.8328
R22563 a_24729_3490.n2 a_24729_3490.n3 1.14175
R22564 a_24729_3490.n1 a_24729_3490.n2 1.14175
R22565 a_24729_3490.n0 a_24729_3490.n1 1.14175
R22566 a_24729_3490.n3 a_24729_3490.t0 8.8328
R22567 a_24729_3490.n3 a_24729_3490.t4 8.8328
R22568 a_24729_3490.n2 a_24729_3490.t1 8.8328
R22569 a_24729_3490.n2 a_24729_3490.t5 8.8318
R22570 a_24729_3490.n1 a_24729_3490.t2 8.8328
R22571 a_24729_3490.n1 a_24729_3490.t7 8.8318
R22572 a_24729_3490.n0 a_24729_3490.t6 8.8318
R22573 a_22746_3493.t0 a_22746_3493.t1 35.1591
R22574 a_21870_3429.t0 a_21870_3429.t1 35.2643
R22575 a_26665_3794.t0 a_26665_3794.n0 17.1718
R22576 a_26665_3794.n0 a_26665_3794.t1 9.7433
R22577 a_26665_3794.n0 a_26665_3794.t2 15.4943
R22578 a_23641_3694.t0 a_23641_3694.n0 8.76769
R22579 a_23641_3694.n0 a_23641_3694.t2 15.0661
R22580 a_23641_3694.n0 a_23641_3694.t1 5.94842
R22581 a_23068_3633.t0 a_23068_3633.n0 17.0005
R22582 a_23068_3633.n0 a_23068_3633.t1 18.2612
R22583 a_23068_3633.n0 a_23068_3633.t2 15.5529
R22584 a_22840_3493.t1 a_22840_3493.n0 17.5293
R22585 a_22840_3493.n0 a_22840_3493.t0 17.726
R22586 a_22840_3493.n0 a_22840_3493.t2 15.773
R22587 a_20738_3417.n0 a_20738_3417.t0 8.46601
R22588 a_20738_3417.t1 a_20738_3417.n0 9.03504
R22589 a_20738_3417.n0 a_20738_3417.t2 9.14806
R22590 a_22092_3760.t0 a_22092_3760.n1 17.3368
R22591 a_22092_3760.n0 a_22092_3760.t1 8.47322
R22592 a_22092_3760.n1 a_22092_3760.n0 0.103627
R22593 a_22092_3760.n0 a_22092_3760.t2 17.4516
R22594 a_22092_3760.n1 a_22092_3760.t3 15.0435
R22595 a_21990_3673.n0 a_21990_3673.t3 15.0005
R22596 a_21990_3673.t0 a_21990_3673.n0 17.9114
R22597 a_21990_3673.n1 a_21990_3673.t1 17.0005
R22598 a_21990_3673.n0 a_21990_3673.n1 0.655551
R22599 a_21990_3673.n1 a_21990_3673.t2 15.2176
R22600 a_21581_3734.t0 a_21581_3734.n2 17.1232
R22601 a_21581_3734.n2 a_21581_3734.n0 0.498937
R22602 a_21581_3734.n2 a_21581_3734.t1 18.4279
R22603 a_21581_3734.n0 a_21581_3734.n1 3.38952
R22604 a_21581_3734.n1 a_21581_3734.t3 18.3531
R22605 a_21581_3734.n1 a_21581_3734.t2 17.9378
R22606 a_21581_3734.n0 a_21581_3734.t4 15.4204
R22607 a_21295_3416.n0 a_21295_3416.t1 17.0005
R22608 a_21295_3416.t0 a_21295_3416.n0 18.3191
R22609 a_21295_3416.n1 a_21295_3416.t2 17.0005
R22610 a_21295_3416.n0 a_21295_3416.n1 3.28463
R22611 a_21295_3416.n1 a_21295_3416.t3 18.6222
R22612 a_21555_3639.t0 a_21555_3639.n1 17.3352
R22613 a_21555_3639.n1 a_21555_3639.t1 17.2651
R22614 a_21555_3639.n1 a_21555_3639.n0 0.948441
R22615 a_21555_3639.n0 a_21555_3639.t2 17.3305
R22616 a_21555_3639.n0 a_21555_3639.t3 15.4436
R22617 a_20839_3714.t0 a_20839_3714.n1 17.1443
R22618 a_20839_3714.n1 a_20839_3714.n0 0.743
R22619 a_20839_3714.n0 a_20839_3714.t2 8.65706
R22620 a_20839_3714.n0 a_20839_3714.t1 8.71106
R22621 a_20839_3714.n1 a_20839_3714.t3 15.731
R22622 a_20450_3398.t0 a_20450_3398.n0 8.81393
R22623 a_20450_3398.n0 a_20450_3398.t2 15.4488
R22624 a_20450_3398.n0 a_20450_3398.t1 6.09623
R22625 a_18209_3490.t3 a_18209_3490.n0 8.8328
R22626 a_18209_3490.n2 a_18209_3490.n3 1.14175
R22627 a_18209_3490.n1 a_18209_3490.n2 1.14175
R22628 a_18209_3490.n0 a_18209_3490.n1 1.14175
R22629 a_18209_3490.n3 a_18209_3490.t0 8.8328
R22630 a_18209_3490.n3 a_18209_3490.t4 8.8328
R22631 a_18209_3490.n2 a_18209_3490.t1 8.8328
R22632 a_18209_3490.n2 a_18209_3490.t5 8.8318
R22633 a_18209_3490.n1 a_18209_3490.t2 8.8328
R22634 a_18209_3490.n1 a_18209_3490.t7 8.8318
R22635 a_18209_3490.n0 a_18209_3490.t6 8.8318
R22636 a_16226_3493.t0 a_16226_3493.t1 35.1591
R22637 a_15350_3429.t0 a_15350_3429.t1 35.2643
R22638 a_20145_3794.t0 a_20145_3794.n0 17.1718
R22639 a_20145_3794.n0 a_20145_3794.t1 9.7433
R22640 a_20145_3794.n0 a_20145_3794.t2 15.4943
R22641 a_17121_3694.t0 a_17121_3694.n0 8.76769
R22642 a_17121_3694.n0 a_17121_3694.t2 15.0661
R22643 a_17121_3694.n0 a_17121_3694.t1 5.94842
R22644 a_16548_3633.n0 a_16548_3633.t1 17.0005
R22645 a_16548_3633.t0 a_16548_3633.n0 18.2612
R22646 a_16548_3633.n0 a_16548_3633.t2 15.5529
R22647 a_16320_3493.t1 a_16320_3493.n0 17.5293
R22648 a_16320_3493.n0 a_16320_3493.t0 17.726
R22649 a_16320_3493.n0 a_16320_3493.t2 15.773
R22650 a_14218_3417.n0 a_14218_3417.t0 8.46601
R22651 a_14218_3417.t1 a_14218_3417.n0 9.03504
R22652 a_14218_3417.n0 a_14218_3417.t2 9.14806
R22653 a_15572_3760.t0 a_15572_3760.n1 17.3368
R22654 a_15572_3760.n0 a_15572_3760.t1 8.47322
R22655 a_15572_3760.n1 a_15572_3760.n0 0.103627
R22656 a_15572_3760.n0 a_15572_3760.t2 17.4516
R22657 a_15572_3760.n1 a_15572_3760.t3 15.0435
R22658 a_15470_3673.n0 a_15470_3673.t3 15.0005
R22659 a_15470_3673.t0 a_15470_3673.n0 17.9114
R22660 a_15470_3673.n1 a_15470_3673.t1 17.0005
R22661 a_15470_3673.n0 a_15470_3673.n1 0.655551
R22662 a_15470_3673.n1 a_15470_3673.t2 15.2176
R22663 a_15061_3734.t0 a_15061_3734.n2 17.1232
R22664 a_15061_3734.n2 a_15061_3734.n0 0.498937
R22665 a_15061_3734.n2 a_15061_3734.t1 18.4279
R22666 a_15061_3734.n0 a_15061_3734.n1 3.38952
R22667 a_15061_3734.n1 a_15061_3734.t3 18.3531
R22668 a_15061_3734.n1 a_15061_3734.t2 17.9378
R22669 a_15061_3734.n0 a_15061_3734.t4 15.4204
R22670 a_14775_3416.t0 a_14775_3416.n1 17.0005
R22671 a_14775_3416.n1 a_14775_3416.t1 18.3191
R22672 a_14775_3416.n0 a_14775_3416.t2 17.0005
R22673 a_14775_3416.n1 a_14775_3416.n0 3.28463
R22674 a_14775_3416.n0 a_14775_3416.t3 18.6222
R22675 a_15035_3639.t0 a_15035_3639.n1 17.3352
R22676 a_15035_3639.n1 a_15035_3639.t1 17.2651
R22677 a_15035_3639.n1 a_15035_3639.n0 0.948441
R22678 a_15035_3639.n0 a_15035_3639.t2 17.3305
R22679 a_15035_3639.n0 a_15035_3639.t3 15.4436
R22680 a_14319_3714.t0 a_14319_3714.n1 17.1443
R22681 a_14319_3714.n1 a_14319_3714.n0 0.743
R22682 a_14319_3714.n0 a_14319_3714.t2 8.65706
R22683 a_14319_3714.n0 a_14319_3714.t1 8.71106
R22684 a_14319_3714.n1 a_14319_3714.t3 15.731
R22685 a_13930_3398.t0 a_13930_3398.n0 8.81393
R22686 a_13930_3398.n0 a_13930_3398.t2 15.4488
R22687 a_13930_3398.n0 a_13930_3398.t1 6.09623
R22688 a_11689_3490.t3 a_11689_3490.n0 8.8328
R22689 a_11689_3490.n2 a_11689_3490.n3 1.14175
R22690 a_11689_3490.n1 a_11689_3490.n2 1.14175
R22691 a_11689_3490.n0 a_11689_3490.n1 1.14175
R22692 a_11689_3490.n3 a_11689_3490.t0 8.8328
R22693 a_11689_3490.n3 a_11689_3490.t4 8.8328
R22694 a_11689_3490.n2 a_11689_3490.t1 8.8328
R22695 a_11689_3490.n2 a_11689_3490.t5 8.8318
R22696 a_11689_3490.n1 a_11689_3490.t2 8.8328
R22697 a_11689_3490.n1 a_11689_3490.t7 8.8318
R22698 a_11689_3490.n0 a_11689_3490.t6 8.8318
R22699 a_9706_3493.t0 a_9706_3493.t1 35.1591
R22700 a_8830_3429.t0 a_8830_3429.t1 35.2643
R22701 a_13625_3794.t0 a_13625_3794.n0 17.1718
R22702 a_13625_3794.n0 a_13625_3794.t1 9.7433
R22703 a_13625_3794.n0 a_13625_3794.t2 15.4943
R22704 a_10601_3694.t0 a_10601_3694.n0 8.76769
R22705 a_10601_3694.n0 a_10601_3694.t2 15.0661
R22706 a_10601_3694.n0 a_10601_3694.t1 5.94842
R22707 a_10028_3633.n0 a_10028_3633.t1 17.0005
R22708 a_10028_3633.t0 a_10028_3633.n0 18.2612
R22709 a_10028_3633.n0 a_10028_3633.t2 15.5529
R22710 a_9800_3493.t1 a_9800_3493.n0 17.5293
R22711 a_9800_3493.n0 a_9800_3493.t0 17.726
R22712 a_9800_3493.n0 a_9800_3493.t2 15.773
R22713 a_7698_3417.n0 a_7698_3417.t0 8.46601
R22714 a_7698_3417.t1 a_7698_3417.n0 9.03504
R22715 a_7698_3417.n0 a_7698_3417.t2 9.14806
R22716 a_9052_3760.t0 a_9052_3760.n1 17.3368
R22717 a_9052_3760.n0 a_9052_3760.t1 8.47322
R22718 a_9052_3760.n1 a_9052_3760.n0 0.103627
R22719 a_9052_3760.n0 a_9052_3760.t2 17.4516
R22720 a_9052_3760.n1 a_9052_3760.t3 15.0435
R22721 a_8950_3673.n0 a_8950_3673.t3 15.0005
R22722 a_8950_3673.t0 a_8950_3673.n0 17.9114
R22723 a_8950_3673.n1 a_8950_3673.t1 17.0005
R22724 a_8950_3673.n0 a_8950_3673.n1 0.655551
R22725 a_8950_3673.n1 a_8950_3673.t2 15.2176
R22726 a_8541_3734.t0 a_8541_3734.n2 17.1232
R22727 a_8541_3734.n2 a_8541_3734.n0 0.498937
R22728 a_8541_3734.n2 a_8541_3734.t1 18.4279
R22729 a_8541_3734.n0 a_8541_3734.n1 3.38952
R22730 a_8541_3734.n1 a_8541_3734.t3 18.3531
R22731 a_8541_3734.n1 a_8541_3734.t2 17.9378
R22732 a_8541_3734.n0 a_8541_3734.t4 15.4204
R22733 a_8255_3416.n0 a_8255_3416.t1 17.0005
R22734 a_8255_3416.t0 a_8255_3416.n0 18.3191
R22735 a_8255_3416.n1 a_8255_3416.t2 17.0005
R22736 a_8255_3416.n0 a_8255_3416.n1 3.28463
R22737 a_8255_3416.n1 a_8255_3416.t3 18.6222
R22738 a_8515_3639.t0 a_8515_3639.n1 17.3352
R22739 a_8515_3639.n1 a_8515_3639.t1 17.2651
R22740 a_8515_3639.n1 a_8515_3639.n0 0.948441
R22741 a_8515_3639.n0 a_8515_3639.t2 17.3305
R22742 a_8515_3639.n0 a_8515_3639.t3 15.4436
R22743 a_7799_3714.t0 a_7799_3714.n1 17.1443
R22744 a_7799_3714.n1 a_7799_3714.n0 0.743
R22745 a_7799_3714.n0 a_7799_3714.t2 8.65706
R22746 a_7799_3714.n0 a_7799_3714.t1 8.71106
R22747 a_7799_3714.n1 a_7799_3714.t3 15.731
R22748 a_7410_3398.t0 a_7410_3398.n0 8.81393
R22749 a_7410_3398.n0 a_7410_3398.t2 15.4488
R22750 a_7410_3398.n0 a_7410_3398.t1 6.09623
R22751 a_5169_3490.t3 a_5169_3490.n0 8.8328
R22752 a_5169_3490.n2 a_5169_3490.n3 1.14175
R22753 a_5169_3490.n1 a_5169_3490.n2 1.14175
R22754 a_5169_3490.n0 a_5169_3490.n1 1.14175
R22755 a_5169_3490.n3 a_5169_3490.t0 8.8328
R22756 a_5169_3490.n3 a_5169_3490.t4 8.8328
R22757 a_5169_3490.n2 a_5169_3490.t1 8.8328
R22758 a_5169_3490.n2 a_5169_3490.t5 8.8318
R22759 a_5169_3490.n1 a_5169_3490.t2 8.8328
R22760 a_5169_3490.n1 a_5169_3490.t7 8.8318
R22761 a_5169_3490.n0 a_5169_3490.t6 8.8318
R22762 a_3186_3493.t0 a_3186_3493.t1 35.1591
R22763 a_2310_3429.t0 a_2310_3429.t1 35.2643
R22764 a_7105_3794.t0 a_7105_3794.n0 17.1718
R22765 a_7105_3794.n0 a_7105_3794.t1 9.7433
R22766 a_7105_3794.n0 a_7105_3794.t2 15.4943
R22767 a_4081_3694.t0 a_4081_3694.n0 8.76769
R22768 a_4081_3694.n0 a_4081_3694.t2 15.0661
R22769 a_4081_3694.n0 a_4081_3694.t1 5.94842
R22770 a_3508_3633.n0 a_3508_3633.t1 17.0005
R22771 a_3508_3633.t0 a_3508_3633.n0 18.2612
R22772 a_3508_3633.n0 a_3508_3633.t2 15.5529
R22773 a_3280_3493.t1 a_3280_3493.n0 17.5293
R22774 a_3280_3493.n0 a_3280_3493.t0 17.726
R22775 a_3280_3493.n0 a_3280_3493.t2 15.773
R22776 a_1178_3417.t1 a_1178_3417.n0 8.46601
R22777 a_1178_3417.n0 a_1178_3417.t2 9.03504
R22778 a_1178_3417.n0 a_1178_3417.t0 9.14806
R22779 a_2532_3760.t0 a_2532_3760.n1 17.3368
R22780 a_2532_3760.n0 a_2532_3760.t1 8.47322
R22781 a_2532_3760.n1 a_2532_3760.n0 0.103627
R22782 a_2532_3760.n0 a_2532_3760.t2 17.4516
R22783 a_2532_3760.n1 a_2532_3760.t3 15.0435
R22784 a_2430_3673.n0 a_2430_3673.t3 15.0005
R22785 a_2430_3673.t0 a_2430_3673.n0 17.9114
R22786 a_2430_3673.n1 a_2430_3673.t1 17.0005
R22787 a_2430_3673.n0 a_2430_3673.n1 0.655551
R22788 a_2430_3673.n1 a_2430_3673.t2 15.2176
R22789 a_2021_3734.t0 a_2021_3734.n2 17.1232
R22790 a_2021_3734.n2 a_2021_3734.n0 0.498937
R22791 a_2021_3734.n2 a_2021_3734.t1 18.4279
R22792 a_2021_3734.n0 a_2021_3734.n1 3.38952
R22793 a_2021_3734.n1 a_2021_3734.t2 18.3531
R22794 a_2021_3734.n1 a_2021_3734.t3 17.9378
R22795 a_2021_3734.n0 a_2021_3734.t4 15.4204
R22796 a_1735_3416.n0 a_1735_3416.t1 17.0005
R22797 a_1735_3416.t0 a_1735_3416.n0 18.3191
R22798 a_1735_3416.n1 a_1735_3416.t3 17.0005
R22799 a_1735_3416.n0 a_1735_3416.n1 3.28463
R22800 a_1735_3416.n1 a_1735_3416.t2 18.6222
R22801 a_1995_3639.t0 a_1995_3639.n1 17.3352
R22802 a_1995_3639.n1 a_1995_3639.t1 17.2651
R22803 a_1995_3639.n1 a_1995_3639.n0 0.948441
R22804 a_1995_3639.n0 a_1995_3639.t2 17.3305
R22805 a_1995_3639.n0 a_1995_3639.t3 15.4436
R22806 a_1279_3714.t1 a_1279_3714.n1 17.1443
R22807 a_1279_3714.n1 a_1279_3714.n0 0.743
R22808 a_1279_3714.n0 a_1279_3714.t0 8.65706
R22809 a_1279_3714.n0 a_1279_3714.t2 8.71106
R22810 a_1279_3714.n1 a_1279_3714.t3 15.731
R22811 a_n2042_2484.t0 a_n2042_2484.n0 8.96998
R22812 a_n2042_2484.n0 a_n2042_2484.t1 6.13517
R22813 a_n2042_2484.n0 a_n2042_2484.n15 17.0745
R22814 a_n2042_2484.n15 a_n2042_2484.n14 0.557571
R22815 a_n2042_2484.n14 a_n2042_2484.n13 4.56629
R22816 a_n2042_2484.n13 a_n2042_2484.n12 0.557571
R22817 a_n2042_2484.n12 a_n2042_2484.n11 4.56629
R22818 a_n2042_2484.n11 a_n2042_2484.n10 0.557571
R22819 a_n2042_2484.n10 a_n2042_2484.n9 4.56629
R22820 a_n2042_2484.n9 a_n2042_2484.n8 0.557571
R22821 a_n2042_2484.n8 a_n2042_2484.n7 4.56629
R22822 a_n2042_2484.n7 a_n2042_2484.n6 0.557571
R22823 a_n2042_2484.n6 a_n2042_2484.n5 4.56629
R22824 a_n2042_2484.n5 a_n2042_2484.n4 0.557571
R22825 a_n2042_2484.n4 a_n2042_2484.n3 4.56629
R22826 a_n2042_2484.n3 a_n2042_2484.n2 0.557571
R22827 a_n2042_2484.n2 a_n2042_2484.n1 4.56629
R22828 a_n2042_2484.n1 a_n2042_2484.t10 30.2193
R22829 a_n2042_2484.n15 a_n2042_2484.t9 31.6835
R22830 a_n2042_2484.n14 a_n2042_2484.t17 29.6622
R22831 a_n2042_2484.n13 a_n2042_2484.t8 31.6835
R22832 a_n2042_2484.n12 a_n2042_2484.t16 29.6622
R22833 a_n2042_2484.n11 a_n2042_2484.t7 31.6835
R22834 a_n2042_2484.n10 a_n2042_2484.t15 29.6622
R22835 a_n2042_2484.n9 a_n2042_2484.t6 31.6835
R22836 a_n2042_2484.n8 a_n2042_2484.t14 29.6622
R22837 a_n2042_2484.n7 a_n2042_2484.t5 31.6835
R22838 a_n2042_2484.n6 a_n2042_2484.t13 29.6622
R22839 a_n2042_2484.n5 a_n2042_2484.t4 31.6835
R22840 a_n2042_2484.n4 a_n2042_2484.t12 29.6622
R22841 a_n2042_2484.n3 a_n2042_2484.t3 31.6835
R22842 a_n2042_2484.n2 a_n2042_2484.t11 29.6622
R22843 a_n2042_2484.n1 a_n2042_2484.t2 31.6835
R22844 a_890_3398.t0 a_890_3398.n0 8.81393
R22845 a_890_3398.n0 a_890_3398.t2 15.4488
R22846 a_890_3398.n0 a_890_3398.t1 6.09623
R22847 a_n2946_3612.t1 a_n2946_3612.n0 17.5197
R22848 a_n2946_3612.n0 a_n2946_3612.t0 8.76789
R22849 a_n2946_3612.n0 a_n2946_3612.t2 15.4262
R22850 a_585_3794.t0 a_585_3794.n0 17.1718
R22851 a_585_3794.n0 a_585_3794.t1 9.7433
R22852 a_585_3794.n0 a_585_3794.t2 15.4943
R22853 a_50643_3750.t9 a_50643_3750.n5 8.90498
R22854 a_50643_3750.n5 a_50643_3750.t3 10.0462
R22855 a_50643_3750.n5 a_50643_3750.n0 1.09706
R22856 a_50643_3750.n0 a_50643_3750.n4 1.09706
R22857 a_50643_3750.n4 a_50643_3750.t7 8.90498
R22858 a_50643_3750.n4 a_50643_3750.t2 10.0462
R22859 a_50643_3750.n0 a_50643_3750.n1 18.263
R22860 a_50643_3750.n3 a_50643_3750.t5 17.0005
R22861 a_50643_3750.n1 a_50643_3750.n3 1.37206
R22862 a_50643_3750.n3 a_50643_3750.t1 18.9255
R22863 a_50643_3750.n2 a_50643_3750.t4 17.0005
R22864 a_50643_3750.n1 a_50643_3750.n2 1.37206
R22865 a_50643_3750.n2 a_50643_3750.t0 18.9255
R22866 a_50643_3750.n1 a_50643_3750.t6 17.6708
R22867 a_50643_3750.n0 a_50643_3750.t8 8.81561
R22868 a_44123_3750.t9 a_44123_3750.n5 8.90498
R22869 a_44123_3750.n5 a_44123_3750.t3 10.0462
R22870 a_44123_3750.n5 a_44123_3750.n0 1.09706
R22871 a_44123_3750.n0 a_44123_3750.n4 1.09706
R22872 a_44123_3750.n4 a_44123_3750.t7 8.90498
R22873 a_44123_3750.n4 a_44123_3750.t2 10.0462
R22874 a_44123_3750.n0 a_44123_3750.n1 18.263
R22875 a_44123_3750.n3 a_44123_3750.t5 17.0005
R22876 a_44123_3750.n1 a_44123_3750.n3 1.37206
R22877 a_44123_3750.n3 a_44123_3750.t1 18.9255
R22878 a_44123_3750.n2 a_44123_3750.t4 17.0005
R22879 a_44123_3750.n1 a_44123_3750.n2 1.37206
R22880 a_44123_3750.n2 a_44123_3750.t0 18.9255
R22881 a_44123_3750.n1 a_44123_3750.t6 17.6708
R22882 a_44123_3750.n0 a_44123_3750.t8 8.81561
R22883 a_37603_3750.t9 a_37603_3750.n5 8.90498
R22884 a_37603_3750.n5 a_37603_3750.t3 10.0462
R22885 a_37603_3750.n5 a_37603_3750.n0 1.09706
R22886 a_37603_3750.n0 a_37603_3750.n4 1.09706
R22887 a_37603_3750.n4 a_37603_3750.t7 8.90498
R22888 a_37603_3750.n4 a_37603_3750.t2 10.0462
R22889 a_37603_3750.n0 a_37603_3750.n1 18.263
R22890 a_37603_3750.n3 a_37603_3750.t4 17.0005
R22891 a_37603_3750.n1 a_37603_3750.n3 1.37206
R22892 a_37603_3750.n3 a_37603_3750.t1 18.9255
R22893 a_37603_3750.n2 a_37603_3750.t5 17.0005
R22894 a_37603_3750.n1 a_37603_3750.n2 1.37206
R22895 a_37603_3750.n2 a_37603_3750.t0 18.9255
R22896 a_37603_3750.n1 a_37603_3750.t6 17.6708
R22897 a_37603_3750.n0 a_37603_3750.t8 8.81561
R22898 a_31083_3750.t9 a_31083_3750.n5 8.90498
R22899 a_31083_3750.n5 a_31083_3750.t3 10.0462
R22900 a_31083_3750.n5 a_31083_3750.n0 1.09706
R22901 a_31083_3750.n0 a_31083_3750.n4 1.09706
R22902 a_31083_3750.n4 a_31083_3750.t7 8.90498
R22903 a_31083_3750.n4 a_31083_3750.t2 10.0462
R22904 a_31083_3750.n0 a_31083_3750.n1 18.263
R22905 a_31083_3750.n3 a_31083_3750.t5 17.0005
R22906 a_31083_3750.n1 a_31083_3750.n3 1.37206
R22907 a_31083_3750.n3 a_31083_3750.t1 18.9255
R22908 a_31083_3750.n2 a_31083_3750.t4 17.0005
R22909 a_31083_3750.n1 a_31083_3750.n2 1.37206
R22910 a_31083_3750.n2 a_31083_3750.t0 18.9255
R22911 a_31083_3750.n1 a_31083_3750.t6 17.6708
R22912 a_31083_3750.n0 a_31083_3750.t8 8.81561
R22913 a_24563_3750.t9 a_24563_3750.n5 8.90498
R22914 a_24563_3750.n5 a_24563_3750.t3 10.0462
R22915 a_24563_3750.n5 a_24563_3750.n0 1.09706
R22916 a_24563_3750.n0 a_24563_3750.n4 1.09706
R22917 a_24563_3750.n4 a_24563_3750.t7 8.90498
R22918 a_24563_3750.n4 a_24563_3750.t2 10.0462
R22919 a_24563_3750.n0 a_24563_3750.n1 18.263
R22920 a_24563_3750.n3 a_24563_3750.t5 17.0005
R22921 a_24563_3750.n1 a_24563_3750.n3 1.37206
R22922 a_24563_3750.n3 a_24563_3750.t1 18.9255
R22923 a_24563_3750.n2 a_24563_3750.t4 17.0005
R22924 a_24563_3750.n1 a_24563_3750.n2 1.37206
R22925 a_24563_3750.n2 a_24563_3750.t0 18.9255
R22926 a_24563_3750.n1 a_24563_3750.t6 17.6708
R22927 a_24563_3750.n0 a_24563_3750.t8 8.81561
R22928 a_18043_3750.t9 a_18043_3750.n5 8.90498
R22929 a_18043_3750.n5 a_18043_3750.t3 10.0462
R22930 a_18043_3750.n5 a_18043_3750.n0 1.09706
R22931 a_18043_3750.n0 a_18043_3750.n4 1.09706
R22932 a_18043_3750.n4 a_18043_3750.t7 8.90498
R22933 a_18043_3750.n4 a_18043_3750.t2 10.0462
R22934 a_18043_3750.n0 a_18043_3750.n1 18.263
R22935 a_18043_3750.n3 a_18043_3750.t5 17.0005
R22936 a_18043_3750.n1 a_18043_3750.n3 1.37206
R22937 a_18043_3750.n3 a_18043_3750.t1 18.9255
R22938 a_18043_3750.n2 a_18043_3750.t4 17.0005
R22939 a_18043_3750.n1 a_18043_3750.n2 1.37206
R22940 a_18043_3750.n2 a_18043_3750.t0 18.9255
R22941 a_18043_3750.n1 a_18043_3750.t6 17.6708
R22942 a_18043_3750.n0 a_18043_3750.t8 8.81561
R22943 a_11523_3750.t9 a_11523_3750.n5 8.90498
R22944 a_11523_3750.n5 a_11523_3750.t3 10.0462
R22945 a_11523_3750.n5 a_11523_3750.n0 1.09706
R22946 a_11523_3750.n0 a_11523_3750.n4 1.09706
R22947 a_11523_3750.n4 a_11523_3750.t7 8.90498
R22948 a_11523_3750.n4 a_11523_3750.t2 10.0462
R22949 a_11523_3750.n0 a_11523_3750.n1 18.263
R22950 a_11523_3750.n3 a_11523_3750.t5 17.0005
R22951 a_11523_3750.n1 a_11523_3750.n3 1.37206
R22952 a_11523_3750.n3 a_11523_3750.t1 18.9255
R22953 a_11523_3750.n2 a_11523_3750.t4 17.0005
R22954 a_11523_3750.n1 a_11523_3750.n2 1.37206
R22955 a_11523_3750.n2 a_11523_3750.t0 18.9255
R22956 a_11523_3750.n1 a_11523_3750.t6 17.6708
R22957 a_11523_3750.n0 a_11523_3750.t8 8.81561
R22958 a_5003_3750.t9 a_5003_3750.n5 8.90498
R22959 a_5003_3750.n5 a_5003_3750.t3 10.0462
R22960 a_5003_3750.n5 a_5003_3750.n0 1.09706
R22961 a_5003_3750.n0 a_5003_3750.n4 1.09706
R22962 a_5003_3750.n4 a_5003_3750.t7 8.90498
R22963 a_5003_3750.n4 a_5003_3750.t2 10.0462
R22964 a_5003_3750.n0 a_5003_3750.n1 18.263
R22965 a_5003_3750.n3 a_5003_3750.t5 17.0005
R22966 a_5003_3750.n1 a_5003_3750.n3 1.37206
R22967 a_5003_3750.n3 a_5003_3750.t1 18.9255
R22968 a_5003_3750.n2 a_5003_3750.t4 17.0005
R22969 a_5003_3750.n1 a_5003_3750.n2 1.37206
R22970 a_5003_3750.n2 a_5003_3750.t0 18.9255
R22971 a_5003_3750.n1 a_5003_3750.t6 17.6708
R22972 a_5003_3750.n0 a_5003_3750.t8 8.81561
R22973 a_49938_3714.t0 a_49938_3714.n0 8.53521
R22974 a_49938_3714.n0 a_49938_3714.t2 16.6582
R22975 a_49938_3714.n0 a_49938_3714.t1 6.13582
R22976 a_43418_3714.t0 a_43418_3714.n0 8.53521
R22977 a_43418_3714.n0 a_43418_3714.t2 16.6582
R22978 a_43418_3714.n0 a_43418_3714.t1 6.13582
R22979 a_49517_3694.t0 a_49517_3694.n0 8.53379
R22980 a_49517_3694.n0 a_49517_3694.t1 6.23476
R22981 a_49517_3694.n0 a_49517_3694.t2 35.9286
R22982 a_36898_3714.t0 a_36898_3714.n0 8.53521
R22983 a_36898_3714.n0 a_36898_3714.t2 16.6582
R22984 a_36898_3714.n0 a_36898_3714.t1 6.13582
R22985 a_42997_3694.t0 a_42997_3694.n0 8.53379
R22986 a_42997_3694.n0 a_42997_3694.t1 6.23476
R22987 a_42997_3694.n0 a_42997_3694.t2 35.9286
R22988 a_30378_3714.t0 a_30378_3714.n0 8.53521
R22989 a_30378_3714.n0 a_30378_3714.t2 16.6582
R22990 a_30378_3714.n0 a_30378_3714.t1 6.13582
R22991 a_36477_3694.t0 a_36477_3694.n0 8.53379
R22992 a_36477_3694.n0 a_36477_3694.t1 6.23476
R22993 a_36477_3694.n0 a_36477_3694.t2 35.9286
R22994 a_23858_3714.t0 a_23858_3714.n0 8.53521
R22995 a_23858_3714.n0 a_23858_3714.t2 16.6582
R22996 a_23858_3714.n0 a_23858_3714.t1 6.13582
R22997 a_29957_3694.t0 a_29957_3694.n0 8.53379
R22998 a_29957_3694.n0 a_29957_3694.t1 6.23476
R22999 a_29957_3694.n0 a_29957_3694.t2 35.9286
R23000 a_17338_3714.t0 a_17338_3714.n0 8.53521
R23001 a_17338_3714.n0 a_17338_3714.t2 16.6582
R23002 a_17338_3714.n0 a_17338_3714.t1 6.13582
R23003 a_23437_3694.t0 a_23437_3694.n0 8.53379
R23004 a_23437_3694.n0 a_23437_3694.t1 6.23476
R23005 a_23437_3694.n0 a_23437_3694.t2 35.9286
R23006 a_10818_3714.t0 a_10818_3714.n0 8.53521
R23007 a_10818_3714.n0 a_10818_3714.t2 16.6582
R23008 a_10818_3714.n0 a_10818_3714.t1 6.13582
R23009 a_16917_3694.t0 a_16917_3694.n0 8.53379
R23010 a_16917_3694.n0 a_16917_3694.t1 6.23476
R23011 a_16917_3694.n0 a_16917_3694.t2 35.9286
R23012 a_4298_3714.t0 a_4298_3714.n0 8.53521
R23013 a_4298_3714.n0 a_4298_3714.t2 16.6582
R23014 a_4298_3714.n0 a_4298_3714.t1 6.13582
R23015 a_10397_3694.t0 a_10397_3694.n0 8.53379
R23016 a_10397_3694.n0 a_10397_3694.t1 6.23476
R23017 a_10397_3694.n0 a_10397_3694.t2 35.9286
R23018 a_3877_3694.t0 a_3877_3694.n0 8.53379
R23019 a_3877_3694.n0 a_3877_3694.t1 6.23476
R23020 a_3877_3694.n0 a_3877_3694.t2 35.9286
R23021 a_n2342_4060.t1 a_n2342_4060.n0 17.5197
R23022 a_n2342_4060.n0 a_n2342_4060.t0 8.76789
R23023 a_n2342_4060.n0 a_n2342_4060.t2 15.4262
R23024 a_n2648_4040.t0 a_n2648_4040.n0 8.78861
R23025 a_n2648_4040.n0 a_n2648_4040.t1 6.03168
R23026 a_n2648_4040.n0 a_n2648_4040.t2 33.6055
R23027 a_n2946_4060.t0 a_n2946_4060.n0 17.5197
R23028 a_n2946_4060.n0 a_n2946_4060.t1 8.76789
R23029 a_n2946_4060.n0 a_n2946_4060.t2 15.4262
R23030 a_50809_6290.t3 a_50809_6290.n0 8.8328
R23031 a_50809_6290.n2 a_50809_6290.n3 1.14175
R23032 a_50809_6290.n1 a_50809_6290.n2 1.14175
R23033 a_50809_6290.n0 a_50809_6290.n1 1.14175
R23034 a_50809_6290.n3 a_50809_6290.t0 8.8328
R23035 a_50809_6290.n3 a_50809_6290.t4 8.8328
R23036 a_50809_6290.n2 a_50809_6290.t1 8.8328
R23037 a_50809_6290.n2 a_50809_6290.t5 8.8318
R23038 a_50809_6290.n1 a_50809_6290.t2 8.8328
R23039 a_50809_6290.n1 a_50809_6290.t7 8.8318
R23040 a_50809_6290.n0 a_50809_6290.t6 8.8318
R23041 a_48826_6293.t0 a_48826_6293.t1 35.1591
R23042 a_47950_6229.t0 a_47950_6229.t1 35.2643
R23043 a_49721_6494.t0 a_49721_6494.n0 8.76769
R23044 a_49721_6494.n0 a_49721_6494.t2 15.0661
R23045 a_49721_6494.n0 a_49721_6494.t1 5.94842
R23046 a_49148_6433.n0 a_49148_6433.t1 17.0005
R23047 a_49148_6433.t0 a_49148_6433.n0 18.2612
R23048 a_49148_6433.n0 a_49148_6433.t2 15.5529
R23049 a_48920_6293.t1 a_48920_6293.n0 17.5293
R23050 a_48920_6293.n0 a_48920_6293.t0 17.726
R23051 a_48920_6293.n0 a_48920_6293.t2 15.773
R23052 a_46818_6217.n0 a_46818_6217.t0 8.46601
R23053 a_46818_6217.t1 a_46818_6217.n0 9.03504
R23054 a_46818_6217.n0 a_46818_6217.t2 9.14806
R23055 a_48172_6560.t0 a_48172_6560.n1 17.3368
R23056 a_48172_6560.n0 a_48172_6560.t1 8.47322
R23057 a_48172_6560.n1 a_48172_6560.n0 0.103627
R23058 a_48172_6560.n0 a_48172_6560.t2 17.4516
R23059 a_48172_6560.n1 a_48172_6560.t3 15.0435
R23060 a_48070_6473.n0 a_48070_6473.t3 15.0005
R23061 a_48070_6473.t0 a_48070_6473.n0 17.9114
R23062 a_48070_6473.n1 a_48070_6473.t1 17.0005
R23063 a_48070_6473.n0 a_48070_6473.n1 0.655551
R23064 a_48070_6473.n1 a_48070_6473.t2 15.2176
R23065 a_47661_6534.t0 a_47661_6534.n2 17.1232
R23066 a_47661_6534.n2 a_47661_6534.n0 0.498937
R23067 a_47661_6534.n2 a_47661_6534.t1 18.4279
R23068 a_47661_6534.n0 a_47661_6534.n1 3.38952
R23069 a_47661_6534.n1 a_47661_6534.t2 18.3531
R23070 a_47661_6534.n1 a_47661_6534.t3 17.9378
R23071 a_47661_6534.n0 a_47661_6534.t4 15.4204
R23072 a_47375_6216.n0 a_47375_6216.t1 17.0005
R23073 a_47375_6216.t0 a_47375_6216.n0 18.3191
R23074 a_47375_6216.n1 a_47375_6216.t3 17.0005
R23075 a_47375_6216.n0 a_47375_6216.n1 3.28463
R23076 a_47375_6216.n1 a_47375_6216.t2 18.6222
R23077 a_47635_6439.t0 a_47635_6439.n1 17.2651
R23078 a_47635_6439.n1 a_47635_6439.t1 17.3352
R23079 a_47635_6439.n1 a_47635_6439.n0 0.948441
R23080 a_47635_6439.n0 a_47635_6439.t2 17.3305
R23081 a_47635_6439.n0 a_47635_6439.t3 15.4436
R23082 a_46919_6514.t1 a_46919_6514.n1 17.1443
R23083 a_46919_6514.n1 a_46919_6514.n0 0.743
R23084 a_46919_6514.n0 a_46919_6514.t2 8.65706
R23085 a_46919_6514.n0 a_46919_6514.t0 8.71106
R23086 a_46919_6514.n1 a_46919_6514.t3 15.731
R23087 a_46530_6198.t0 a_46530_6198.n0 8.81393
R23088 a_46530_6198.n0 a_46530_6198.t2 15.4488
R23089 a_46530_6198.n0 a_46530_6198.t1 6.09623
R23090 a_44289_6290.t3 a_44289_6290.n0 8.8328
R23091 a_44289_6290.n2 a_44289_6290.n3 1.14175
R23092 a_44289_6290.n1 a_44289_6290.n2 1.14175
R23093 a_44289_6290.n0 a_44289_6290.n1 1.14175
R23094 a_44289_6290.n3 a_44289_6290.t0 8.8328
R23095 a_44289_6290.n3 a_44289_6290.t4 8.8328
R23096 a_44289_6290.n2 a_44289_6290.t1 8.8328
R23097 a_44289_6290.n2 a_44289_6290.t5 8.8318
R23098 a_44289_6290.n1 a_44289_6290.t2 8.8328
R23099 a_44289_6290.n1 a_44289_6290.t7 8.8318
R23100 a_44289_6290.n0 a_44289_6290.t6 8.8318
R23101 a_42306_6293.t0 a_42306_6293.t1 35.1591
R23102 a_41430_6229.t0 a_41430_6229.t1 35.2643
R23103 a_46225_6594.t0 a_46225_6594.n0 17.1718
R23104 a_46225_6594.n0 a_46225_6594.t1 9.7433
R23105 a_46225_6594.n0 a_46225_6594.t2 15.4943
R23106 a_43201_6494.t0 a_43201_6494.n0 8.76769
R23107 a_43201_6494.n0 a_43201_6494.t2 15.0661
R23108 a_43201_6494.n0 a_43201_6494.t1 5.94842
R23109 a_42628_6433.n0 a_42628_6433.t1 17.0005
R23110 a_42628_6433.t0 a_42628_6433.n0 18.2612
R23111 a_42628_6433.n0 a_42628_6433.t2 15.5529
R23112 a_42400_6293.t1 a_42400_6293.n0 17.5293
R23113 a_42400_6293.n0 a_42400_6293.t0 17.726
R23114 a_42400_6293.n0 a_42400_6293.t2 15.773
R23115 a_40298_6217.n0 a_40298_6217.t0 8.46601
R23116 a_40298_6217.t1 a_40298_6217.n0 9.03504
R23117 a_40298_6217.n0 a_40298_6217.t2 9.14806
R23118 a_41652_6560.t0 a_41652_6560.n1 17.3368
R23119 a_41652_6560.n0 a_41652_6560.t1 8.47322
R23120 a_41652_6560.n1 a_41652_6560.n0 0.103627
R23121 a_41652_6560.n0 a_41652_6560.t2 17.4516
R23122 a_41652_6560.n1 a_41652_6560.t3 15.0435
R23123 a_41550_6473.n0 a_41550_6473.t3 15.0005
R23124 a_41550_6473.t0 a_41550_6473.n0 17.9114
R23125 a_41550_6473.n1 a_41550_6473.t1 17.0005
R23126 a_41550_6473.n0 a_41550_6473.n1 0.655551
R23127 a_41550_6473.n1 a_41550_6473.t2 15.2176
R23128 a_41141_6534.t0 a_41141_6534.n2 17.1232
R23129 a_41141_6534.n2 a_41141_6534.n0 0.498937
R23130 a_41141_6534.n2 a_41141_6534.t1 18.4279
R23131 a_41141_6534.n0 a_41141_6534.n1 3.38952
R23132 a_41141_6534.n1 a_41141_6534.t2 18.3531
R23133 a_41141_6534.n1 a_41141_6534.t3 17.9378
R23134 a_41141_6534.n0 a_41141_6534.t4 15.4204
R23135 a_40855_6216.n0 a_40855_6216.t1 17.0005
R23136 a_40855_6216.t0 a_40855_6216.n0 18.3191
R23137 a_40855_6216.n1 a_40855_6216.t3 17.0005
R23138 a_40855_6216.n0 a_40855_6216.n1 3.28463
R23139 a_40855_6216.n1 a_40855_6216.t2 18.6222
R23140 a_41115_6439.t0 a_41115_6439.n1 17.3352
R23141 a_41115_6439.n1 a_41115_6439.t1 17.2651
R23142 a_41115_6439.n1 a_41115_6439.n0 0.948441
R23143 a_41115_6439.n0 a_41115_6439.t2 17.3305
R23144 a_41115_6439.n0 a_41115_6439.t3 15.4436
R23145 a_40399_6514.t0 a_40399_6514.n1 17.1443
R23146 a_40399_6514.n1 a_40399_6514.n0 0.743
R23147 a_40399_6514.n0 a_40399_6514.t2 8.65706
R23148 a_40399_6514.n0 a_40399_6514.t1 8.71106
R23149 a_40399_6514.n1 a_40399_6514.t3 15.731
R23150 a_40010_6198.t0 a_40010_6198.n0 8.81393
R23151 a_40010_6198.n0 a_40010_6198.t2 15.4488
R23152 a_40010_6198.n0 a_40010_6198.t1 6.09623
R23153 a_37769_6290.t3 a_37769_6290.n0 8.8328
R23154 a_37769_6290.n2 a_37769_6290.n3 1.14175
R23155 a_37769_6290.n1 a_37769_6290.n2 1.14175
R23156 a_37769_6290.n0 a_37769_6290.n1 1.14175
R23157 a_37769_6290.n3 a_37769_6290.t0 8.8328
R23158 a_37769_6290.n3 a_37769_6290.t4 8.8328
R23159 a_37769_6290.n2 a_37769_6290.t1 8.8328
R23160 a_37769_6290.n2 a_37769_6290.t5 8.8318
R23161 a_37769_6290.n1 a_37769_6290.t2 8.8328
R23162 a_37769_6290.n1 a_37769_6290.t7 8.8318
R23163 a_37769_6290.n0 a_37769_6290.t6 8.8318
R23164 a_35786_6293.t0 a_35786_6293.t1 35.1591
R23165 a_34910_6229.t0 a_34910_6229.t1 35.2643
R23166 a_39705_6594.t0 a_39705_6594.n0 17.1718
R23167 a_39705_6594.n0 a_39705_6594.t1 9.7433
R23168 a_39705_6594.n0 a_39705_6594.t2 15.4943
R23169 a_36681_6494.t0 a_36681_6494.n0 8.76769
R23170 a_36681_6494.n0 a_36681_6494.t2 15.0661
R23171 a_36681_6494.n0 a_36681_6494.t1 5.94842
R23172 a_36108_6433.n0 a_36108_6433.t1 17.0005
R23173 a_36108_6433.t0 a_36108_6433.n0 18.2612
R23174 a_36108_6433.n0 a_36108_6433.t2 15.5529
R23175 a_35880_6293.t1 a_35880_6293.n0 17.5293
R23176 a_35880_6293.n0 a_35880_6293.t0 17.726
R23177 a_35880_6293.n0 a_35880_6293.t2 15.773
R23178 a_33778_6217.n0 a_33778_6217.t0 8.46601
R23179 a_33778_6217.t1 a_33778_6217.n0 9.03504
R23180 a_33778_6217.n0 a_33778_6217.t2 9.14806
R23181 a_35132_6560.t0 a_35132_6560.n1 17.3368
R23182 a_35132_6560.n0 a_35132_6560.t1 8.47322
R23183 a_35132_6560.n1 a_35132_6560.n0 0.103627
R23184 a_35132_6560.n0 a_35132_6560.t2 17.4516
R23185 a_35132_6560.n1 a_35132_6560.t3 15.0435
R23186 a_35030_6473.n0 a_35030_6473.t3 15.0005
R23187 a_35030_6473.t0 a_35030_6473.n0 17.9114
R23188 a_35030_6473.n1 a_35030_6473.t1 17.0005
R23189 a_35030_6473.n0 a_35030_6473.n1 0.655551
R23190 a_35030_6473.n1 a_35030_6473.t2 15.2176
R23191 a_34621_6534.t0 a_34621_6534.n2 17.1232
R23192 a_34621_6534.n2 a_34621_6534.n0 0.498937
R23193 a_34621_6534.n2 a_34621_6534.t1 18.4279
R23194 a_34621_6534.n0 a_34621_6534.n1 3.38952
R23195 a_34621_6534.n1 a_34621_6534.t2 18.3531
R23196 a_34621_6534.n1 a_34621_6534.t3 17.9378
R23197 a_34621_6534.n0 a_34621_6534.t4 15.4204
R23198 a_34335_6216.n0 a_34335_6216.t1 17.0005
R23199 a_34335_6216.t0 a_34335_6216.n0 18.3191
R23200 a_34335_6216.n1 a_34335_6216.t3 17.0005
R23201 a_34335_6216.n0 a_34335_6216.n1 3.28463
R23202 a_34335_6216.n1 a_34335_6216.t2 18.6222
R23203 a_34595_6439.t0 a_34595_6439.n1 17.2651
R23204 a_34595_6439.n1 a_34595_6439.t1 17.3352
R23205 a_34595_6439.n1 a_34595_6439.n0 0.948441
R23206 a_34595_6439.n0 a_34595_6439.t2 17.3305
R23207 a_34595_6439.n0 a_34595_6439.t3 15.4436
R23208 a_33879_6514.t0 a_33879_6514.n1 17.1443
R23209 a_33879_6514.n1 a_33879_6514.n0 0.743
R23210 a_33879_6514.n0 a_33879_6514.t2 8.65706
R23211 a_33879_6514.n0 a_33879_6514.t1 8.71106
R23212 a_33879_6514.n1 a_33879_6514.t3 15.731
R23213 a_33490_6198.t0 a_33490_6198.n0 8.81393
R23214 a_33490_6198.n0 a_33490_6198.t2 15.4488
R23215 a_33490_6198.n0 a_33490_6198.t1 6.09623
R23216 a_31249_6290.t3 a_31249_6290.n0 8.8328
R23217 a_31249_6290.n2 a_31249_6290.n3 1.14175
R23218 a_31249_6290.n1 a_31249_6290.n2 1.14175
R23219 a_31249_6290.n0 a_31249_6290.n1 1.14175
R23220 a_31249_6290.n3 a_31249_6290.t0 8.8328
R23221 a_31249_6290.n3 a_31249_6290.t4 8.8328
R23222 a_31249_6290.n2 a_31249_6290.t1 8.8328
R23223 a_31249_6290.n2 a_31249_6290.t5 8.8318
R23224 a_31249_6290.n1 a_31249_6290.t2 8.8328
R23225 a_31249_6290.n1 a_31249_6290.t7 8.8318
R23226 a_31249_6290.n0 a_31249_6290.t6 8.8318
R23227 a_29266_6293.t0 a_29266_6293.t1 35.1591
R23228 a_28390_6229.t0 a_28390_6229.t1 35.2643
R23229 a_33185_6594.t0 a_33185_6594.n0 17.1718
R23230 a_33185_6594.n0 a_33185_6594.t1 9.7433
R23231 a_33185_6594.n0 a_33185_6594.t2 15.4943
R23232 a_30161_6494.t0 a_30161_6494.n0 8.76769
R23233 a_30161_6494.n0 a_30161_6494.t2 15.0661
R23234 a_30161_6494.n0 a_30161_6494.t1 5.94842
R23235 a_29588_6433.t0 a_29588_6433.n0 17.0005
R23236 a_29588_6433.n0 a_29588_6433.t1 18.2612
R23237 a_29588_6433.n0 a_29588_6433.t2 15.5529
R23238 a_29360_6293.t1 a_29360_6293.n0 17.5293
R23239 a_29360_6293.n0 a_29360_6293.t0 17.726
R23240 a_29360_6293.n0 a_29360_6293.t2 15.773
R23241 a_27258_6217.n0 a_27258_6217.t0 8.46601
R23242 a_27258_6217.t1 a_27258_6217.n0 9.03504
R23243 a_27258_6217.n0 a_27258_6217.t2 9.14806
R23244 a_28612_6560.t0 a_28612_6560.n1 17.3368
R23245 a_28612_6560.n0 a_28612_6560.t1 8.47322
R23246 a_28612_6560.n1 a_28612_6560.n0 0.103627
R23247 a_28612_6560.n0 a_28612_6560.t2 17.4516
R23248 a_28612_6560.n1 a_28612_6560.t3 15.0435
R23249 a_28510_6473.n0 a_28510_6473.t3 15.0005
R23250 a_28510_6473.t0 a_28510_6473.n0 17.9114
R23251 a_28510_6473.n1 a_28510_6473.t1 17.0005
R23252 a_28510_6473.n0 a_28510_6473.n1 0.655551
R23253 a_28510_6473.n1 a_28510_6473.t2 15.2176
R23254 a_28101_6534.t0 a_28101_6534.n2 17.1232
R23255 a_28101_6534.n2 a_28101_6534.n0 0.498937
R23256 a_28101_6534.n2 a_28101_6534.t1 18.4279
R23257 a_28101_6534.n0 a_28101_6534.n1 3.38952
R23258 a_28101_6534.n1 a_28101_6534.t2 18.3531
R23259 a_28101_6534.n1 a_28101_6534.t3 17.9378
R23260 a_28101_6534.n0 a_28101_6534.t4 15.4204
R23261 a_27815_6216.n0 a_27815_6216.t1 17.0005
R23262 a_27815_6216.t0 a_27815_6216.n0 18.3191
R23263 a_27815_6216.n1 a_27815_6216.t3 17.0005
R23264 a_27815_6216.n0 a_27815_6216.n1 3.28463
R23265 a_27815_6216.n1 a_27815_6216.t2 18.6222
R23266 a_28075_6439.t0 a_28075_6439.n1 17.3352
R23267 a_28075_6439.n1 a_28075_6439.t1 17.2651
R23268 a_28075_6439.n1 a_28075_6439.n0 0.948441
R23269 a_28075_6439.n0 a_28075_6439.t2 17.3305
R23270 a_28075_6439.n0 a_28075_6439.t3 15.4436
R23271 a_27359_6514.t1 a_27359_6514.n1 17.1443
R23272 a_27359_6514.n1 a_27359_6514.n0 0.743
R23273 a_27359_6514.n0 a_27359_6514.t2 8.65706
R23274 a_27359_6514.n0 a_27359_6514.t0 8.71106
R23275 a_27359_6514.n1 a_27359_6514.t3 15.731
R23276 a_26970_6198.t0 a_26970_6198.n0 8.81393
R23277 a_26970_6198.n0 a_26970_6198.t2 15.4488
R23278 a_26970_6198.n0 a_26970_6198.t1 6.09623
R23279 a_24729_6290.t3 a_24729_6290.n0 8.8328
R23280 a_24729_6290.n2 a_24729_6290.n3 1.14175
R23281 a_24729_6290.n1 a_24729_6290.n2 1.14175
R23282 a_24729_6290.n0 a_24729_6290.n1 1.14175
R23283 a_24729_6290.n3 a_24729_6290.t0 8.8328
R23284 a_24729_6290.n3 a_24729_6290.t4 8.8328
R23285 a_24729_6290.n2 a_24729_6290.t1 8.8328
R23286 a_24729_6290.n2 a_24729_6290.t5 8.8318
R23287 a_24729_6290.n1 a_24729_6290.t2 8.8328
R23288 a_24729_6290.n1 a_24729_6290.t7 8.8318
R23289 a_24729_6290.n0 a_24729_6290.t6 8.8318
R23290 a_22746_6293.t0 a_22746_6293.t1 35.1591
R23291 a_21870_6229.t0 a_21870_6229.t1 35.2643
R23292 a_26665_6594.t0 a_26665_6594.n0 17.1718
R23293 a_26665_6594.n0 a_26665_6594.t1 9.7433
R23294 a_26665_6594.n0 a_26665_6594.t2 15.4943
R23295 a_23641_6494.t0 a_23641_6494.n0 8.76769
R23296 a_23641_6494.n0 a_23641_6494.t2 15.0661
R23297 a_23641_6494.n0 a_23641_6494.t1 5.94842
R23298 a_23068_6433.n0 a_23068_6433.t1 17.0005
R23299 a_23068_6433.t0 a_23068_6433.n0 18.2612
R23300 a_23068_6433.n0 a_23068_6433.t2 15.5529
R23301 a_22840_6293.t1 a_22840_6293.n0 17.5293
R23302 a_22840_6293.n0 a_22840_6293.t0 17.726
R23303 a_22840_6293.n0 a_22840_6293.t2 15.773
R23304 a_20738_6217.n0 a_20738_6217.t0 8.46601
R23305 a_20738_6217.t1 a_20738_6217.n0 9.03504
R23306 a_20738_6217.n0 a_20738_6217.t2 9.14806
R23307 a_22092_6560.t0 a_22092_6560.n1 17.3368
R23308 a_22092_6560.n0 a_22092_6560.t1 8.47322
R23309 a_22092_6560.n1 a_22092_6560.n0 0.103627
R23310 a_22092_6560.n0 a_22092_6560.t2 17.4516
R23311 a_22092_6560.n1 a_22092_6560.t3 15.0435
R23312 a_21990_6473.n0 a_21990_6473.t3 15.0005
R23313 a_21990_6473.t0 a_21990_6473.n0 17.9114
R23314 a_21990_6473.n1 a_21990_6473.t1 17.0005
R23315 a_21990_6473.n0 a_21990_6473.n1 0.655551
R23316 a_21990_6473.n1 a_21990_6473.t2 15.2176
R23317 a_21581_6534.t0 a_21581_6534.n2 17.1232
R23318 a_21581_6534.n2 a_21581_6534.n0 0.498937
R23319 a_21581_6534.n2 a_21581_6534.t1 18.4279
R23320 a_21581_6534.n0 a_21581_6534.n1 3.38952
R23321 a_21581_6534.n1 a_21581_6534.t3 18.3531
R23322 a_21581_6534.n1 a_21581_6534.t2 17.9378
R23323 a_21581_6534.n0 a_21581_6534.t4 15.4204
R23324 a_21295_6216.n0 a_21295_6216.t1 17.0005
R23325 a_21295_6216.t0 a_21295_6216.n0 18.3191
R23326 a_21295_6216.n1 a_21295_6216.t2 17.0005
R23327 a_21295_6216.n0 a_21295_6216.n1 3.28463
R23328 a_21295_6216.n1 a_21295_6216.t3 18.6222
R23329 a_21555_6439.t0 a_21555_6439.n1 17.2651
R23330 a_21555_6439.n1 a_21555_6439.t1 17.3352
R23331 a_21555_6439.n1 a_21555_6439.n0 0.948441
R23332 a_21555_6439.n0 a_21555_6439.t2 17.3305
R23333 a_21555_6439.n0 a_21555_6439.t3 15.4436
R23334 a_20839_6514.t0 a_20839_6514.n1 17.1443
R23335 a_20839_6514.n1 a_20839_6514.n0 0.743
R23336 a_20839_6514.n0 a_20839_6514.t2 8.65706
R23337 a_20839_6514.n0 a_20839_6514.t1 8.71106
R23338 a_20839_6514.n1 a_20839_6514.t3 15.731
R23339 a_20450_6198.t0 a_20450_6198.n0 8.81393
R23340 a_20450_6198.n0 a_20450_6198.t2 15.4488
R23341 a_20450_6198.n0 a_20450_6198.t1 6.09623
R23342 a_18209_6290.t3 a_18209_6290.n0 8.8328
R23343 a_18209_6290.n2 a_18209_6290.n3 1.14175
R23344 a_18209_6290.n1 a_18209_6290.n2 1.14175
R23345 a_18209_6290.n0 a_18209_6290.n1 1.14175
R23346 a_18209_6290.n3 a_18209_6290.t0 8.8328
R23347 a_18209_6290.n3 a_18209_6290.t4 8.8328
R23348 a_18209_6290.n2 a_18209_6290.t1 8.8328
R23349 a_18209_6290.n2 a_18209_6290.t5 8.8318
R23350 a_18209_6290.n1 a_18209_6290.t2 8.8328
R23351 a_18209_6290.n1 a_18209_6290.t7 8.8318
R23352 a_18209_6290.n0 a_18209_6290.t6 8.8318
R23353 a_16226_6293.t0 a_16226_6293.t1 35.1591
R23354 a_15350_6229.t0 a_15350_6229.t1 35.2643
R23355 a_20145_6594.t0 a_20145_6594.n0 17.1718
R23356 a_20145_6594.n0 a_20145_6594.t1 9.7433
R23357 a_20145_6594.n0 a_20145_6594.t2 15.4943
R23358 a_17121_6494.t0 a_17121_6494.n0 8.76769
R23359 a_17121_6494.n0 a_17121_6494.t2 15.0661
R23360 a_17121_6494.n0 a_17121_6494.t1 5.94842
R23361 a_16548_6433.n0 a_16548_6433.t1 17.0005
R23362 a_16548_6433.t0 a_16548_6433.n0 18.2612
R23363 a_16548_6433.n0 a_16548_6433.t2 15.5529
R23364 a_16320_6293.t1 a_16320_6293.n0 17.5293
R23365 a_16320_6293.n0 a_16320_6293.t0 17.726
R23366 a_16320_6293.n0 a_16320_6293.t2 15.773
R23367 a_14218_6217.n0 a_14218_6217.t0 8.46601
R23368 a_14218_6217.t1 a_14218_6217.n0 9.03504
R23369 a_14218_6217.n0 a_14218_6217.t2 9.14806
R23370 a_15572_6560.t0 a_15572_6560.n1 17.3368
R23371 a_15572_6560.n0 a_15572_6560.t1 8.47322
R23372 a_15572_6560.n1 a_15572_6560.n0 0.103627
R23373 a_15572_6560.n0 a_15572_6560.t2 17.4516
R23374 a_15572_6560.n1 a_15572_6560.t3 15.0435
R23375 a_15470_6473.n0 a_15470_6473.t3 15.0005
R23376 a_15470_6473.t0 a_15470_6473.n0 17.9114
R23377 a_15470_6473.n1 a_15470_6473.t1 17.0005
R23378 a_15470_6473.n0 a_15470_6473.n1 0.655551
R23379 a_15470_6473.n1 a_15470_6473.t2 15.2176
R23380 a_15061_6534.t0 a_15061_6534.n2 17.1232
R23381 a_15061_6534.n2 a_15061_6534.n0 0.498937
R23382 a_15061_6534.n2 a_15061_6534.t1 18.4279
R23383 a_15061_6534.n0 a_15061_6534.n1 3.38952
R23384 a_15061_6534.n1 a_15061_6534.t3 18.3531
R23385 a_15061_6534.n1 a_15061_6534.t2 17.9378
R23386 a_15061_6534.n0 a_15061_6534.t4 15.4204
R23387 a_14775_6216.n0 a_14775_6216.t1 17.0005
R23388 a_14775_6216.t0 a_14775_6216.n0 18.3191
R23389 a_14775_6216.n1 a_14775_6216.t2 17.0005
R23390 a_14775_6216.n0 a_14775_6216.n1 3.28463
R23391 a_14775_6216.n1 a_14775_6216.t3 18.6222
R23392 a_15035_6439.t0 a_15035_6439.n1 17.2651
R23393 a_15035_6439.n1 a_15035_6439.t1 17.3352
R23394 a_15035_6439.n1 a_15035_6439.n0 0.948441
R23395 a_15035_6439.n0 a_15035_6439.t2 17.3305
R23396 a_15035_6439.n0 a_15035_6439.t3 15.4436
R23397 a_14319_6514.t1 a_14319_6514.n1 17.1443
R23398 a_14319_6514.n1 a_14319_6514.n0 0.743
R23399 a_14319_6514.n0 a_14319_6514.t2 8.65706
R23400 a_14319_6514.n0 a_14319_6514.t0 8.71106
R23401 a_14319_6514.n1 a_14319_6514.t3 15.731
R23402 a_13930_6198.t0 a_13930_6198.n0 8.81393
R23403 a_13930_6198.n0 a_13930_6198.t2 15.4488
R23404 a_13930_6198.n0 a_13930_6198.t1 6.09623
R23405 a_11689_6290.t3 a_11689_6290.n0 8.8328
R23406 a_11689_6290.n2 a_11689_6290.n3 1.14175
R23407 a_11689_6290.n1 a_11689_6290.n2 1.14175
R23408 a_11689_6290.n0 a_11689_6290.n1 1.14175
R23409 a_11689_6290.n3 a_11689_6290.t0 8.8328
R23410 a_11689_6290.n3 a_11689_6290.t4 8.8328
R23411 a_11689_6290.n2 a_11689_6290.t1 8.8328
R23412 a_11689_6290.n2 a_11689_6290.t5 8.8318
R23413 a_11689_6290.n1 a_11689_6290.t2 8.8328
R23414 a_11689_6290.n1 a_11689_6290.t7 8.8318
R23415 a_11689_6290.n0 a_11689_6290.t6 8.8318
R23416 a_9706_6293.t0 a_9706_6293.t1 35.1591
R23417 a_8830_6229.t0 a_8830_6229.t1 35.2643
R23418 a_13625_6594.t0 a_13625_6594.n0 17.1718
R23419 a_13625_6594.n0 a_13625_6594.t1 9.7433
R23420 a_13625_6594.n0 a_13625_6594.t2 15.4943
R23421 a_10601_6494.t0 a_10601_6494.n0 8.76769
R23422 a_10601_6494.n0 a_10601_6494.t2 15.0661
R23423 a_10601_6494.n0 a_10601_6494.t1 5.94842
R23424 a_10028_6433.t0 a_10028_6433.n0 17.0005
R23425 a_10028_6433.n0 a_10028_6433.t1 18.2612
R23426 a_10028_6433.n0 a_10028_6433.t2 15.5529
R23427 a_9800_6293.t1 a_9800_6293.n0 17.5293
R23428 a_9800_6293.n0 a_9800_6293.t0 17.726
R23429 a_9800_6293.n0 a_9800_6293.t2 15.773
R23430 a_7698_6217.n0 a_7698_6217.t0 8.46601
R23431 a_7698_6217.t1 a_7698_6217.n0 9.03504
R23432 a_7698_6217.n0 a_7698_6217.t2 9.14806
R23433 a_9052_6560.t0 a_9052_6560.n1 17.3368
R23434 a_9052_6560.n0 a_9052_6560.t1 8.47322
R23435 a_9052_6560.n1 a_9052_6560.n0 0.103627
R23436 a_9052_6560.n0 a_9052_6560.t2 17.4516
R23437 a_9052_6560.n1 a_9052_6560.t3 15.0435
R23438 a_8950_6473.n0 a_8950_6473.t3 15.0005
R23439 a_8950_6473.t0 a_8950_6473.n0 17.9114
R23440 a_8950_6473.n1 a_8950_6473.t1 17.0005
R23441 a_8950_6473.n0 a_8950_6473.n1 0.655551
R23442 a_8950_6473.n1 a_8950_6473.t2 15.2176
R23443 a_8541_6534.t0 a_8541_6534.n2 17.1232
R23444 a_8541_6534.n2 a_8541_6534.n0 0.498937
R23445 a_8541_6534.n2 a_8541_6534.t1 18.4279
R23446 a_8541_6534.n0 a_8541_6534.n1 3.38952
R23447 a_8541_6534.n1 a_8541_6534.t2 18.3531
R23448 a_8541_6534.n1 a_8541_6534.t3 17.9378
R23449 a_8541_6534.n0 a_8541_6534.t4 15.4204
R23450 a_8255_6216.n0 a_8255_6216.t1 17.0005
R23451 a_8255_6216.t0 a_8255_6216.n0 18.3191
R23452 a_8255_6216.n1 a_8255_6216.t3 17.0005
R23453 a_8255_6216.n0 a_8255_6216.n1 3.28463
R23454 a_8255_6216.n1 a_8255_6216.t2 18.6222
R23455 a_8515_6439.t0 a_8515_6439.n1 17.2651
R23456 a_8515_6439.n1 a_8515_6439.t1 17.3352
R23457 a_8515_6439.n1 a_8515_6439.n0 0.948441
R23458 a_8515_6439.n0 a_8515_6439.t2 17.3305
R23459 a_8515_6439.n0 a_8515_6439.t3 15.4436
R23460 a_7799_6514.t0 a_7799_6514.n1 17.1443
R23461 a_7799_6514.n1 a_7799_6514.n0 0.743
R23462 a_7799_6514.n0 a_7799_6514.t2 8.65706
R23463 a_7799_6514.n0 a_7799_6514.t1 8.71106
R23464 a_7799_6514.n1 a_7799_6514.t3 15.731
R23465 a_7410_6198.t0 a_7410_6198.n0 8.81393
R23466 a_7410_6198.n0 a_7410_6198.t2 15.4488
R23467 a_7410_6198.n0 a_7410_6198.t1 6.09623
R23468 a_5169_6290.t3 a_5169_6290.n0 8.8328
R23469 a_5169_6290.n2 a_5169_6290.n3 1.14175
R23470 a_5169_6290.n1 a_5169_6290.n2 1.14175
R23471 a_5169_6290.n0 a_5169_6290.n1 1.14175
R23472 a_5169_6290.n3 a_5169_6290.t0 8.8328
R23473 a_5169_6290.n3 a_5169_6290.t4 8.8328
R23474 a_5169_6290.n2 a_5169_6290.t1 8.8328
R23475 a_5169_6290.n2 a_5169_6290.t5 8.8318
R23476 a_5169_6290.n1 a_5169_6290.t2 8.8328
R23477 a_5169_6290.n1 a_5169_6290.t7 8.8318
R23478 a_5169_6290.n0 a_5169_6290.t6 8.8318
R23479 a_3186_6293.t0 a_3186_6293.t1 35.1591
R23480 a_2310_6229.t0 a_2310_6229.t1 35.2643
R23481 a_7105_6594.t0 a_7105_6594.n0 17.1718
R23482 a_7105_6594.n0 a_7105_6594.t1 9.7433
R23483 a_7105_6594.n0 a_7105_6594.t2 15.4943
R23484 a_4081_6494.t0 a_4081_6494.n0 8.76769
R23485 a_4081_6494.n0 a_4081_6494.t2 15.0661
R23486 a_4081_6494.n0 a_4081_6494.t1 5.94842
R23487 a_3508_6433.n0 a_3508_6433.t1 17.0005
R23488 a_3508_6433.t0 a_3508_6433.n0 18.2612
R23489 a_3508_6433.n0 a_3508_6433.t2 15.5529
R23490 a_3280_6293.t1 a_3280_6293.n0 17.5293
R23491 a_3280_6293.n0 a_3280_6293.t0 17.726
R23492 a_3280_6293.n0 a_3280_6293.t2 15.773
R23493 a_1178_6217.t1 a_1178_6217.n0 8.46601
R23494 a_1178_6217.n0 a_1178_6217.t2 9.03504
R23495 a_1178_6217.n0 a_1178_6217.t0 9.14806
R23496 a_2532_6560.t0 a_2532_6560.n1 17.3368
R23497 a_2532_6560.n0 a_2532_6560.t1 8.47322
R23498 a_2532_6560.n1 a_2532_6560.n0 0.103627
R23499 a_2532_6560.n0 a_2532_6560.t2 17.4516
R23500 a_2532_6560.n1 a_2532_6560.t3 15.0435
R23501 a_2430_6473.n0 a_2430_6473.t3 15.0005
R23502 a_2430_6473.t0 a_2430_6473.n0 17.9114
R23503 a_2430_6473.n1 a_2430_6473.t1 17.0005
R23504 a_2430_6473.n0 a_2430_6473.n1 0.655551
R23505 a_2430_6473.n1 a_2430_6473.t2 15.2176
R23506 a_2021_6534.t0 a_2021_6534.n2 17.1232
R23507 a_2021_6534.n2 a_2021_6534.n0 0.498937
R23508 a_2021_6534.n2 a_2021_6534.t1 18.4279
R23509 a_2021_6534.n0 a_2021_6534.n1 3.38952
R23510 a_2021_6534.n1 a_2021_6534.t3 18.3531
R23511 a_2021_6534.n1 a_2021_6534.t2 17.9378
R23512 a_2021_6534.n0 a_2021_6534.t4 15.4204
R23513 a_1735_6216.n0 a_1735_6216.t1 17.0005
R23514 a_1735_6216.t0 a_1735_6216.n0 18.3191
R23515 a_1735_6216.n1 a_1735_6216.t2 17.0005
R23516 a_1735_6216.n0 a_1735_6216.n1 3.28463
R23517 a_1735_6216.n1 a_1735_6216.t3 18.6222
R23518 a_1995_6439.t0 a_1995_6439.n1 17.3352
R23519 a_1995_6439.n1 a_1995_6439.t1 17.2651
R23520 a_1995_6439.n1 a_1995_6439.n0 0.948441
R23521 a_1995_6439.n0 a_1995_6439.t2 17.3305
R23522 a_1995_6439.n0 a_1995_6439.t3 15.4436
R23523 a_1279_6514.t2 a_1279_6514.n1 17.1443
R23524 a_1279_6514.n1 a_1279_6514.n0 0.743
R23525 a_1279_6514.n0 a_1279_6514.t0 8.65706
R23526 a_1279_6514.n0 a_1279_6514.t1 8.71106
R23527 a_1279_6514.n1 a_1279_6514.t3 15.731
R23528 a_n2646_2484.t0 a_n2646_2484.n0 8.98227
R23529 a_n2646_2484.n0 a_n2646_2484.t1 6.15412
R23530 a_n2646_2484.n0 a_n2646_2484.n1 9.2205
R23531 a_n2646_2484.n1 a_n2646_2484.n16 11.0846
R23532 a_n2646_2484.n16 a_n2646_2484.n15 0.557571
R23533 a_n2646_2484.n15 a_n2646_2484.n14 4.56629
R23534 a_n2646_2484.n14 a_n2646_2484.n13 0.557571
R23535 a_n2646_2484.n13 a_n2646_2484.n12 4.56629
R23536 a_n2646_2484.n12 a_n2646_2484.n11 0.557571
R23537 a_n2646_2484.n11 a_n2646_2484.n10 4.56629
R23538 a_n2646_2484.n10 a_n2646_2484.n9 0.557571
R23539 a_n2646_2484.n9 a_n2646_2484.n8 4.56629
R23540 a_n2646_2484.n8 a_n2646_2484.n7 0.557571
R23541 a_n2646_2484.n7 a_n2646_2484.n6 4.56629
R23542 a_n2646_2484.n6 a_n2646_2484.n5 0.557571
R23543 a_n2646_2484.n5 a_n2646_2484.n4 4.56629
R23544 a_n2646_2484.n4 a_n2646_2484.n3 0.557571
R23545 a_n2646_2484.n3 a_n2646_2484.n2 4.56629
R23546 a_n2646_2484.n2 a_n2646_2484.t11 30.2193
R23547 a_n2646_2484.n16 a_n2646_2484.t10 31.6835
R23548 a_n2646_2484.n15 a_n2646_2484.t18 29.6622
R23549 a_n2646_2484.n14 a_n2646_2484.t9 31.6835
R23550 a_n2646_2484.n13 a_n2646_2484.t17 29.6622
R23551 a_n2646_2484.n12 a_n2646_2484.t8 31.6835
R23552 a_n2646_2484.n11 a_n2646_2484.t16 29.6622
R23553 a_n2646_2484.n10 a_n2646_2484.t7 31.6835
R23554 a_n2646_2484.n9 a_n2646_2484.t15 29.6622
R23555 a_n2646_2484.n8 a_n2646_2484.t6 31.6835
R23556 a_n2646_2484.n7 a_n2646_2484.t14 29.6622
R23557 a_n2646_2484.n6 a_n2646_2484.t5 31.6835
R23558 a_n2646_2484.n5 a_n2646_2484.t13 29.6622
R23559 a_n2646_2484.n4 a_n2646_2484.t4 31.6835
R23560 a_n2646_2484.n3 a_n2646_2484.t12 29.6622
R23561 a_n2646_2484.n2 a_n2646_2484.t3 31.6835
R23562 a_n2646_2484.n1 a_n2646_2484.t2 24.281
R23563 a_890_6198.t0 a_890_6198.n0 8.81393
R23564 a_890_6198.n0 a_890_6198.t2 15.4488
R23565 a_890_6198.n0 a_890_6198.t1 6.09623
R23566 a_585_6594.t0 a_585_6594.n0 17.1718
R23567 a_585_6594.n0 a_585_6594.t1 9.7433
R23568 a_585_6594.n0 a_585_6594.t2 15.4943
R23569 a_50643_6550.t9 a_50643_6550.n5 8.90498
R23570 a_50643_6550.n5 a_50643_6550.t3 10.0462
R23571 a_50643_6550.n5 a_50643_6550.n0 1.09706
R23572 a_50643_6550.n0 a_50643_6550.n4 1.09706
R23573 a_50643_6550.n4 a_50643_6550.t7 8.90498
R23574 a_50643_6550.n4 a_50643_6550.t2 10.0462
R23575 a_50643_6550.n0 a_50643_6550.n1 18.263
R23576 a_50643_6550.n3 a_50643_6550.t4 17.0005
R23577 a_50643_6550.n1 a_50643_6550.n3 1.37206
R23578 a_50643_6550.n3 a_50643_6550.t1 18.9255
R23579 a_50643_6550.n2 a_50643_6550.t5 17.0005
R23580 a_50643_6550.n1 a_50643_6550.n2 1.37206
R23581 a_50643_6550.n2 a_50643_6550.t0 18.9255
R23582 a_50643_6550.n1 a_50643_6550.t6 17.6708
R23583 a_50643_6550.n0 a_50643_6550.t8 8.81561
R23584 a_44123_6550.t9 a_44123_6550.n5 8.90498
R23585 a_44123_6550.n5 a_44123_6550.t3 10.0462
R23586 a_44123_6550.n5 a_44123_6550.n0 1.09706
R23587 a_44123_6550.n0 a_44123_6550.n4 1.09706
R23588 a_44123_6550.n4 a_44123_6550.t7 8.90498
R23589 a_44123_6550.n4 a_44123_6550.t2 10.0462
R23590 a_44123_6550.n0 a_44123_6550.n1 18.263
R23591 a_44123_6550.n3 a_44123_6550.t5 17.0005
R23592 a_44123_6550.n1 a_44123_6550.n3 1.37206
R23593 a_44123_6550.n3 a_44123_6550.t1 18.9255
R23594 a_44123_6550.n2 a_44123_6550.t4 17.0005
R23595 a_44123_6550.n1 a_44123_6550.n2 1.37206
R23596 a_44123_6550.n2 a_44123_6550.t0 18.9255
R23597 a_44123_6550.n1 a_44123_6550.t6 17.6708
R23598 a_44123_6550.n0 a_44123_6550.t8 8.81561
R23599 a_37603_6550.t9 a_37603_6550.n5 8.90498
R23600 a_37603_6550.n5 a_37603_6550.t3 10.0462
R23601 a_37603_6550.n5 a_37603_6550.n0 1.09706
R23602 a_37603_6550.n0 a_37603_6550.n4 1.09706
R23603 a_37603_6550.n4 a_37603_6550.t7 8.90498
R23604 a_37603_6550.n4 a_37603_6550.t2 10.0462
R23605 a_37603_6550.n0 a_37603_6550.n1 18.263
R23606 a_37603_6550.n3 a_37603_6550.t4 17.0005
R23607 a_37603_6550.n1 a_37603_6550.n3 1.37206
R23608 a_37603_6550.n3 a_37603_6550.t1 18.9255
R23609 a_37603_6550.n2 a_37603_6550.t5 17.0005
R23610 a_37603_6550.n1 a_37603_6550.n2 1.37206
R23611 a_37603_6550.n2 a_37603_6550.t0 18.9255
R23612 a_37603_6550.n1 a_37603_6550.t6 17.6708
R23613 a_37603_6550.n0 a_37603_6550.t8 8.81561
R23614 a_31083_6550.t9 a_31083_6550.n5 8.90498
R23615 a_31083_6550.n5 a_31083_6550.t3 10.0462
R23616 a_31083_6550.n5 a_31083_6550.n0 1.09706
R23617 a_31083_6550.n0 a_31083_6550.n4 1.09706
R23618 a_31083_6550.n4 a_31083_6550.t7 8.90498
R23619 a_31083_6550.n4 a_31083_6550.t2 10.0462
R23620 a_31083_6550.n0 a_31083_6550.n1 18.263
R23621 a_31083_6550.n3 a_31083_6550.t5 17.0005
R23622 a_31083_6550.n1 a_31083_6550.n3 1.37206
R23623 a_31083_6550.n3 a_31083_6550.t1 18.9255
R23624 a_31083_6550.n2 a_31083_6550.t4 17.0005
R23625 a_31083_6550.n1 a_31083_6550.n2 1.37206
R23626 a_31083_6550.n2 a_31083_6550.t0 18.9255
R23627 a_31083_6550.n1 a_31083_6550.t6 17.6708
R23628 a_31083_6550.n0 a_31083_6550.t8 8.81561
R23629 a_24563_6550.t9 a_24563_6550.n5 8.90498
R23630 a_24563_6550.n5 a_24563_6550.t3 10.0462
R23631 a_24563_6550.n5 a_24563_6550.n0 1.09706
R23632 a_24563_6550.n0 a_24563_6550.n4 1.09706
R23633 a_24563_6550.n4 a_24563_6550.t7 8.90498
R23634 a_24563_6550.n4 a_24563_6550.t2 10.0462
R23635 a_24563_6550.n0 a_24563_6550.n1 18.263
R23636 a_24563_6550.n3 a_24563_6550.t5 17.0005
R23637 a_24563_6550.n1 a_24563_6550.n3 1.37206
R23638 a_24563_6550.n3 a_24563_6550.t1 18.9255
R23639 a_24563_6550.n2 a_24563_6550.t4 17.0005
R23640 a_24563_6550.n1 a_24563_6550.n2 1.37206
R23641 a_24563_6550.n2 a_24563_6550.t0 18.9255
R23642 a_24563_6550.n1 a_24563_6550.t6 17.6708
R23643 a_24563_6550.n0 a_24563_6550.t8 8.81561
R23644 a_18043_6550.t9 a_18043_6550.n5 8.90498
R23645 a_18043_6550.n5 a_18043_6550.t3 10.0462
R23646 a_18043_6550.n5 a_18043_6550.n0 1.09706
R23647 a_18043_6550.n0 a_18043_6550.n4 1.09706
R23648 a_18043_6550.n4 a_18043_6550.t7 8.90498
R23649 a_18043_6550.n4 a_18043_6550.t2 10.0462
R23650 a_18043_6550.n0 a_18043_6550.n1 18.263
R23651 a_18043_6550.n3 a_18043_6550.t5 17.0005
R23652 a_18043_6550.n1 a_18043_6550.n3 1.37206
R23653 a_18043_6550.n3 a_18043_6550.t1 18.9255
R23654 a_18043_6550.n2 a_18043_6550.t4 17.0005
R23655 a_18043_6550.n1 a_18043_6550.n2 1.37206
R23656 a_18043_6550.n2 a_18043_6550.t0 18.9255
R23657 a_18043_6550.n1 a_18043_6550.t6 17.6708
R23658 a_18043_6550.n0 a_18043_6550.t8 8.81561
R23659 a_11523_6550.t9 a_11523_6550.n5 8.90498
R23660 a_11523_6550.n5 a_11523_6550.t3 10.0462
R23661 a_11523_6550.n5 a_11523_6550.n0 1.09706
R23662 a_11523_6550.n0 a_11523_6550.n4 1.09706
R23663 a_11523_6550.n4 a_11523_6550.t7 8.90498
R23664 a_11523_6550.n4 a_11523_6550.t2 10.0462
R23665 a_11523_6550.n0 a_11523_6550.n1 18.263
R23666 a_11523_6550.n3 a_11523_6550.t5 17.0005
R23667 a_11523_6550.n1 a_11523_6550.n3 1.37206
R23668 a_11523_6550.n3 a_11523_6550.t1 18.9255
R23669 a_11523_6550.n2 a_11523_6550.t4 17.0005
R23670 a_11523_6550.n1 a_11523_6550.n2 1.37206
R23671 a_11523_6550.n2 a_11523_6550.t0 18.9255
R23672 a_11523_6550.n1 a_11523_6550.t6 17.6708
R23673 a_11523_6550.n0 a_11523_6550.t8 8.81561
R23674 a_5003_6550.t9 a_5003_6550.n5 8.90498
R23675 a_5003_6550.n5 a_5003_6550.t3 10.0462
R23676 a_5003_6550.n5 a_5003_6550.n0 1.09706
R23677 a_5003_6550.n0 a_5003_6550.n4 1.09706
R23678 a_5003_6550.n4 a_5003_6550.t7 8.90498
R23679 a_5003_6550.n4 a_5003_6550.t2 10.0462
R23680 a_5003_6550.n0 a_5003_6550.n1 18.263
R23681 a_5003_6550.n3 a_5003_6550.t5 17.0005
R23682 a_5003_6550.n1 a_5003_6550.n3 1.37206
R23683 a_5003_6550.n3 a_5003_6550.t1 18.9255
R23684 a_5003_6550.n2 a_5003_6550.t4 17.0005
R23685 a_5003_6550.n1 a_5003_6550.n2 1.37206
R23686 a_5003_6550.n2 a_5003_6550.t0 18.9255
R23687 a_5003_6550.n1 a_5003_6550.t6 17.6708
R23688 a_5003_6550.n0 a_5003_6550.t8 8.81561
R23689 a_49938_6514.t0 a_49938_6514.n0 8.53521
R23690 a_49938_6514.n0 a_49938_6514.t2 16.6582
R23691 a_49938_6514.n0 a_49938_6514.t1 6.13582
R23692 a_43418_6514.t0 a_43418_6514.n0 8.53521
R23693 a_43418_6514.n0 a_43418_6514.t2 16.6582
R23694 a_43418_6514.n0 a_43418_6514.t1 6.13582
R23695 a_49517_6494.t0 a_49517_6494.n0 8.53379
R23696 a_49517_6494.n0 a_49517_6494.t1 6.23476
R23697 a_49517_6494.n0 a_49517_6494.t2 35.9286
R23698 a_36898_6514.t0 a_36898_6514.n0 8.53521
R23699 a_36898_6514.n0 a_36898_6514.t2 16.6582
R23700 a_36898_6514.n0 a_36898_6514.t1 6.13582
R23701 a_42997_6494.t0 a_42997_6494.n0 8.53379
R23702 a_42997_6494.n0 a_42997_6494.t1 6.23476
R23703 a_42997_6494.n0 a_42997_6494.t2 35.9286
R23704 a_30378_6514.t0 a_30378_6514.n0 8.53521
R23705 a_30378_6514.n0 a_30378_6514.t2 16.6582
R23706 a_30378_6514.n0 a_30378_6514.t1 6.13582
R23707 a_36477_6494.t0 a_36477_6494.n0 8.53379
R23708 a_36477_6494.n0 a_36477_6494.t1 6.23476
R23709 a_36477_6494.n0 a_36477_6494.t2 35.9286
R23710 a_23858_6514.t0 a_23858_6514.n0 8.53521
R23711 a_23858_6514.n0 a_23858_6514.t2 16.6582
R23712 a_23858_6514.n0 a_23858_6514.t1 6.13582
R23713 a_29957_6494.t0 a_29957_6494.n0 8.53379
R23714 a_29957_6494.n0 a_29957_6494.t1 6.23476
R23715 a_29957_6494.n0 a_29957_6494.t2 35.9286
R23716 a_17338_6514.t0 a_17338_6514.n0 8.53521
R23717 a_17338_6514.n0 a_17338_6514.t2 16.6582
R23718 a_17338_6514.n0 a_17338_6514.t1 6.13582
R23719 a_23437_6494.t0 a_23437_6494.n0 8.53379
R23720 a_23437_6494.n0 a_23437_6494.t1 6.23476
R23721 a_23437_6494.n0 a_23437_6494.t2 35.9286
R23722 a_10818_6514.t0 a_10818_6514.n0 8.53521
R23723 a_10818_6514.n0 a_10818_6514.t2 16.6582
R23724 a_10818_6514.n0 a_10818_6514.t1 6.13582
R23725 a_16917_6494.t0 a_16917_6494.n0 8.53379
R23726 a_16917_6494.n0 a_16917_6494.t1 6.23476
R23727 a_16917_6494.n0 a_16917_6494.t2 35.9286
R23728 a_4298_6514.t0 a_4298_6514.n0 8.53521
R23729 a_4298_6514.n0 a_4298_6514.t2 16.6582
R23730 a_4298_6514.n0 a_4298_6514.t1 6.13582
R23731 a_10397_6494.t0 a_10397_6494.n0 8.53379
R23732 a_10397_6494.n0 a_10397_6494.t1 6.23476
R23733 a_10397_6494.n0 a_10397_6494.t2 35.9286
R23734 a_3877_6494.t0 a_3877_6494.n0 8.53379
R23735 a_3877_6494.n0 a_3877_6494.t1 6.23476
R23736 a_3877_6494.n0 a_3877_6494.t2 35.9286
R23737 a_50809_9090.t3 a_50809_9090.n0 8.8328
R23738 a_50809_9090.n2 a_50809_9090.n3 1.14175
R23739 a_50809_9090.n1 a_50809_9090.n2 1.14175
R23740 a_50809_9090.n0 a_50809_9090.n1 1.14175
R23741 a_50809_9090.n3 a_50809_9090.t0 8.8328
R23742 a_50809_9090.n3 a_50809_9090.t4 8.8328
R23743 a_50809_9090.n2 a_50809_9090.t1 8.8328
R23744 a_50809_9090.n2 a_50809_9090.t5 8.8318
R23745 a_50809_9090.n1 a_50809_9090.t2 8.8328
R23746 a_50809_9090.n1 a_50809_9090.t7 8.8318
R23747 a_50809_9090.n0 a_50809_9090.t6 8.8318
R23748 a_48826_9093.t0 a_48826_9093.t1 35.1591
R23749 a_47950_9029.t0 a_47950_9029.t1 35.2643
R23750 a_49721_9294.t0 a_49721_9294.n0 8.76769
R23751 a_49721_9294.n0 a_49721_9294.t2 15.0661
R23752 a_49721_9294.n0 a_49721_9294.t1 5.94842
R23753 a_49148_9233.n0 a_49148_9233.t1 17.0005
R23754 a_49148_9233.t0 a_49148_9233.n0 18.2612
R23755 a_49148_9233.n0 a_49148_9233.t2 15.5529
R23756 a_48920_9093.t1 a_48920_9093.n0 17.5293
R23757 a_48920_9093.n0 a_48920_9093.t0 17.726
R23758 a_48920_9093.n0 a_48920_9093.t2 15.773
R23759 a_46818_9017.n0 a_46818_9017.t0 8.46601
R23760 a_46818_9017.t1 a_46818_9017.n0 9.03504
R23761 a_46818_9017.n0 a_46818_9017.t2 9.14806
R23762 a_48172_9360.t0 a_48172_9360.n1 17.3368
R23763 a_48172_9360.n0 a_48172_9360.t1 8.47322
R23764 a_48172_9360.n1 a_48172_9360.n0 0.103627
R23765 a_48172_9360.n0 a_48172_9360.t2 17.4516
R23766 a_48172_9360.n1 a_48172_9360.t3 15.0435
R23767 a_48070_9273.n0 a_48070_9273.t3 15.0005
R23768 a_48070_9273.t0 a_48070_9273.n0 17.9114
R23769 a_48070_9273.n1 a_48070_9273.t1 17.0005
R23770 a_48070_9273.n0 a_48070_9273.n1 0.655551
R23771 a_48070_9273.n1 a_48070_9273.t2 15.2176
R23772 a_47661_9334.t0 a_47661_9334.n2 17.1232
R23773 a_47661_9334.n2 a_47661_9334.n0 0.498937
R23774 a_47661_9334.n2 a_47661_9334.t1 18.4279
R23775 a_47661_9334.n0 a_47661_9334.n1 3.38952
R23776 a_47661_9334.n1 a_47661_9334.t2 18.3531
R23777 a_47661_9334.n1 a_47661_9334.t3 17.9378
R23778 a_47661_9334.n0 a_47661_9334.t4 15.4204
R23779 a_47375_9016.n0 a_47375_9016.t1 17.0005
R23780 a_47375_9016.t0 a_47375_9016.n0 18.3191
R23781 a_47375_9016.n1 a_47375_9016.t3 17.0005
R23782 a_47375_9016.n0 a_47375_9016.n1 3.28463
R23783 a_47375_9016.n1 a_47375_9016.t2 18.6222
R23784 a_47635_9239.t0 a_47635_9239.n1 17.3352
R23785 a_47635_9239.n1 a_47635_9239.t1 17.2651
R23786 a_47635_9239.n1 a_47635_9239.n0 0.948441
R23787 a_47635_9239.n0 a_47635_9239.t2 17.3305
R23788 a_47635_9239.n0 a_47635_9239.t3 15.4436
R23789 a_46919_9314.t0 a_46919_9314.n1 17.1443
R23790 a_46919_9314.n1 a_46919_9314.n0 0.743
R23791 a_46919_9314.n0 a_46919_9314.t2 8.65706
R23792 a_46919_9314.n0 a_46919_9314.t1 8.71106
R23793 a_46919_9314.n1 a_46919_9314.t3 15.731
R23794 a_46530_8998.t0 a_46530_8998.n0 8.81393
R23795 a_46530_8998.n0 a_46530_8998.t2 15.4488
R23796 a_46530_8998.n0 a_46530_8998.t1 6.09623
R23797 a_44289_9090.t3 a_44289_9090.n0 8.8328
R23798 a_44289_9090.n2 a_44289_9090.n3 1.14175
R23799 a_44289_9090.n1 a_44289_9090.n2 1.14175
R23800 a_44289_9090.n0 a_44289_9090.n1 1.14175
R23801 a_44289_9090.n3 a_44289_9090.t0 8.8328
R23802 a_44289_9090.n3 a_44289_9090.t4 8.8328
R23803 a_44289_9090.n2 a_44289_9090.t1 8.8328
R23804 a_44289_9090.n2 a_44289_9090.t5 8.8318
R23805 a_44289_9090.n1 a_44289_9090.t2 8.8328
R23806 a_44289_9090.n1 a_44289_9090.t7 8.8318
R23807 a_44289_9090.n0 a_44289_9090.t6 8.8318
R23808 a_42306_9093.t0 a_42306_9093.t1 35.1591
R23809 a_41430_9029.t0 a_41430_9029.t1 35.2643
R23810 a_46225_9394.t0 a_46225_9394.n0 17.1718
R23811 a_46225_9394.n0 a_46225_9394.t1 9.7433
R23812 a_46225_9394.n0 a_46225_9394.t2 15.4943
R23813 a_43201_9294.t0 a_43201_9294.n0 8.76769
R23814 a_43201_9294.n0 a_43201_9294.t2 15.0661
R23815 a_43201_9294.n0 a_43201_9294.t1 5.94842
R23816 a_42628_9233.t0 a_42628_9233.n0 17.0005
R23817 a_42628_9233.n0 a_42628_9233.t1 18.2612
R23818 a_42628_9233.n0 a_42628_9233.t2 15.5529
R23819 a_42400_9093.t1 a_42400_9093.n0 17.5293
R23820 a_42400_9093.n0 a_42400_9093.t0 17.726
R23821 a_42400_9093.n0 a_42400_9093.t2 15.773
R23822 a_40298_9017.n0 a_40298_9017.t0 8.46601
R23823 a_40298_9017.t1 a_40298_9017.n0 9.03504
R23824 a_40298_9017.n0 a_40298_9017.t2 9.14806
R23825 a_41652_9360.t0 a_41652_9360.n1 17.3368
R23826 a_41652_9360.n0 a_41652_9360.t1 8.47322
R23827 a_41652_9360.n1 a_41652_9360.n0 0.103627
R23828 a_41652_9360.n0 a_41652_9360.t2 17.4516
R23829 a_41652_9360.n1 a_41652_9360.t3 15.0435
R23830 a_41550_9273.n0 a_41550_9273.t3 15.0005
R23831 a_41550_9273.t0 a_41550_9273.n0 17.9114
R23832 a_41550_9273.n1 a_41550_9273.t1 17.0005
R23833 a_41550_9273.n0 a_41550_9273.n1 0.655551
R23834 a_41550_9273.n1 a_41550_9273.t2 15.2176
R23835 a_41141_9334.t0 a_41141_9334.n2 17.1232
R23836 a_41141_9334.n2 a_41141_9334.n0 0.498937
R23837 a_41141_9334.n2 a_41141_9334.t1 18.4279
R23838 a_41141_9334.n0 a_41141_9334.n1 3.38952
R23839 a_41141_9334.n1 a_41141_9334.t3 18.3531
R23840 a_41141_9334.n1 a_41141_9334.t2 17.9378
R23841 a_41141_9334.n0 a_41141_9334.t4 15.4204
R23842 a_40855_9016.n0 a_40855_9016.t1 17.0005
R23843 a_40855_9016.t0 a_40855_9016.n0 18.3191
R23844 a_40855_9016.n1 a_40855_9016.t2 17.0005
R23845 a_40855_9016.n0 a_40855_9016.n1 3.28463
R23846 a_40855_9016.n1 a_40855_9016.t3 18.6222
R23847 a_41115_9239.t0 a_41115_9239.n1 17.3352
R23848 a_41115_9239.n1 a_41115_9239.t1 17.2651
R23849 a_41115_9239.n1 a_41115_9239.n0 0.948441
R23850 a_41115_9239.n0 a_41115_9239.t2 17.3305
R23851 a_41115_9239.n0 a_41115_9239.t3 15.4436
R23852 a_40399_9314.t1 a_40399_9314.n1 17.1443
R23853 a_40399_9314.n1 a_40399_9314.n0 0.743
R23854 a_40399_9314.n0 a_40399_9314.t2 8.65706
R23855 a_40399_9314.n0 a_40399_9314.t0 8.71106
R23856 a_40399_9314.n1 a_40399_9314.t3 15.731
R23857 a_40010_8998.t0 a_40010_8998.n0 8.81393
R23858 a_40010_8998.n0 a_40010_8998.t2 15.4488
R23859 a_40010_8998.n0 a_40010_8998.t1 6.09623
R23860 a_37769_9090.t3 a_37769_9090.n0 8.8328
R23861 a_37769_9090.n2 a_37769_9090.n3 1.14175
R23862 a_37769_9090.n1 a_37769_9090.n2 1.14175
R23863 a_37769_9090.n0 a_37769_9090.n1 1.14175
R23864 a_37769_9090.n3 a_37769_9090.t0 8.8328
R23865 a_37769_9090.n3 a_37769_9090.t4 8.8328
R23866 a_37769_9090.n2 a_37769_9090.t1 8.8328
R23867 a_37769_9090.n2 a_37769_9090.t5 8.8318
R23868 a_37769_9090.n1 a_37769_9090.t2 8.8328
R23869 a_37769_9090.n1 a_37769_9090.t7 8.8318
R23870 a_37769_9090.n0 a_37769_9090.t6 8.8318
R23871 a_35786_9093.t0 a_35786_9093.t1 35.1591
R23872 a_34910_9029.t0 a_34910_9029.t1 35.2643
R23873 a_39705_9394.t0 a_39705_9394.n0 17.1718
R23874 a_39705_9394.n0 a_39705_9394.t1 9.7433
R23875 a_39705_9394.n0 a_39705_9394.t2 15.4943
R23876 a_36681_9294.t0 a_36681_9294.n0 8.76769
R23877 a_36681_9294.n0 a_36681_9294.t2 15.0661
R23878 a_36681_9294.n0 a_36681_9294.t1 5.94842
R23879 a_36108_9233.t0 a_36108_9233.n0 17.0005
R23880 a_36108_9233.n0 a_36108_9233.t1 18.2612
R23881 a_36108_9233.n0 a_36108_9233.t2 15.5529
R23882 a_35880_9093.t1 a_35880_9093.n0 17.5293
R23883 a_35880_9093.n0 a_35880_9093.t0 17.726
R23884 a_35880_9093.n0 a_35880_9093.t2 15.773
R23885 a_33778_9017.n0 a_33778_9017.t0 8.46601
R23886 a_33778_9017.t1 a_33778_9017.n0 9.03504
R23887 a_33778_9017.n0 a_33778_9017.t2 9.14806
R23888 a_35132_9360.t0 a_35132_9360.n1 17.3368
R23889 a_35132_9360.n0 a_35132_9360.t1 8.47322
R23890 a_35132_9360.n1 a_35132_9360.n0 0.103627
R23891 a_35132_9360.n0 a_35132_9360.t2 17.4516
R23892 a_35132_9360.n1 a_35132_9360.t3 15.0435
R23893 a_35030_9273.n0 a_35030_9273.t3 15.0005
R23894 a_35030_9273.t0 a_35030_9273.n0 17.9114
R23895 a_35030_9273.n1 a_35030_9273.t1 17.0005
R23896 a_35030_9273.n0 a_35030_9273.n1 0.655551
R23897 a_35030_9273.n1 a_35030_9273.t2 15.2176
R23898 a_34621_9334.t0 a_34621_9334.n2 17.1232
R23899 a_34621_9334.n2 a_34621_9334.n0 0.498937
R23900 a_34621_9334.n2 a_34621_9334.t1 18.4279
R23901 a_34621_9334.n0 a_34621_9334.n1 3.38952
R23902 a_34621_9334.n1 a_34621_9334.t2 18.3531
R23903 a_34621_9334.n1 a_34621_9334.t3 17.9378
R23904 a_34621_9334.n0 a_34621_9334.t4 15.4204
R23905 a_34335_9016.n0 a_34335_9016.t1 17.0005
R23906 a_34335_9016.t0 a_34335_9016.n0 18.3191
R23907 a_34335_9016.n1 a_34335_9016.t3 17.0005
R23908 a_34335_9016.n0 a_34335_9016.n1 3.28463
R23909 a_34335_9016.n1 a_34335_9016.t2 18.6222
R23910 a_34595_9239.t0 a_34595_9239.n1 17.3352
R23911 a_34595_9239.n1 a_34595_9239.t1 17.2651
R23912 a_34595_9239.n1 a_34595_9239.n0 0.948441
R23913 a_34595_9239.n0 a_34595_9239.t2 17.3305
R23914 a_34595_9239.n0 a_34595_9239.t3 15.4436
R23915 a_33879_9314.t0 a_33879_9314.n1 17.1443
R23916 a_33879_9314.n1 a_33879_9314.n0 0.743
R23917 a_33879_9314.n0 a_33879_9314.t2 8.65706
R23918 a_33879_9314.n0 a_33879_9314.t1 8.71106
R23919 a_33879_9314.n1 a_33879_9314.t3 15.731
R23920 a_33490_8998.t0 a_33490_8998.n0 8.81393
R23921 a_33490_8998.n0 a_33490_8998.t2 15.4488
R23922 a_33490_8998.n0 a_33490_8998.t1 6.09623
R23923 a_31249_9090.t3 a_31249_9090.n0 8.8328
R23924 a_31249_9090.n2 a_31249_9090.n3 1.14175
R23925 a_31249_9090.n1 a_31249_9090.n2 1.14175
R23926 a_31249_9090.n0 a_31249_9090.n1 1.14175
R23927 a_31249_9090.n3 a_31249_9090.t0 8.8328
R23928 a_31249_9090.n3 a_31249_9090.t4 8.8328
R23929 a_31249_9090.n2 a_31249_9090.t1 8.8328
R23930 a_31249_9090.n2 a_31249_9090.t5 8.8318
R23931 a_31249_9090.n1 a_31249_9090.t2 8.8328
R23932 a_31249_9090.n1 a_31249_9090.t7 8.8318
R23933 a_31249_9090.n0 a_31249_9090.t6 8.8318
R23934 a_29266_9093.t0 a_29266_9093.t1 35.1591
R23935 a_28390_9029.t0 a_28390_9029.t1 35.2643
R23936 a_33185_9394.t0 a_33185_9394.n0 17.1718
R23937 a_33185_9394.n0 a_33185_9394.t1 9.7433
R23938 a_33185_9394.n0 a_33185_9394.t2 15.4943
R23939 a_30161_9294.t0 a_30161_9294.n0 8.76769
R23940 a_30161_9294.n0 a_30161_9294.t2 15.0661
R23941 a_30161_9294.n0 a_30161_9294.t1 5.94842
R23942 a_29588_9233.n0 a_29588_9233.t1 17.0005
R23943 a_29588_9233.t0 a_29588_9233.n0 18.2612
R23944 a_29588_9233.n0 a_29588_9233.t2 15.5529
R23945 a_29360_9093.t1 a_29360_9093.n0 17.5293
R23946 a_29360_9093.n0 a_29360_9093.t0 17.726
R23947 a_29360_9093.n0 a_29360_9093.t2 15.773
R23948 a_27258_9017.n0 a_27258_9017.t0 8.46601
R23949 a_27258_9017.t1 a_27258_9017.n0 9.03504
R23950 a_27258_9017.n0 a_27258_9017.t2 9.14806
R23951 a_28612_9360.t0 a_28612_9360.n1 17.3368
R23952 a_28612_9360.n0 a_28612_9360.t1 8.47322
R23953 a_28612_9360.n1 a_28612_9360.n0 0.103627
R23954 a_28612_9360.n0 a_28612_9360.t2 17.4516
R23955 a_28612_9360.n1 a_28612_9360.t3 15.0435
R23956 a_28510_9273.n0 a_28510_9273.t3 15.0005
R23957 a_28510_9273.t0 a_28510_9273.n0 17.9114
R23958 a_28510_9273.n1 a_28510_9273.t1 17.0005
R23959 a_28510_9273.n0 a_28510_9273.n1 0.655551
R23960 a_28510_9273.n1 a_28510_9273.t2 15.2176
R23961 a_28101_9334.t0 a_28101_9334.n2 17.1232
R23962 a_28101_9334.n2 a_28101_9334.n0 0.498937
R23963 a_28101_9334.n2 a_28101_9334.t1 18.4279
R23964 a_28101_9334.n0 a_28101_9334.n1 3.38952
R23965 a_28101_9334.n1 a_28101_9334.t3 18.3531
R23966 a_28101_9334.n1 a_28101_9334.t2 17.9378
R23967 a_28101_9334.n0 a_28101_9334.t4 15.4204
R23968 a_27815_9016.n0 a_27815_9016.t1 17.0005
R23969 a_27815_9016.t0 a_27815_9016.n0 18.3191
R23970 a_27815_9016.n1 a_27815_9016.t2 17.0005
R23971 a_27815_9016.n0 a_27815_9016.n1 3.28463
R23972 a_27815_9016.n1 a_27815_9016.t3 18.6222
R23973 a_28075_9239.t0 a_28075_9239.n1 17.3352
R23974 a_28075_9239.n1 a_28075_9239.t1 17.2651
R23975 a_28075_9239.n1 a_28075_9239.n0 0.948441
R23976 a_28075_9239.n0 a_28075_9239.t2 17.3305
R23977 a_28075_9239.n0 a_28075_9239.t3 15.4436
R23978 a_27359_9314.t0 a_27359_9314.n1 17.1443
R23979 a_27359_9314.n1 a_27359_9314.n0 0.743
R23980 a_27359_9314.n0 a_27359_9314.t2 8.65706
R23981 a_27359_9314.n0 a_27359_9314.t1 8.71106
R23982 a_27359_9314.n1 a_27359_9314.t3 15.731
R23983 a_26970_8998.t0 a_26970_8998.n0 8.81393
R23984 a_26970_8998.n0 a_26970_8998.t2 15.4488
R23985 a_26970_8998.n0 a_26970_8998.t1 6.09623
R23986 a_24729_9090.t3 a_24729_9090.n0 8.8328
R23987 a_24729_9090.n2 a_24729_9090.n3 1.14175
R23988 a_24729_9090.n1 a_24729_9090.n2 1.14175
R23989 a_24729_9090.n0 a_24729_9090.n1 1.14175
R23990 a_24729_9090.n3 a_24729_9090.t0 8.8328
R23991 a_24729_9090.n3 a_24729_9090.t4 8.8328
R23992 a_24729_9090.n2 a_24729_9090.t1 8.8328
R23993 a_24729_9090.n2 a_24729_9090.t5 8.8318
R23994 a_24729_9090.n1 a_24729_9090.t2 8.8328
R23995 a_24729_9090.n1 a_24729_9090.t7 8.8318
R23996 a_24729_9090.n0 a_24729_9090.t6 8.8318
R23997 a_22746_9093.t0 a_22746_9093.t1 35.1591
R23998 a_21870_9029.t0 a_21870_9029.t1 35.2643
R23999 a_26665_9394.t0 a_26665_9394.n0 17.1718
R24000 a_26665_9394.n0 a_26665_9394.t1 9.7433
R24001 a_26665_9394.n0 a_26665_9394.t2 15.4943
R24002 a_23641_9294.t0 a_23641_9294.n0 8.76769
R24003 a_23641_9294.n0 a_23641_9294.t2 15.0661
R24004 a_23641_9294.n0 a_23641_9294.t1 5.94842
R24005 a_23068_9233.n0 a_23068_9233.t1 17.0005
R24006 a_23068_9233.t0 a_23068_9233.n0 18.2612
R24007 a_23068_9233.n0 a_23068_9233.t2 15.5529
R24008 a_22840_9093.t1 a_22840_9093.n0 17.5293
R24009 a_22840_9093.n0 a_22840_9093.t0 17.726
R24010 a_22840_9093.n0 a_22840_9093.t2 15.773
R24011 a_20738_9017.n0 a_20738_9017.t0 8.46601
R24012 a_20738_9017.t1 a_20738_9017.n0 9.03504
R24013 a_20738_9017.n0 a_20738_9017.t2 9.14806
R24014 a_22092_9360.t0 a_22092_9360.n1 17.3368
R24015 a_22092_9360.n0 a_22092_9360.t1 8.47322
R24016 a_22092_9360.n1 a_22092_9360.n0 0.103627
R24017 a_22092_9360.n0 a_22092_9360.t2 17.4516
R24018 a_22092_9360.n1 a_22092_9360.t3 15.0435
R24019 a_21990_9273.n0 a_21990_9273.t3 15.0005
R24020 a_21990_9273.t0 a_21990_9273.n0 17.9114
R24021 a_21990_9273.n1 a_21990_9273.t1 17.0005
R24022 a_21990_9273.n0 a_21990_9273.n1 0.655551
R24023 a_21990_9273.n1 a_21990_9273.t2 15.2176
R24024 a_21581_9334.t0 a_21581_9334.n2 17.1232
R24025 a_21581_9334.n2 a_21581_9334.n0 0.498937
R24026 a_21581_9334.n2 a_21581_9334.t1 18.4279
R24027 a_21581_9334.n0 a_21581_9334.n1 3.38952
R24028 a_21581_9334.n1 a_21581_9334.t2 18.3531
R24029 a_21581_9334.n1 a_21581_9334.t3 17.9378
R24030 a_21581_9334.n0 a_21581_9334.t4 15.4204
R24031 a_21295_9016.n0 a_21295_9016.t1 17.0005
R24032 a_21295_9016.t0 a_21295_9016.n0 18.3191
R24033 a_21295_9016.n1 a_21295_9016.t3 17.0005
R24034 a_21295_9016.n0 a_21295_9016.n1 3.28463
R24035 a_21295_9016.n1 a_21295_9016.t2 18.6222
R24036 a_21555_9239.t0 a_21555_9239.n1 17.2651
R24037 a_21555_9239.n1 a_21555_9239.t1 17.3352
R24038 a_21555_9239.n1 a_21555_9239.n0 0.948441
R24039 a_21555_9239.n0 a_21555_9239.t2 17.3305
R24040 a_21555_9239.n0 a_21555_9239.t3 15.4436
R24041 a_20839_9314.t0 a_20839_9314.n1 17.1443
R24042 a_20839_9314.n1 a_20839_9314.n0 0.743
R24043 a_20839_9314.n0 a_20839_9314.t2 8.65706
R24044 a_20839_9314.n0 a_20839_9314.t1 8.71106
R24045 a_20839_9314.n1 a_20839_9314.t3 15.731
R24046 a_20450_8998.t0 a_20450_8998.n0 8.81393
R24047 a_20450_8998.n0 a_20450_8998.t2 15.4488
R24048 a_20450_8998.n0 a_20450_8998.t1 6.09623
R24049 a_18209_9090.t3 a_18209_9090.n0 8.8328
R24050 a_18209_9090.n2 a_18209_9090.n3 1.14175
R24051 a_18209_9090.n1 a_18209_9090.n2 1.14175
R24052 a_18209_9090.n0 a_18209_9090.n1 1.14175
R24053 a_18209_9090.n3 a_18209_9090.t0 8.8328
R24054 a_18209_9090.n3 a_18209_9090.t4 8.8328
R24055 a_18209_9090.n2 a_18209_9090.t1 8.8328
R24056 a_18209_9090.n2 a_18209_9090.t5 8.8318
R24057 a_18209_9090.n1 a_18209_9090.t2 8.8328
R24058 a_18209_9090.n1 a_18209_9090.t7 8.8318
R24059 a_18209_9090.n0 a_18209_9090.t6 8.8318
R24060 a_16226_9093.t0 a_16226_9093.t1 35.1591
R24061 a_15350_9029.t0 a_15350_9029.t1 35.2643
R24062 a_20145_9394.t0 a_20145_9394.n0 17.1718
R24063 a_20145_9394.n0 a_20145_9394.t1 9.7433
R24064 a_20145_9394.n0 a_20145_9394.t2 15.4943
R24065 a_17121_9294.t0 a_17121_9294.n0 8.76769
R24066 a_17121_9294.n0 a_17121_9294.t2 15.0661
R24067 a_17121_9294.n0 a_17121_9294.t1 5.94842
R24068 a_16548_9233.n0 a_16548_9233.t1 17.0005
R24069 a_16548_9233.t0 a_16548_9233.n0 18.2612
R24070 a_16548_9233.n0 a_16548_9233.t2 15.5529
R24071 a_16320_9093.t1 a_16320_9093.n0 17.5293
R24072 a_16320_9093.n0 a_16320_9093.t0 17.726
R24073 a_16320_9093.n0 a_16320_9093.t2 15.773
R24074 a_14218_9017.n0 a_14218_9017.t0 8.46601
R24075 a_14218_9017.t1 a_14218_9017.n0 9.03504
R24076 a_14218_9017.n0 a_14218_9017.t2 9.14806
R24077 a_15572_9360.t0 a_15572_9360.n1 17.3368
R24078 a_15572_9360.n0 a_15572_9360.t1 8.47322
R24079 a_15572_9360.n1 a_15572_9360.n0 0.103627
R24080 a_15572_9360.n0 a_15572_9360.t2 17.4516
R24081 a_15572_9360.n1 a_15572_9360.t3 15.0435
R24082 a_15470_9273.n0 a_15470_9273.t3 15.0005
R24083 a_15470_9273.t0 a_15470_9273.n0 17.9114
R24084 a_15470_9273.n1 a_15470_9273.t1 17.0005
R24085 a_15470_9273.n0 a_15470_9273.n1 0.655551
R24086 a_15470_9273.n1 a_15470_9273.t2 15.2176
R24087 a_15061_9334.t0 a_15061_9334.n2 17.1232
R24088 a_15061_9334.n2 a_15061_9334.n0 0.498937
R24089 a_15061_9334.n2 a_15061_9334.t1 18.4279
R24090 a_15061_9334.n0 a_15061_9334.n1 3.38952
R24091 a_15061_9334.n1 a_15061_9334.t2 18.3531
R24092 a_15061_9334.n1 a_15061_9334.t3 17.9378
R24093 a_15061_9334.n0 a_15061_9334.t4 15.4204
R24094 a_14775_9016.n0 a_14775_9016.t1 17.0005
R24095 a_14775_9016.t0 a_14775_9016.n0 18.3191
R24096 a_14775_9016.n1 a_14775_9016.t3 17.0005
R24097 a_14775_9016.n0 a_14775_9016.n1 3.28463
R24098 a_14775_9016.n1 a_14775_9016.t2 18.6222
R24099 a_15035_9239.t0 a_15035_9239.n1 17.3352
R24100 a_15035_9239.n1 a_15035_9239.t1 17.2651
R24101 a_15035_9239.n1 a_15035_9239.n0 0.948441
R24102 a_15035_9239.n0 a_15035_9239.t2 17.3305
R24103 a_15035_9239.n0 a_15035_9239.t3 15.4436
R24104 a_14319_9314.t1 a_14319_9314.n1 17.1443
R24105 a_14319_9314.n1 a_14319_9314.n0 0.743
R24106 a_14319_9314.n0 a_14319_9314.t2 8.65706
R24107 a_14319_9314.n0 a_14319_9314.t0 8.71106
R24108 a_14319_9314.n1 a_14319_9314.t3 15.731
R24109 a_13930_8998.t0 a_13930_8998.n0 8.81393
R24110 a_13930_8998.n0 a_13930_8998.t2 15.4488
R24111 a_13930_8998.n0 a_13930_8998.t1 6.09623
R24112 a_11689_9090.t3 a_11689_9090.n0 8.8328
R24113 a_11689_9090.n2 a_11689_9090.n3 1.14175
R24114 a_11689_9090.n1 a_11689_9090.n2 1.14175
R24115 a_11689_9090.n0 a_11689_9090.n1 1.14175
R24116 a_11689_9090.n3 a_11689_9090.t0 8.8328
R24117 a_11689_9090.n3 a_11689_9090.t4 8.8328
R24118 a_11689_9090.n2 a_11689_9090.t1 8.8328
R24119 a_11689_9090.n2 a_11689_9090.t5 8.8318
R24120 a_11689_9090.n1 a_11689_9090.t2 8.8328
R24121 a_11689_9090.n1 a_11689_9090.t7 8.8318
R24122 a_11689_9090.n0 a_11689_9090.t6 8.8318
R24123 a_9706_9093.t0 a_9706_9093.t1 35.1591
R24124 a_8830_9029.t0 a_8830_9029.t1 35.2643
R24125 a_13625_9394.t0 a_13625_9394.n0 17.1718
R24126 a_13625_9394.n0 a_13625_9394.t1 9.7433
R24127 a_13625_9394.n0 a_13625_9394.t2 15.4943
R24128 a_10601_9294.t0 a_10601_9294.n0 8.76769
R24129 a_10601_9294.n0 a_10601_9294.t2 15.0661
R24130 a_10601_9294.n0 a_10601_9294.t1 5.94842
R24131 a_10028_9233.t0 a_10028_9233.n0 17.0005
R24132 a_10028_9233.n0 a_10028_9233.t1 18.2612
R24133 a_10028_9233.n0 a_10028_9233.t2 15.5529
R24134 a_9800_9093.t1 a_9800_9093.n0 17.5293
R24135 a_9800_9093.n0 a_9800_9093.t0 17.726
R24136 a_9800_9093.n0 a_9800_9093.t2 15.773
R24137 a_7698_9017.n0 a_7698_9017.t0 8.46601
R24138 a_7698_9017.t1 a_7698_9017.n0 9.03504
R24139 a_7698_9017.n0 a_7698_9017.t2 9.14806
R24140 a_9052_9360.t0 a_9052_9360.n1 17.3368
R24141 a_9052_9360.n0 a_9052_9360.t1 8.47322
R24142 a_9052_9360.n1 a_9052_9360.n0 0.103627
R24143 a_9052_9360.n0 a_9052_9360.t2 17.4516
R24144 a_9052_9360.n1 a_9052_9360.t3 15.0435
R24145 a_8950_9273.n0 a_8950_9273.t3 15.0005
R24146 a_8950_9273.t0 a_8950_9273.n0 17.9114
R24147 a_8950_9273.n1 a_8950_9273.t1 17.0005
R24148 a_8950_9273.n0 a_8950_9273.n1 0.655551
R24149 a_8950_9273.n1 a_8950_9273.t2 15.2176
R24150 a_8541_9334.t0 a_8541_9334.n2 17.1232
R24151 a_8541_9334.n2 a_8541_9334.n0 0.498937
R24152 a_8541_9334.n2 a_8541_9334.t1 18.4279
R24153 a_8541_9334.n0 a_8541_9334.n1 3.38952
R24154 a_8541_9334.n1 a_8541_9334.t3 18.3531
R24155 a_8541_9334.n1 a_8541_9334.t2 17.9378
R24156 a_8541_9334.n0 a_8541_9334.t4 15.4204
R24157 a_8255_9016.n0 a_8255_9016.t1 17.0005
R24158 a_8255_9016.t0 a_8255_9016.n0 18.3191
R24159 a_8255_9016.n1 a_8255_9016.t2 17.0005
R24160 a_8255_9016.n0 a_8255_9016.n1 3.28463
R24161 a_8255_9016.n1 a_8255_9016.t3 18.6222
R24162 a_8515_9239.t0 a_8515_9239.n1 17.2651
R24163 a_8515_9239.n1 a_8515_9239.t1 17.3352
R24164 a_8515_9239.n1 a_8515_9239.n0 0.948441
R24165 a_8515_9239.n0 a_8515_9239.t2 17.3305
R24166 a_8515_9239.n0 a_8515_9239.t3 15.4436
R24167 a_7799_9314.t0 a_7799_9314.n1 17.1443
R24168 a_7799_9314.n1 a_7799_9314.n0 0.743
R24169 a_7799_9314.n0 a_7799_9314.t2 8.65706
R24170 a_7799_9314.n0 a_7799_9314.t1 8.71106
R24171 a_7799_9314.n1 a_7799_9314.t3 15.731
R24172 a_7410_8998.t0 a_7410_8998.n0 8.81393
R24173 a_7410_8998.n0 a_7410_8998.t2 15.4488
R24174 a_7410_8998.n0 a_7410_8998.t1 6.09623
R24175 a_5169_9090.t3 a_5169_9090.n0 8.8328
R24176 a_5169_9090.n2 a_5169_9090.n3 1.14175
R24177 a_5169_9090.n1 a_5169_9090.n2 1.14175
R24178 a_5169_9090.n0 a_5169_9090.n1 1.14175
R24179 a_5169_9090.n3 a_5169_9090.t0 8.8328
R24180 a_5169_9090.n3 a_5169_9090.t4 8.8328
R24181 a_5169_9090.n2 a_5169_9090.t1 8.8328
R24182 a_5169_9090.n2 a_5169_9090.t5 8.8318
R24183 a_5169_9090.n1 a_5169_9090.t2 8.8328
R24184 a_5169_9090.n1 a_5169_9090.t7 8.8318
R24185 a_5169_9090.n0 a_5169_9090.t6 8.8318
R24186 a_3186_9093.t0 a_3186_9093.t1 35.1591
R24187 a_2310_9029.t0 a_2310_9029.t1 35.2643
R24188 a_7105_9394.t0 a_7105_9394.n0 17.1718
R24189 a_7105_9394.n0 a_7105_9394.t1 9.7433
R24190 a_7105_9394.n0 a_7105_9394.t2 15.4943
R24191 a_4081_9294.t0 a_4081_9294.n0 8.76769
R24192 a_4081_9294.n0 a_4081_9294.t2 15.0661
R24193 a_4081_9294.n0 a_4081_9294.t1 5.94842
R24194 a_3508_9233.t0 a_3508_9233.n0 17.0005
R24195 a_3508_9233.n0 a_3508_9233.t1 18.2612
R24196 a_3508_9233.n0 a_3508_9233.t2 15.5529
R24197 a_3280_9093.t1 a_3280_9093.n0 17.5293
R24198 a_3280_9093.n0 a_3280_9093.t0 17.726
R24199 a_3280_9093.n0 a_3280_9093.t2 15.773
R24200 a_1178_9017.t1 a_1178_9017.n0 8.46601
R24201 a_1178_9017.n0 a_1178_9017.t2 9.03504
R24202 a_1178_9017.n0 a_1178_9017.t0 9.14806
R24203 a_2532_9360.t0 a_2532_9360.n1 17.3368
R24204 a_2532_9360.n0 a_2532_9360.t1 8.47322
R24205 a_2532_9360.n1 a_2532_9360.n0 0.103627
R24206 a_2532_9360.n0 a_2532_9360.t2 17.4516
R24207 a_2532_9360.n1 a_2532_9360.t3 15.0435
R24208 a_2430_9273.n0 a_2430_9273.t3 15.0005
R24209 a_2430_9273.t0 a_2430_9273.n0 17.9114
R24210 a_2430_9273.n1 a_2430_9273.t1 17.0005
R24211 a_2430_9273.n0 a_2430_9273.n1 0.655551
R24212 a_2430_9273.n1 a_2430_9273.t2 15.2176
R24213 a_2021_9334.t0 a_2021_9334.n2 17.1232
R24214 a_2021_9334.n2 a_2021_9334.n0 0.498937
R24215 a_2021_9334.n2 a_2021_9334.t1 18.4279
R24216 a_2021_9334.n0 a_2021_9334.n1 3.38952
R24217 a_2021_9334.n1 a_2021_9334.t3 18.3531
R24218 a_2021_9334.n1 a_2021_9334.t2 17.9378
R24219 a_2021_9334.n0 a_2021_9334.t4 15.4204
R24220 a_1735_9016.n0 a_1735_9016.t1 17.0005
R24221 a_1735_9016.t0 a_1735_9016.n0 18.3191
R24222 a_1735_9016.n1 a_1735_9016.t2 17.0005
R24223 a_1735_9016.n0 a_1735_9016.n1 3.28463
R24224 a_1735_9016.n1 a_1735_9016.t3 18.6222
R24225 a_1995_9239.t0 a_1995_9239.n1 17.2651
R24226 a_1995_9239.n1 a_1995_9239.t1 17.3352
R24227 a_1995_9239.n1 a_1995_9239.n0 0.948441
R24228 a_1995_9239.n0 a_1995_9239.t2 17.3305
R24229 a_1995_9239.n0 a_1995_9239.t3 15.4436
R24230 a_1279_9314.t1 a_1279_9314.n1 17.1443
R24231 a_1279_9314.n1 a_1279_9314.n0 0.743
R24232 a_1279_9314.n0 a_1279_9314.t0 8.65706
R24233 a_1279_9314.n0 a_1279_9314.t2 8.71106
R24234 a_1279_9314.n1 a_1279_9314.t3 15.731
R24235 a_n2042_972.t0 a_n2042_972.n0 9.01232
R24236 a_n2042_972.n0 a_n2042_972.t1 6.08418
R24237 a_n2042_972.n0 a_n2042_972.n15 22.3729
R24238 a_n2042_972.n15 a_n2042_972.n14 0.557571
R24239 a_n2042_972.n14 a_n2042_972.n13 4.56629
R24240 a_n2042_972.n13 a_n2042_972.n12 0.557571
R24241 a_n2042_972.n12 a_n2042_972.n11 4.56629
R24242 a_n2042_972.n11 a_n2042_972.n10 0.557571
R24243 a_n2042_972.n10 a_n2042_972.n9 4.56629
R24244 a_n2042_972.n9 a_n2042_972.n8 0.557571
R24245 a_n2042_972.n8 a_n2042_972.n7 4.56629
R24246 a_n2042_972.n7 a_n2042_972.n6 0.557571
R24247 a_n2042_972.n6 a_n2042_972.n5 4.56629
R24248 a_n2042_972.n5 a_n2042_972.n4 0.557571
R24249 a_n2042_972.n4 a_n2042_972.n3 4.56629
R24250 a_n2042_972.n3 a_n2042_972.n2 0.557571
R24251 a_n2042_972.n2 a_n2042_972.n1 4.56629
R24252 a_n2042_972.n1 a_n2042_972.t10 30.2193
R24253 a_n2042_972.n15 a_n2042_972.t9 31.6835
R24254 a_n2042_972.n14 a_n2042_972.t17 29.6622
R24255 a_n2042_972.n13 a_n2042_972.t8 31.6835
R24256 a_n2042_972.n12 a_n2042_972.t16 29.6622
R24257 a_n2042_972.n11 a_n2042_972.t7 31.6835
R24258 a_n2042_972.n10 a_n2042_972.t15 29.6622
R24259 a_n2042_972.n9 a_n2042_972.t6 31.6835
R24260 a_n2042_972.n8 a_n2042_972.t14 29.6622
R24261 a_n2042_972.n7 a_n2042_972.t5 31.6835
R24262 a_n2042_972.n6 a_n2042_972.t13 29.6622
R24263 a_n2042_972.n5 a_n2042_972.t4 31.6835
R24264 a_n2042_972.n4 a_n2042_972.t12 29.6622
R24265 a_n2042_972.n3 a_n2042_972.t3 31.6835
R24266 a_n2042_972.n2 a_n2042_972.t11 29.6622
R24267 a_n2042_972.n1 a_n2042_972.t2 31.6835
R24268 a_890_8998.t0 a_890_8998.n0 8.81393
R24269 a_890_8998.n0 a_890_8998.t2 15.4488
R24270 a_890_8998.n0 a_890_8998.t1 6.09623
R24271 a_585_9394.t0 a_585_9394.n0 17.1718
R24272 a_585_9394.n0 a_585_9394.t1 9.7433
R24273 a_585_9394.n0 a_585_9394.t2 15.4943
R24274 a_50643_9350.t9 a_50643_9350.n5 8.90498
R24275 a_50643_9350.n5 a_50643_9350.t5 10.0462
R24276 a_50643_9350.n5 a_50643_9350.n0 1.09706
R24277 a_50643_9350.n0 a_50643_9350.n4 1.09706
R24278 a_50643_9350.n4 a_50643_9350.t7 8.90498
R24279 a_50643_9350.n4 a_50643_9350.t4 10.0462
R24280 a_50643_9350.n0 a_50643_9350.n1 18.263
R24281 a_50643_9350.n3 a_50643_9350.t2 17.0005
R24282 a_50643_9350.n1 a_50643_9350.n3 1.37206
R24283 a_50643_9350.n3 a_50643_9350.t3 18.9255
R24284 a_50643_9350.n2 a_50643_9350.t1 17.0005
R24285 a_50643_9350.n1 a_50643_9350.n2 1.37206
R24286 a_50643_9350.n2 a_50643_9350.t0 18.9255
R24287 a_50643_9350.n1 a_50643_9350.t6 17.6708
R24288 a_50643_9350.n0 a_50643_9350.t8 8.81561
R24289 a_44123_9350.t9 a_44123_9350.n5 8.90498
R24290 a_44123_9350.n5 a_44123_9350.t3 10.0462
R24291 a_44123_9350.n5 a_44123_9350.n0 1.09706
R24292 a_44123_9350.n0 a_44123_9350.n4 1.09706
R24293 a_44123_9350.n4 a_44123_9350.t7 8.90498
R24294 a_44123_9350.n4 a_44123_9350.t2 10.0462
R24295 a_44123_9350.n0 a_44123_9350.n1 18.263
R24296 a_44123_9350.n3 a_44123_9350.t6 17.0005
R24297 a_44123_9350.n1 a_44123_9350.n3 1.37206
R24298 a_44123_9350.n3 a_44123_9350.t1 18.9255
R24299 a_44123_9350.n2 a_44123_9350.t4 17.0005
R24300 a_44123_9350.n1 a_44123_9350.n2 1.37206
R24301 a_44123_9350.n2 a_44123_9350.t0 18.9255
R24302 a_44123_9350.n1 a_44123_9350.t5 17.6708
R24303 a_44123_9350.n0 a_44123_9350.t8 8.81561
R24304 a_37603_9350.t9 a_37603_9350.n5 8.90498
R24305 a_37603_9350.n5 a_37603_9350.t3 10.0462
R24306 a_37603_9350.n5 a_37603_9350.n0 1.09706
R24307 a_37603_9350.n0 a_37603_9350.n4 1.09706
R24308 a_37603_9350.n4 a_37603_9350.t7 8.90498
R24309 a_37603_9350.n4 a_37603_9350.t2 10.0462
R24310 a_37603_9350.n0 a_37603_9350.n1 18.263
R24311 a_37603_9350.n3 a_37603_9350.t5 17.0005
R24312 a_37603_9350.n1 a_37603_9350.n3 1.37206
R24313 a_37603_9350.n3 a_37603_9350.t1 18.9255
R24314 a_37603_9350.n2 a_37603_9350.t4 17.0005
R24315 a_37603_9350.n1 a_37603_9350.n2 1.37206
R24316 a_37603_9350.n2 a_37603_9350.t0 18.9255
R24317 a_37603_9350.n1 a_37603_9350.t6 17.6708
R24318 a_37603_9350.n0 a_37603_9350.t8 8.81561
R24319 a_31083_9350.t9 a_31083_9350.n5 8.90498
R24320 a_31083_9350.n5 a_31083_9350.t3 10.0462
R24321 a_31083_9350.n5 a_31083_9350.n0 1.09706
R24322 a_31083_9350.n0 a_31083_9350.n4 1.09706
R24323 a_31083_9350.n4 a_31083_9350.t7 8.90498
R24324 a_31083_9350.n4 a_31083_9350.t2 10.0462
R24325 a_31083_9350.n0 a_31083_9350.n1 18.263
R24326 a_31083_9350.n3 a_31083_9350.t6 17.0005
R24327 a_31083_9350.n1 a_31083_9350.n3 1.37206
R24328 a_31083_9350.n3 a_31083_9350.t1 18.9255
R24329 a_31083_9350.n2 a_31083_9350.t4 17.0005
R24330 a_31083_9350.n1 a_31083_9350.n2 1.37206
R24331 a_31083_9350.n2 a_31083_9350.t0 18.9255
R24332 a_31083_9350.n1 a_31083_9350.t5 17.6708
R24333 a_31083_9350.n0 a_31083_9350.t8 8.81561
R24334 a_24563_9350.t9 a_24563_9350.n5 8.90498
R24335 a_24563_9350.n5 a_24563_9350.t3 10.0462
R24336 a_24563_9350.n5 a_24563_9350.n0 1.09706
R24337 a_24563_9350.n0 a_24563_9350.n4 1.09706
R24338 a_24563_9350.n4 a_24563_9350.t7 8.90498
R24339 a_24563_9350.n4 a_24563_9350.t2 10.0462
R24340 a_24563_9350.n0 a_24563_9350.n1 18.263
R24341 a_24563_9350.n3 a_24563_9350.t6 17.0005
R24342 a_24563_9350.n1 a_24563_9350.n3 1.37206
R24343 a_24563_9350.n3 a_24563_9350.t1 18.9255
R24344 a_24563_9350.n2 a_24563_9350.t4 17.0005
R24345 a_24563_9350.n1 a_24563_9350.n2 1.37206
R24346 a_24563_9350.n2 a_24563_9350.t0 18.9255
R24347 a_24563_9350.n1 a_24563_9350.t5 17.6708
R24348 a_24563_9350.n0 a_24563_9350.t8 8.81561
R24349 a_18043_9350.t9 a_18043_9350.n5 8.90498
R24350 a_18043_9350.n5 a_18043_9350.t3 10.0462
R24351 a_18043_9350.n5 a_18043_9350.n0 1.09706
R24352 a_18043_9350.n0 a_18043_9350.n4 1.09706
R24353 a_18043_9350.n4 a_18043_9350.t7 8.90498
R24354 a_18043_9350.n4 a_18043_9350.t2 10.0462
R24355 a_18043_9350.n0 a_18043_9350.n1 18.263
R24356 a_18043_9350.n3 a_18043_9350.t5 17.0005
R24357 a_18043_9350.n1 a_18043_9350.n3 1.37206
R24358 a_18043_9350.n3 a_18043_9350.t1 18.9255
R24359 a_18043_9350.n2 a_18043_9350.t4 17.0005
R24360 a_18043_9350.n1 a_18043_9350.n2 1.37206
R24361 a_18043_9350.n2 a_18043_9350.t0 18.9255
R24362 a_18043_9350.n1 a_18043_9350.t6 17.6708
R24363 a_18043_9350.n0 a_18043_9350.t8 8.81561
R24364 a_11523_9350.t9 a_11523_9350.n5 8.90498
R24365 a_11523_9350.n5 a_11523_9350.t3 10.0462
R24366 a_11523_9350.n5 a_11523_9350.n0 1.09706
R24367 a_11523_9350.n0 a_11523_9350.n4 1.09706
R24368 a_11523_9350.n4 a_11523_9350.t7 8.90498
R24369 a_11523_9350.n4 a_11523_9350.t2 10.0462
R24370 a_11523_9350.n0 a_11523_9350.n1 18.263
R24371 a_11523_9350.n3 a_11523_9350.t5 17.0005
R24372 a_11523_9350.n1 a_11523_9350.n3 1.37206
R24373 a_11523_9350.n3 a_11523_9350.t1 18.9255
R24374 a_11523_9350.n2 a_11523_9350.t4 17.0005
R24375 a_11523_9350.n1 a_11523_9350.n2 1.37206
R24376 a_11523_9350.n2 a_11523_9350.t0 18.9255
R24377 a_11523_9350.n1 a_11523_9350.t6 17.6708
R24378 a_11523_9350.n0 a_11523_9350.t8 8.81561
R24379 a_5003_9350.t9 a_5003_9350.n5 8.90498
R24380 a_5003_9350.n5 a_5003_9350.t3 10.0462
R24381 a_5003_9350.n5 a_5003_9350.n0 1.09706
R24382 a_5003_9350.n0 a_5003_9350.n4 1.09706
R24383 a_5003_9350.n4 a_5003_9350.t7 8.90498
R24384 a_5003_9350.n4 a_5003_9350.t2 10.0462
R24385 a_5003_9350.n0 a_5003_9350.n1 18.263
R24386 a_5003_9350.n3 a_5003_9350.t5 17.0005
R24387 a_5003_9350.n1 a_5003_9350.n3 1.37206
R24388 a_5003_9350.n3 a_5003_9350.t1 18.9255
R24389 a_5003_9350.n2 a_5003_9350.t4 17.0005
R24390 a_5003_9350.n1 a_5003_9350.n2 1.37206
R24391 a_5003_9350.n2 a_5003_9350.t0 18.9255
R24392 a_5003_9350.n1 a_5003_9350.t6 17.6708
R24393 a_5003_9350.n0 a_5003_9350.t8 8.81561
R24394 a_49938_9314.t0 a_49938_9314.n0 8.53521
R24395 a_49938_9314.n0 a_49938_9314.t2 16.6582
R24396 a_49938_9314.n0 a_49938_9314.t1 6.13582
R24397 a_43418_9314.t0 a_43418_9314.n0 8.53521
R24398 a_43418_9314.n0 a_43418_9314.t2 16.6582
R24399 a_43418_9314.n0 a_43418_9314.t1 6.13582
R24400 a_49517_9294.t0 a_49517_9294.n0 8.53379
R24401 a_49517_9294.n0 a_49517_9294.t1 6.23476
R24402 a_49517_9294.n0 a_49517_9294.t2 35.9286
R24403 a_36898_9314.t0 a_36898_9314.n0 8.53521
R24404 a_36898_9314.n0 a_36898_9314.t2 16.6582
R24405 a_36898_9314.n0 a_36898_9314.t1 6.13582
R24406 a_42997_9294.t0 a_42997_9294.n0 8.53379
R24407 a_42997_9294.n0 a_42997_9294.t1 6.23476
R24408 a_42997_9294.n0 a_42997_9294.t2 35.9286
R24409 a_30378_9314.t0 a_30378_9314.n0 8.53521
R24410 a_30378_9314.n0 a_30378_9314.t2 16.6582
R24411 a_30378_9314.n0 a_30378_9314.t1 6.13582
R24412 a_36477_9294.t0 a_36477_9294.n0 8.53379
R24413 a_36477_9294.n0 a_36477_9294.t1 6.23476
R24414 a_36477_9294.n0 a_36477_9294.t2 35.9286
R24415 a_23858_9314.t0 a_23858_9314.n0 8.53521
R24416 a_23858_9314.n0 a_23858_9314.t2 16.6582
R24417 a_23858_9314.n0 a_23858_9314.t1 6.13582
R24418 a_29957_9294.t0 a_29957_9294.n0 8.53379
R24419 a_29957_9294.n0 a_29957_9294.t1 6.23476
R24420 a_29957_9294.n0 a_29957_9294.t2 35.9286
R24421 a_17338_9314.t0 a_17338_9314.n0 8.53521
R24422 a_17338_9314.n0 a_17338_9314.t2 16.6582
R24423 a_17338_9314.n0 a_17338_9314.t1 6.13582
R24424 a_23437_9294.t0 a_23437_9294.n0 8.53379
R24425 a_23437_9294.n0 a_23437_9294.t1 6.23476
R24426 a_23437_9294.n0 a_23437_9294.t2 35.9286
R24427 a_10818_9314.t0 a_10818_9314.n0 8.53521
R24428 a_10818_9314.n0 a_10818_9314.t2 16.6582
R24429 a_10818_9314.n0 a_10818_9314.t1 6.13582
R24430 a_16917_9294.t0 a_16917_9294.n0 8.53379
R24431 a_16917_9294.n0 a_16917_9294.t1 6.23476
R24432 a_16917_9294.n0 a_16917_9294.t2 35.9286
R24433 a_4298_9314.t0 a_4298_9314.n0 8.53521
R24434 a_4298_9314.n0 a_4298_9314.t2 16.6582
R24435 a_4298_9314.n0 a_4298_9314.t1 6.13582
R24436 a_10397_9294.t0 a_10397_9294.n0 8.53379
R24437 a_10397_9294.n0 a_10397_9294.t1 6.23476
R24438 a_10397_9294.n0 a_10397_9294.t2 35.9286
R24439 a_3877_9294.t0 a_3877_9294.n0 8.53379
R24440 a_3877_9294.n0 a_3877_9294.t1 6.23476
R24441 a_3877_9294.n0 a_3877_9294.t2 35.9286
R24442 a_50809_11890.t3 a_50809_11890.n0 8.8328
R24443 a_50809_11890.n2 a_50809_11890.n3 1.14175
R24444 a_50809_11890.n1 a_50809_11890.n2 1.14175
R24445 a_50809_11890.n0 a_50809_11890.n1 1.14175
R24446 a_50809_11890.n3 a_50809_11890.t0 8.8328
R24447 a_50809_11890.n3 a_50809_11890.t6 8.8328
R24448 a_50809_11890.n2 a_50809_11890.t1 8.8328
R24449 a_50809_11890.n2 a_50809_11890.t7 8.8318
R24450 a_50809_11890.n1 a_50809_11890.t2 8.8328
R24451 a_50809_11890.n1 a_50809_11890.t5 8.8318
R24452 a_50809_11890.n0 a_50809_11890.t4 8.8318
R24453 a_48826_11893.t0 a_48826_11893.t1 35.1591
R24454 a_47950_11829.t0 a_47950_11829.t1 35.2643
R24455 a_49721_12094.t0 a_49721_12094.n0 8.76769
R24456 a_49721_12094.n0 a_49721_12094.t2 15.0661
R24457 a_49721_12094.n0 a_49721_12094.t1 5.94842
R24458 a_49148_12033.n0 a_49148_12033.t1 17.0005
R24459 a_49148_12033.t0 a_49148_12033.n0 18.2612
R24460 a_49148_12033.n0 a_49148_12033.t2 15.5529
R24461 a_48920_11893.t1 a_48920_11893.n0 17.5293
R24462 a_48920_11893.n0 a_48920_11893.t0 17.726
R24463 a_48920_11893.n0 a_48920_11893.t2 15.773
R24464 a_46818_11817.t1 a_46818_11817.n0 8.46601
R24465 a_46818_11817.n0 a_46818_11817.t2 9.03504
R24466 a_46818_11817.n0 a_46818_11817.t0 9.14806
R24467 a_48172_12160.t0 a_48172_12160.n1 17.3368
R24468 a_48172_12160.n0 a_48172_12160.t1 8.47322
R24469 a_48172_12160.n1 a_48172_12160.n0 0.103627
R24470 a_48172_12160.n0 a_48172_12160.t2 17.4516
R24471 a_48172_12160.n1 a_48172_12160.t3 15.0435
R24472 a_48070_12073.n0 a_48070_12073.t3 15.0005
R24473 a_48070_12073.t0 a_48070_12073.n0 17.9114
R24474 a_48070_12073.n1 a_48070_12073.t1 17.0005
R24475 a_48070_12073.n0 a_48070_12073.n1 0.655551
R24476 a_48070_12073.n1 a_48070_12073.t2 15.2176
R24477 a_47661_12134.t0 a_47661_12134.n2 17.1232
R24478 a_47661_12134.n2 a_47661_12134.n0 0.498937
R24479 a_47661_12134.n2 a_47661_12134.t1 18.4279
R24480 a_47661_12134.n0 a_47661_12134.n1 3.38952
R24481 a_47661_12134.n1 a_47661_12134.t3 18.3531
R24482 a_47661_12134.n1 a_47661_12134.t2 17.9378
R24483 a_47661_12134.n0 a_47661_12134.t4 15.4204
R24484 a_47375_11816.n0 a_47375_11816.t1 17.0005
R24485 a_47375_11816.t0 a_47375_11816.n0 18.3191
R24486 a_47375_11816.n1 a_47375_11816.t2 17.0005
R24487 a_47375_11816.n0 a_47375_11816.n1 3.28463
R24488 a_47375_11816.n1 a_47375_11816.t3 18.6222
R24489 a_47635_12039.t0 a_47635_12039.n1 17.3352
R24490 a_47635_12039.n1 a_47635_12039.t1 17.2651
R24491 a_47635_12039.n1 a_47635_12039.n0 0.948441
R24492 a_47635_12039.n0 a_47635_12039.t2 17.3305
R24493 a_47635_12039.n0 a_47635_12039.t3 15.4436
R24494 a_46919_12114.t1 a_46919_12114.n1 17.1443
R24495 a_46919_12114.n1 a_46919_12114.n0 0.743
R24496 a_46919_12114.n0 a_46919_12114.t0 8.65706
R24497 a_46919_12114.n0 a_46919_12114.t2 8.71106
R24498 a_46919_12114.n1 a_46919_12114.t3 15.731
R24499 a_46530_11798.t0 a_46530_11798.n0 8.81393
R24500 a_46530_11798.n0 a_46530_11798.t2 15.4488
R24501 a_46530_11798.n0 a_46530_11798.t1 6.09623
R24502 a_44289_11890.t3 a_44289_11890.n0 8.8328
R24503 a_44289_11890.n2 a_44289_11890.n3 1.14175
R24504 a_44289_11890.n1 a_44289_11890.n2 1.14175
R24505 a_44289_11890.n0 a_44289_11890.n1 1.14175
R24506 a_44289_11890.n3 a_44289_11890.t0 8.8328
R24507 a_44289_11890.n3 a_44289_11890.t7 8.8328
R24508 a_44289_11890.n2 a_44289_11890.t1 8.8328
R24509 a_44289_11890.n2 a_44289_11890.t4 8.8318
R24510 a_44289_11890.n1 a_44289_11890.t2 8.8328
R24511 a_44289_11890.n1 a_44289_11890.t5 8.8318
R24512 a_44289_11890.n0 a_44289_11890.t6 8.8318
R24513 a_42306_11893.t0 a_42306_11893.t1 35.1591
R24514 a_41430_11829.t0 a_41430_11829.t1 35.2643
R24515 a_46225_12194.t0 a_46225_12194.n0 17.1718
R24516 a_46225_12194.n0 a_46225_12194.t1 9.7433
R24517 a_46225_12194.n0 a_46225_12194.t2 15.4943
R24518 a_43201_12094.t0 a_43201_12094.n0 8.76769
R24519 a_43201_12094.n0 a_43201_12094.t2 15.0661
R24520 a_43201_12094.n0 a_43201_12094.t1 5.94842
R24521 a_42628_12033.n0 a_42628_12033.t1 17.0005
R24522 a_42628_12033.t0 a_42628_12033.n0 18.2612
R24523 a_42628_12033.n0 a_42628_12033.t2 15.5529
R24524 a_42400_11893.t1 a_42400_11893.n0 17.5293
R24525 a_42400_11893.n0 a_42400_11893.t0 17.726
R24526 a_42400_11893.n0 a_42400_11893.t2 15.773
R24527 a_40298_11817.t1 a_40298_11817.n0 8.46601
R24528 a_40298_11817.n0 a_40298_11817.t2 9.03504
R24529 a_40298_11817.n0 a_40298_11817.t0 9.14806
R24530 a_41652_12160.t0 a_41652_12160.n1 17.3368
R24531 a_41652_12160.n0 a_41652_12160.t1 8.47322
R24532 a_41652_12160.n1 a_41652_12160.n0 0.103627
R24533 a_41652_12160.n0 a_41652_12160.t2 17.4516
R24534 a_41652_12160.n1 a_41652_12160.t3 15.0435
R24535 a_41550_12073.n0 a_41550_12073.t3 15.0005
R24536 a_41550_12073.t0 a_41550_12073.n0 17.9114
R24537 a_41550_12073.n1 a_41550_12073.t1 17.0005
R24538 a_41550_12073.n0 a_41550_12073.n1 0.655551
R24539 a_41550_12073.n1 a_41550_12073.t2 15.2176
R24540 a_41141_12134.t0 a_41141_12134.n2 17.1232
R24541 a_41141_12134.n2 a_41141_12134.n0 0.498937
R24542 a_41141_12134.n2 a_41141_12134.t1 18.4279
R24543 a_41141_12134.n0 a_41141_12134.n1 3.38952
R24544 a_41141_12134.n1 a_41141_12134.t2 18.3531
R24545 a_41141_12134.n1 a_41141_12134.t3 17.9378
R24546 a_41141_12134.n0 a_41141_12134.t4 15.4204
R24547 a_40855_11816.n0 a_40855_11816.t1 17.0005
R24548 a_40855_11816.t0 a_40855_11816.n0 18.3191
R24549 a_40855_11816.n1 a_40855_11816.t3 17.0005
R24550 a_40855_11816.n0 a_40855_11816.n1 3.28463
R24551 a_40855_11816.n1 a_40855_11816.t2 18.6222
R24552 a_41115_12039.t0 a_41115_12039.n1 17.3352
R24553 a_41115_12039.n1 a_41115_12039.t1 17.2651
R24554 a_41115_12039.n1 a_41115_12039.n0 0.948441
R24555 a_41115_12039.n0 a_41115_12039.t2 17.3305
R24556 a_41115_12039.n0 a_41115_12039.t3 15.4436
R24557 a_40399_12114.t2 a_40399_12114.n1 17.1443
R24558 a_40399_12114.n1 a_40399_12114.n0 0.743
R24559 a_40399_12114.n0 a_40399_12114.t0 8.65706
R24560 a_40399_12114.n0 a_40399_12114.t1 8.71106
R24561 a_40399_12114.n1 a_40399_12114.t3 15.731
R24562 a_40010_11798.t0 a_40010_11798.n0 8.81393
R24563 a_40010_11798.n0 a_40010_11798.t2 15.4488
R24564 a_40010_11798.n0 a_40010_11798.t1 6.09623
R24565 a_37769_11890.t3 a_37769_11890.n0 8.8328
R24566 a_37769_11890.n2 a_37769_11890.n3 1.14175
R24567 a_37769_11890.n1 a_37769_11890.n2 1.14175
R24568 a_37769_11890.n0 a_37769_11890.n1 1.14175
R24569 a_37769_11890.n3 a_37769_11890.t0 8.8328
R24570 a_37769_11890.n3 a_37769_11890.t5 8.8328
R24571 a_37769_11890.n2 a_37769_11890.t1 8.8328
R24572 a_37769_11890.n2 a_37769_11890.t6 8.8318
R24573 a_37769_11890.n1 a_37769_11890.t2 8.8328
R24574 a_37769_11890.n1 a_37769_11890.t7 8.8318
R24575 a_37769_11890.n0 a_37769_11890.t4 8.8318
R24576 a_35786_11893.t0 a_35786_11893.t1 35.1591
R24577 a_34910_11829.t0 a_34910_11829.t1 35.2643
R24578 a_39705_12194.t0 a_39705_12194.n0 17.1718
R24579 a_39705_12194.n0 a_39705_12194.t1 9.7433
R24580 a_39705_12194.n0 a_39705_12194.t2 15.4943
R24581 a_36681_12094.t0 a_36681_12094.n0 8.76769
R24582 a_36681_12094.n0 a_36681_12094.t2 15.0661
R24583 a_36681_12094.n0 a_36681_12094.t1 5.94842
R24584 a_36108_12033.n0 a_36108_12033.t1 17.0005
R24585 a_36108_12033.t0 a_36108_12033.n0 18.2612
R24586 a_36108_12033.n0 a_36108_12033.t2 15.5529
R24587 a_35880_11893.t1 a_35880_11893.n0 17.5293
R24588 a_35880_11893.n0 a_35880_11893.t0 17.726
R24589 a_35880_11893.n0 a_35880_11893.t2 15.773
R24590 a_33778_11817.t1 a_33778_11817.n0 8.46601
R24591 a_33778_11817.n0 a_33778_11817.t2 9.03504
R24592 a_33778_11817.n0 a_33778_11817.t0 9.14806
R24593 a_35132_12160.t0 a_35132_12160.n1 17.3368
R24594 a_35132_12160.n0 a_35132_12160.t1 8.47322
R24595 a_35132_12160.n1 a_35132_12160.n0 0.103627
R24596 a_35132_12160.n0 a_35132_12160.t2 17.4516
R24597 a_35132_12160.n1 a_35132_12160.t3 15.0435
R24598 a_35030_12073.n0 a_35030_12073.t3 15.0005
R24599 a_35030_12073.t0 a_35030_12073.n0 17.9114
R24600 a_35030_12073.n1 a_35030_12073.t1 17.0005
R24601 a_35030_12073.n0 a_35030_12073.n1 0.655551
R24602 a_35030_12073.n1 a_35030_12073.t2 15.2176
R24603 a_34621_12134.t0 a_34621_12134.n2 17.1232
R24604 a_34621_12134.n2 a_34621_12134.n0 0.498937
R24605 a_34621_12134.n2 a_34621_12134.t1 18.4279
R24606 a_34621_12134.n0 a_34621_12134.n1 3.38952
R24607 a_34621_12134.n1 a_34621_12134.t2 18.3531
R24608 a_34621_12134.n1 a_34621_12134.t3 17.9378
R24609 a_34621_12134.n0 a_34621_12134.t4 15.4204
R24610 a_34335_11816.n0 a_34335_11816.t1 17.0005
R24611 a_34335_11816.t0 a_34335_11816.n0 18.3191
R24612 a_34335_11816.n1 a_34335_11816.t3 17.0005
R24613 a_34335_11816.n0 a_34335_11816.n1 3.28463
R24614 a_34335_11816.n1 a_34335_11816.t2 18.6222
R24615 a_34595_12039.t0 a_34595_12039.n1 17.3352
R24616 a_34595_12039.n1 a_34595_12039.t1 17.2651
R24617 a_34595_12039.n1 a_34595_12039.n0 0.948441
R24618 a_34595_12039.n0 a_34595_12039.t2 17.3305
R24619 a_34595_12039.n0 a_34595_12039.t3 15.4436
R24620 a_33879_12114.t1 a_33879_12114.n1 17.1443
R24621 a_33879_12114.n1 a_33879_12114.n0 0.743
R24622 a_33879_12114.n0 a_33879_12114.t0 8.65706
R24623 a_33879_12114.n0 a_33879_12114.t2 8.71106
R24624 a_33879_12114.n1 a_33879_12114.t3 15.731
R24625 a_33490_11798.t0 a_33490_11798.n0 8.81393
R24626 a_33490_11798.n0 a_33490_11798.t2 15.4488
R24627 a_33490_11798.n0 a_33490_11798.t1 6.09623
R24628 a_31249_11890.t3 a_31249_11890.n0 8.8328
R24629 a_31249_11890.n2 a_31249_11890.n3 1.14175
R24630 a_31249_11890.n1 a_31249_11890.n2 1.14175
R24631 a_31249_11890.n0 a_31249_11890.n1 1.14175
R24632 a_31249_11890.n3 a_31249_11890.t0 8.8328
R24633 a_31249_11890.n3 a_31249_11890.t4 8.8328
R24634 a_31249_11890.n2 a_31249_11890.t1 8.8328
R24635 a_31249_11890.n2 a_31249_11890.t5 8.8318
R24636 a_31249_11890.n1 a_31249_11890.t2 8.8328
R24637 a_31249_11890.n1 a_31249_11890.t7 8.8318
R24638 a_31249_11890.n0 a_31249_11890.t6 8.8318
R24639 a_29266_11893.t0 a_29266_11893.t1 35.1591
R24640 a_28390_11829.t0 a_28390_11829.t1 35.2643
R24641 a_33185_12194.t0 a_33185_12194.n0 17.1718
R24642 a_33185_12194.n0 a_33185_12194.t1 9.7433
R24643 a_33185_12194.n0 a_33185_12194.t2 15.4943
R24644 a_30161_12094.t0 a_30161_12094.n0 8.76769
R24645 a_30161_12094.n0 a_30161_12094.t2 15.0661
R24646 a_30161_12094.n0 a_30161_12094.t1 5.94842
R24647 a_29588_12033.n0 a_29588_12033.t1 17.0005
R24648 a_29588_12033.t0 a_29588_12033.n0 18.2612
R24649 a_29588_12033.n0 a_29588_12033.t2 15.5529
R24650 a_29360_11893.t1 a_29360_11893.n0 17.5293
R24651 a_29360_11893.n0 a_29360_11893.t0 17.726
R24652 a_29360_11893.n0 a_29360_11893.t2 15.773
R24653 a_27258_11817.t1 a_27258_11817.n0 8.46601
R24654 a_27258_11817.n0 a_27258_11817.t2 9.03504
R24655 a_27258_11817.n0 a_27258_11817.t0 9.14806
R24656 a_28612_12160.t0 a_28612_12160.n1 17.3368
R24657 a_28612_12160.n0 a_28612_12160.t1 8.47322
R24658 a_28612_12160.n1 a_28612_12160.n0 0.103627
R24659 a_28612_12160.n0 a_28612_12160.t2 17.4516
R24660 a_28612_12160.n1 a_28612_12160.t3 15.0435
R24661 a_28510_12073.n0 a_28510_12073.t3 15.0005
R24662 a_28510_12073.t0 a_28510_12073.n0 17.9114
R24663 a_28510_12073.n1 a_28510_12073.t1 17.0005
R24664 a_28510_12073.n0 a_28510_12073.n1 0.655551
R24665 a_28510_12073.n1 a_28510_12073.t2 15.2176
R24666 a_28101_12134.t0 a_28101_12134.n2 17.1232
R24667 a_28101_12134.n2 a_28101_12134.n0 0.498937
R24668 a_28101_12134.n2 a_28101_12134.t1 18.4279
R24669 a_28101_12134.n0 a_28101_12134.n1 3.38952
R24670 a_28101_12134.n1 a_28101_12134.t3 18.3531
R24671 a_28101_12134.n1 a_28101_12134.t2 17.9378
R24672 a_28101_12134.n0 a_28101_12134.t4 15.4204
R24673 a_27815_11816.n0 a_27815_11816.t1 17.0005
R24674 a_27815_11816.t0 a_27815_11816.n0 18.3191
R24675 a_27815_11816.n1 a_27815_11816.t2 17.0005
R24676 a_27815_11816.n0 a_27815_11816.n1 3.28463
R24677 a_27815_11816.n1 a_27815_11816.t3 18.6222
R24678 a_28075_12039.t0 a_28075_12039.n1 17.2651
R24679 a_28075_12039.n1 a_28075_12039.t1 17.3352
R24680 a_28075_12039.n1 a_28075_12039.n0 0.948441
R24681 a_28075_12039.n0 a_28075_12039.t2 17.3305
R24682 a_28075_12039.n0 a_28075_12039.t3 15.4436
R24683 a_27359_12114.t1 a_27359_12114.n1 17.1443
R24684 a_27359_12114.n1 a_27359_12114.n0 0.743
R24685 a_27359_12114.n0 a_27359_12114.t0 8.65706
R24686 a_27359_12114.n0 a_27359_12114.t2 8.71106
R24687 a_27359_12114.n1 a_27359_12114.t3 15.731
R24688 a_26970_11798.t0 a_26970_11798.n0 8.81393
R24689 a_26970_11798.n0 a_26970_11798.t2 15.4488
R24690 a_26970_11798.n0 a_26970_11798.t1 6.09623
R24691 a_24729_11890.t3 a_24729_11890.n0 8.8328
R24692 a_24729_11890.n2 a_24729_11890.n3 1.14175
R24693 a_24729_11890.n1 a_24729_11890.n2 1.14175
R24694 a_24729_11890.n0 a_24729_11890.n1 1.14175
R24695 a_24729_11890.n3 a_24729_11890.t0 8.8328
R24696 a_24729_11890.n3 a_24729_11890.t5 8.8328
R24697 a_24729_11890.n2 a_24729_11890.t1 8.8328
R24698 a_24729_11890.n2 a_24729_11890.t6 8.8318
R24699 a_24729_11890.n1 a_24729_11890.t2 8.8328
R24700 a_24729_11890.n1 a_24729_11890.t7 8.8318
R24701 a_24729_11890.n0 a_24729_11890.t4 8.8318
R24702 a_22746_11893.t0 a_22746_11893.t1 35.1591
R24703 a_21870_11829.t0 a_21870_11829.t1 35.2643
R24704 a_26665_12194.t0 a_26665_12194.n0 17.1718
R24705 a_26665_12194.n0 a_26665_12194.t1 9.7433
R24706 a_26665_12194.n0 a_26665_12194.t2 15.4943
R24707 a_23641_12094.t0 a_23641_12094.n0 8.76769
R24708 a_23641_12094.n0 a_23641_12094.t2 15.0661
R24709 a_23641_12094.n0 a_23641_12094.t1 5.94842
R24710 a_23068_12033.n0 a_23068_12033.t1 17.0005
R24711 a_23068_12033.t0 a_23068_12033.n0 18.2612
R24712 a_23068_12033.n0 a_23068_12033.t2 15.5529
R24713 a_22840_11893.t1 a_22840_11893.n0 17.5293
R24714 a_22840_11893.n0 a_22840_11893.t0 17.726
R24715 a_22840_11893.n0 a_22840_11893.t2 15.773
R24716 a_20738_11817.t1 a_20738_11817.n0 8.46601
R24717 a_20738_11817.n0 a_20738_11817.t2 9.03504
R24718 a_20738_11817.n0 a_20738_11817.t0 9.14806
R24719 a_22092_12160.t0 a_22092_12160.n1 17.3368
R24720 a_22092_12160.n0 a_22092_12160.t1 8.47322
R24721 a_22092_12160.n1 a_22092_12160.n0 0.103627
R24722 a_22092_12160.n0 a_22092_12160.t2 17.4516
R24723 a_22092_12160.n1 a_22092_12160.t3 15.0435
R24724 a_21990_12073.n0 a_21990_12073.t3 15.0005
R24725 a_21990_12073.t0 a_21990_12073.n0 17.9114
R24726 a_21990_12073.n1 a_21990_12073.t1 17.0005
R24727 a_21990_12073.n0 a_21990_12073.n1 0.655551
R24728 a_21990_12073.n1 a_21990_12073.t2 15.2176
R24729 a_21581_12134.t0 a_21581_12134.n2 17.1232
R24730 a_21581_12134.n2 a_21581_12134.n0 0.498937
R24731 a_21581_12134.n2 a_21581_12134.t1 18.4279
R24732 a_21581_12134.n0 a_21581_12134.n1 3.38952
R24733 a_21581_12134.n1 a_21581_12134.t3 18.3531
R24734 a_21581_12134.n1 a_21581_12134.t2 17.9378
R24735 a_21581_12134.n0 a_21581_12134.t4 15.4204
R24736 a_21295_11816.n0 a_21295_11816.t1 17.0005
R24737 a_21295_11816.t0 a_21295_11816.n0 18.3191
R24738 a_21295_11816.n1 a_21295_11816.t2 17.0005
R24739 a_21295_11816.n0 a_21295_11816.n1 3.28463
R24740 a_21295_11816.n1 a_21295_11816.t3 18.6222
R24741 a_21555_12039.t0 a_21555_12039.n1 17.2651
R24742 a_21555_12039.n1 a_21555_12039.t1 17.3352
R24743 a_21555_12039.n1 a_21555_12039.n0 0.948441
R24744 a_21555_12039.n0 a_21555_12039.t2 17.3305
R24745 a_21555_12039.n0 a_21555_12039.t3 15.4436
R24746 a_20839_12114.t1 a_20839_12114.n1 17.1443
R24747 a_20839_12114.n1 a_20839_12114.n0 0.743
R24748 a_20839_12114.n0 a_20839_12114.t0 8.65706
R24749 a_20839_12114.n0 a_20839_12114.t2 8.71106
R24750 a_20839_12114.n1 a_20839_12114.t3 15.731
R24751 a_20450_11798.t0 a_20450_11798.n0 8.81393
R24752 a_20450_11798.n0 a_20450_11798.t2 15.4488
R24753 a_20450_11798.n0 a_20450_11798.t1 6.09623
R24754 a_18209_11890.t3 a_18209_11890.n0 8.8328
R24755 a_18209_11890.n2 a_18209_11890.n3 1.14175
R24756 a_18209_11890.n1 a_18209_11890.n2 1.14175
R24757 a_18209_11890.n0 a_18209_11890.n1 1.14175
R24758 a_18209_11890.n3 a_18209_11890.t0 8.8328
R24759 a_18209_11890.n3 a_18209_11890.t4 8.8328
R24760 a_18209_11890.n2 a_18209_11890.t1 8.8328
R24761 a_18209_11890.n2 a_18209_11890.t5 8.8318
R24762 a_18209_11890.n1 a_18209_11890.t2 8.8328
R24763 a_18209_11890.n1 a_18209_11890.t7 8.8318
R24764 a_18209_11890.n0 a_18209_11890.t6 8.8318
R24765 a_16226_11893.t0 a_16226_11893.t1 35.1591
R24766 a_15350_11829.t0 a_15350_11829.t1 35.2643
R24767 a_20145_12194.t0 a_20145_12194.n0 17.1718
R24768 a_20145_12194.n0 a_20145_12194.t1 9.7433
R24769 a_20145_12194.n0 a_20145_12194.t2 15.4943
R24770 a_17121_12094.t0 a_17121_12094.n0 8.76769
R24771 a_17121_12094.n0 a_17121_12094.t2 15.0661
R24772 a_17121_12094.n0 a_17121_12094.t1 5.94842
R24773 a_16548_12033.n0 a_16548_12033.t1 17.0005
R24774 a_16548_12033.t0 a_16548_12033.n0 18.2612
R24775 a_16548_12033.n0 a_16548_12033.t2 15.5529
R24776 a_16320_11893.t1 a_16320_11893.n0 17.5293
R24777 a_16320_11893.n0 a_16320_11893.t0 17.726
R24778 a_16320_11893.n0 a_16320_11893.t2 15.773
R24779 a_14218_11817.n0 a_14218_11817.t0 8.46601
R24780 a_14218_11817.t1 a_14218_11817.n0 9.03504
R24781 a_14218_11817.n0 a_14218_11817.t2 9.14806
R24782 a_15572_12160.t0 a_15572_12160.n1 17.3368
R24783 a_15572_12160.n0 a_15572_12160.t1 8.47322
R24784 a_15572_12160.n1 a_15572_12160.n0 0.103627
R24785 a_15572_12160.n0 a_15572_12160.t2 17.4516
R24786 a_15572_12160.n1 a_15572_12160.t3 15.0435
R24787 a_15470_12073.n0 a_15470_12073.t3 15.0005
R24788 a_15470_12073.t0 a_15470_12073.n0 17.9114
R24789 a_15470_12073.n1 a_15470_12073.t1 17.0005
R24790 a_15470_12073.n0 a_15470_12073.n1 0.655551
R24791 a_15470_12073.n1 a_15470_12073.t2 15.2176
R24792 a_15061_12134.t0 a_15061_12134.n2 17.1232
R24793 a_15061_12134.n2 a_15061_12134.n0 0.498937
R24794 a_15061_12134.n2 a_15061_12134.t1 18.4279
R24795 a_15061_12134.n0 a_15061_12134.n1 3.38952
R24796 a_15061_12134.n1 a_15061_12134.t3 18.3531
R24797 a_15061_12134.n1 a_15061_12134.t2 17.9378
R24798 a_15061_12134.n0 a_15061_12134.t4 15.4204
R24799 a_14775_11816.n0 a_14775_11816.t1 17.0005
R24800 a_14775_11816.t0 a_14775_11816.n0 18.3191
R24801 a_14775_11816.n1 a_14775_11816.t2 17.0005
R24802 a_14775_11816.n0 a_14775_11816.n1 3.28463
R24803 a_14775_11816.n1 a_14775_11816.t3 18.6222
R24804 a_15035_12039.t0 a_15035_12039.n1 17.3352
R24805 a_15035_12039.n1 a_15035_12039.t1 17.2651
R24806 a_15035_12039.n1 a_15035_12039.n0 0.948441
R24807 a_15035_12039.n0 a_15035_12039.t2 17.3305
R24808 a_15035_12039.n0 a_15035_12039.t3 15.4436
R24809 a_14319_12114.t0 a_14319_12114.n1 17.1443
R24810 a_14319_12114.n1 a_14319_12114.n0 0.743
R24811 a_14319_12114.n0 a_14319_12114.t2 8.65706
R24812 a_14319_12114.n0 a_14319_12114.t1 8.71106
R24813 a_14319_12114.n1 a_14319_12114.t3 15.731
R24814 a_13930_11798.t0 a_13930_11798.n0 8.81393
R24815 a_13930_11798.n0 a_13930_11798.t2 15.4488
R24816 a_13930_11798.n0 a_13930_11798.t1 6.09623
R24817 a_11689_11890.t3 a_11689_11890.n0 8.8328
R24818 a_11689_11890.n2 a_11689_11890.n3 1.14175
R24819 a_11689_11890.n1 a_11689_11890.n2 1.14175
R24820 a_11689_11890.n0 a_11689_11890.n1 1.14175
R24821 a_11689_11890.n3 a_11689_11890.t0 8.8328
R24822 a_11689_11890.n3 a_11689_11890.t4 8.8328
R24823 a_11689_11890.n2 a_11689_11890.t1 8.8328
R24824 a_11689_11890.n2 a_11689_11890.t5 8.8318
R24825 a_11689_11890.n1 a_11689_11890.t2 8.8328
R24826 a_11689_11890.n1 a_11689_11890.t7 8.8318
R24827 a_11689_11890.n0 a_11689_11890.t6 8.8318
R24828 a_9706_11893.t0 a_9706_11893.t1 35.1591
R24829 a_8830_11829.t0 a_8830_11829.t1 35.2643
R24830 a_13625_12194.t0 a_13625_12194.n0 17.1718
R24831 a_13625_12194.n0 a_13625_12194.t1 9.7433
R24832 a_13625_12194.n0 a_13625_12194.t2 15.4943
R24833 a_10601_12094.t0 a_10601_12094.n0 8.76769
R24834 a_10601_12094.n0 a_10601_12094.t2 15.0661
R24835 a_10601_12094.n0 a_10601_12094.t1 5.94842
R24836 a_10028_12033.n0 a_10028_12033.t1 17.0005
R24837 a_10028_12033.t0 a_10028_12033.n0 18.2612
R24838 a_10028_12033.n0 a_10028_12033.t2 15.5529
R24839 a_9800_11893.t1 a_9800_11893.n0 17.5293
R24840 a_9800_11893.n0 a_9800_11893.t0 17.726
R24841 a_9800_11893.n0 a_9800_11893.t2 15.773
R24842 a_7698_11817.t1 a_7698_11817.n0 8.46601
R24843 a_7698_11817.n0 a_7698_11817.t2 9.03504
R24844 a_7698_11817.n0 a_7698_11817.t0 9.14806
R24845 a_9052_12160.t0 a_9052_12160.n1 17.3368
R24846 a_9052_12160.n0 a_9052_12160.t1 8.47322
R24847 a_9052_12160.n1 a_9052_12160.n0 0.103627
R24848 a_9052_12160.n0 a_9052_12160.t2 17.4516
R24849 a_9052_12160.n1 a_9052_12160.t3 15.0435
R24850 a_8950_12073.n0 a_8950_12073.t3 15.0005
R24851 a_8950_12073.t0 a_8950_12073.n0 17.9114
R24852 a_8950_12073.n1 a_8950_12073.t1 17.0005
R24853 a_8950_12073.n0 a_8950_12073.n1 0.655551
R24854 a_8950_12073.n1 a_8950_12073.t2 15.2176
R24855 a_8541_12134.t0 a_8541_12134.n2 17.1232
R24856 a_8541_12134.n2 a_8541_12134.n0 0.498937
R24857 a_8541_12134.n2 a_8541_12134.t1 18.4279
R24858 a_8541_12134.n0 a_8541_12134.n1 3.38952
R24859 a_8541_12134.n1 a_8541_12134.t2 18.3531
R24860 a_8541_12134.n1 a_8541_12134.t3 17.9378
R24861 a_8541_12134.n0 a_8541_12134.t4 15.4204
R24862 a_8255_11816.n0 a_8255_11816.t1 17.0005
R24863 a_8255_11816.t0 a_8255_11816.n0 18.3191
R24864 a_8255_11816.n1 a_8255_11816.t3 17.0005
R24865 a_8255_11816.n0 a_8255_11816.n1 3.28463
R24866 a_8255_11816.n1 a_8255_11816.t2 18.6222
R24867 a_8515_12039.t0 a_8515_12039.n1 17.2651
R24868 a_8515_12039.n1 a_8515_12039.t1 17.3352
R24869 a_8515_12039.n1 a_8515_12039.n0 0.948441
R24870 a_8515_12039.n0 a_8515_12039.t2 17.3305
R24871 a_8515_12039.n0 a_8515_12039.t3 15.4436
R24872 a_7799_12114.t1 a_7799_12114.n1 17.1443
R24873 a_7799_12114.n1 a_7799_12114.n0 0.743
R24874 a_7799_12114.n0 a_7799_12114.t0 8.65706
R24875 a_7799_12114.n0 a_7799_12114.t2 8.71106
R24876 a_7799_12114.n1 a_7799_12114.t3 15.731
R24877 a_7410_11798.t0 a_7410_11798.n0 8.81393
R24878 a_7410_11798.n0 a_7410_11798.t2 15.4488
R24879 a_7410_11798.n0 a_7410_11798.t1 6.09623
R24880 a_5169_11890.t3 a_5169_11890.n0 8.8328
R24881 a_5169_11890.n2 a_5169_11890.n3 1.14175
R24882 a_5169_11890.n1 a_5169_11890.n2 1.14175
R24883 a_5169_11890.n0 a_5169_11890.n1 1.14175
R24884 a_5169_11890.n3 a_5169_11890.t0 8.8328
R24885 a_5169_11890.n3 a_5169_11890.t5 8.8328
R24886 a_5169_11890.n2 a_5169_11890.t1 8.8328
R24887 a_5169_11890.n2 a_5169_11890.t6 8.8318
R24888 a_5169_11890.n1 a_5169_11890.t2 8.8328
R24889 a_5169_11890.n1 a_5169_11890.t7 8.8318
R24890 a_5169_11890.n0 a_5169_11890.t4 8.8318
R24891 a_3186_11893.t0 a_3186_11893.t1 35.1591
R24892 a_2310_11829.t0 a_2310_11829.t1 35.2643
R24893 a_7105_12194.t0 a_7105_12194.n0 17.1718
R24894 a_7105_12194.n0 a_7105_12194.t1 9.7433
R24895 a_7105_12194.n0 a_7105_12194.t2 15.4943
R24896 a_4081_12094.t0 a_4081_12094.n0 8.76769
R24897 a_4081_12094.n0 a_4081_12094.t2 15.0661
R24898 a_4081_12094.n0 a_4081_12094.t1 5.94842
R24899 a_3508_12033.n0 a_3508_12033.t1 17.0005
R24900 a_3508_12033.t0 a_3508_12033.n0 18.2612
R24901 a_3508_12033.n0 a_3508_12033.t2 15.5529
R24902 a_3280_11893.t0 a_3280_11893.n0 17.5293
R24903 a_3280_11893.n0 a_3280_11893.t1 17.726
R24904 a_3280_11893.n0 a_3280_11893.t2 15.773
R24905 a_1178_11817.t1 a_1178_11817.n0 8.46601
R24906 a_1178_11817.n0 a_1178_11817.t2 9.03504
R24907 a_1178_11817.n0 a_1178_11817.t0 9.14806
R24908 a_2532_12160.t0 a_2532_12160.n1 17.3368
R24909 a_2532_12160.n0 a_2532_12160.t1 8.47322
R24910 a_2532_12160.n1 a_2532_12160.n0 0.103627
R24911 a_2532_12160.n0 a_2532_12160.t2 17.4516
R24912 a_2532_12160.n1 a_2532_12160.t3 15.0435
R24913 a_2430_12073.n0 a_2430_12073.t3 15.0005
R24914 a_2430_12073.t0 a_2430_12073.n0 17.9114
R24915 a_2430_12073.n1 a_2430_12073.t1 17.0005
R24916 a_2430_12073.n0 a_2430_12073.n1 0.655551
R24917 a_2430_12073.n1 a_2430_12073.t2 15.2176
R24918 a_2021_12134.t1 a_2021_12134.n2 17.9378
R24919 a_2021_12134.n2 a_2021_12134.t0 18.3531
R24920 a_2021_12134.n2 a_2021_12134.n1 3.38952
R24921 a_2021_12134.n1 a_2021_12134.n0 0.498937
R24922 a_2021_12134.n0 a_2021_12134.t2 17.1232
R24923 a_2021_12134.n0 a_2021_12134.t3 18.4279
R24924 a_2021_12134.n1 a_2021_12134.t4 15.4204
R24925 a_1735_11816.t0 a_1735_11816.n0 18.6222
R24926 a_1735_11816.n0 a_1735_11816.t1 17.0005
R24927 a_1735_11816.n1 a_1735_11816.t2 17.0005
R24928 a_1735_11816.n0 a_1735_11816.n1 3.28463
R24929 a_1735_11816.n1 a_1735_11816.t3 18.3191
R24930 a_1995_12039.t0 a_1995_12039.n1 17.3352
R24931 a_1995_12039.n1 a_1995_12039.t1 17.2651
R24932 a_1995_12039.n1 a_1995_12039.n0 0.948441
R24933 a_1995_12039.n0 a_1995_12039.t2 17.3305
R24934 a_1995_12039.n0 a_1995_12039.t3 15.4436
R24935 a_1279_12114.t1 a_1279_12114.n1 17.1443
R24936 a_1279_12114.n1 a_1279_12114.n0 0.743
R24937 a_1279_12114.n0 a_1279_12114.t0 8.65706
R24938 a_1279_12114.n0 a_1279_12114.t2 8.71106
R24939 a_1279_12114.n1 a_1279_12114.t3 15.731
R24940 a_n2770_240.t0 a_n2770_240.n0 8.72178
R24941 a_n2770_240.n0 a_n2770_240.t1 17.1859
R24942 a_n2770_240.n0 a_n2770_240.n15 25.7332
R24943 a_n2770_240.n15 a_n2770_240.n14 0.557571
R24944 a_n2770_240.n14 a_n2770_240.n13 4.56629
R24945 a_n2770_240.n13 a_n2770_240.n12 0.557571
R24946 a_n2770_240.n12 a_n2770_240.n11 4.56629
R24947 a_n2770_240.n11 a_n2770_240.n10 0.557571
R24948 a_n2770_240.n10 a_n2770_240.n9 4.56629
R24949 a_n2770_240.n9 a_n2770_240.n8 0.557571
R24950 a_n2770_240.n8 a_n2770_240.n7 4.56629
R24951 a_n2770_240.n7 a_n2770_240.n6 0.557571
R24952 a_n2770_240.n6 a_n2770_240.n5 4.56629
R24953 a_n2770_240.n5 a_n2770_240.n4 0.557571
R24954 a_n2770_240.n4 a_n2770_240.n3 4.56629
R24955 a_n2770_240.n3 a_n2770_240.n2 0.557571
R24956 a_n2770_240.n2 a_n2770_240.n1 4.56629
R24957 a_n2770_240.n1 a_n2770_240.t10 30.2193
R24958 a_n2770_240.n15 a_n2770_240.t9 31.6835
R24959 a_n2770_240.n14 a_n2770_240.t17 29.6622
R24960 a_n2770_240.n13 a_n2770_240.t8 31.6835
R24961 a_n2770_240.n12 a_n2770_240.t16 29.6622
R24962 a_n2770_240.n11 a_n2770_240.t7 31.6835
R24963 a_n2770_240.n10 a_n2770_240.t15 29.6622
R24964 a_n2770_240.n9 a_n2770_240.t6 31.6835
R24965 a_n2770_240.n8 a_n2770_240.t14 29.6622
R24966 a_n2770_240.n7 a_n2770_240.t5 31.6835
R24967 a_n2770_240.n6 a_n2770_240.t13 29.6622
R24968 a_n2770_240.n5 a_n2770_240.t4 31.6835
R24969 a_n2770_240.n4 a_n2770_240.t12 29.6622
R24970 a_n2770_240.n3 a_n2770_240.t3 31.6835
R24971 a_n2770_240.n2 a_n2770_240.t11 29.6622
R24972 a_n2770_240.n1 a_n2770_240.t2 31.6835
R24973 a_890_11798.t0 a_890_11798.n0 8.81393
R24974 a_890_11798.n0 a_890_11798.t2 15.4488
R24975 a_890_11798.n0 a_890_11798.t1 6.09623
R24976 a_585_12194.t0 a_585_12194.n0 17.1718
R24977 a_585_12194.n0 a_585_12194.t1 9.7433
R24978 a_585_12194.n0 a_585_12194.t2 15.4943
R24979 a_50643_12150.t3 a_50643_12150.n5 10.0462
R24980 a_50643_12150.n5 a_50643_12150.t6 8.90498
R24981 a_50643_12150.n5 a_50643_12150.n0 1.09706
R24982 a_50643_12150.n0 a_50643_12150.n4 1.09706
R24983 a_50643_12150.n4 a_50643_12150.t4 8.90498
R24984 a_50643_12150.n4 a_50643_12150.t2 10.0462
R24985 a_50643_12150.n0 a_50643_12150.n1 18.263
R24986 a_50643_12150.n3 a_50643_12150.t8 17.0005
R24987 a_50643_12150.n1 a_50643_12150.n3 1.37206
R24988 a_50643_12150.n3 a_50643_12150.t1 18.9255
R24989 a_50643_12150.n2 a_50643_12150.t7 17.0005
R24990 a_50643_12150.n1 a_50643_12150.n2 1.37206
R24991 a_50643_12150.n2 a_50643_12150.t0 18.9255
R24992 a_50643_12150.n1 a_50643_12150.t9 17.6708
R24993 a_50643_12150.n0 a_50643_12150.t5 8.81561
R24994 a_44123_12150.t3 a_44123_12150.n5 10.0462
R24995 a_44123_12150.n5 a_44123_12150.t8 8.90498
R24996 a_44123_12150.n5 a_44123_12150.n0 1.09706
R24997 a_44123_12150.n0 a_44123_12150.n4 1.09706
R24998 a_44123_12150.n4 a_44123_12150.t6 8.90498
R24999 a_44123_12150.n4 a_44123_12150.t2 10.0462
R25000 a_44123_12150.n0 a_44123_12150.n1 18.263
R25001 a_44123_12150.n3 a_44123_12150.t5 17.0005
R25002 a_44123_12150.n1 a_44123_12150.n3 1.37206
R25003 a_44123_12150.n3 a_44123_12150.t1 18.9255
R25004 a_44123_12150.n2 a_44123_12150.t4 17.0005
R25005 a_44123_12150.n1 a_44123_12150.n2 1.37206
R25006 a_44123_12150.n2 a_44123_12150.t0 18.9255
R25007 a_44123_12150.n1 a_44123_12150.t9 17.6708
R25008 a_44123_12150.n0 a_44123_12150.t7 8.81561
R25009 a_37603_12150.t3 a_37603_12150.n5 10.0462
R25010 a_37603_12150.n5 a_37603_12150.t8 8.90498
R25011 a_37603_12150.n5 a_37603_12150.n0 1.09706
R25012 a_37603_12150.n0 a_37603_12150.n4 1.09706
R25013 a_37603_12150.n4 a_37603_12150.t6 8.90498
R25014 a_37603_12150.n4 a_37603_12150.t2 10.0462
R25015 a_37603_12150.n0 a_37603_12150.n1 18.263
R25016 a_37603_12150.n3 a_37603_12150.t5 17.0005
R25017 a_37603_12150.n1 a_37603_12150.n3 1.37206
R25018 a_37603_12150.n3 a_37603_12150.t1 18.9255
R25019 a_37603_12150.n2 a_37603_12150.t4 17.0005
R25020 a_37603_12150.n1 a_37603_12150.n2 1.37206
R25021 a_37603_12150.n2 a_37603_12150.t0 18.9255
R25022 a_37603_12150.n1 a_37603_12150.t9 17.6708
R25023 a_37603_12150.n0 a_37603_12150.t7 8.81561
R25024 a_31083_12150.t9 a_31083_12150.n5 8.90498
R25025 a_31083_12150.n5 a_31083_12150.t3 10.0462
R25026 a_31083_12150.n5 a_31083_12150.n0 1.09706
R25027 a_31083_12150.n0 a_31083_12150.n4 1.09706
R25028 a_31083_12150.n4 a_31083_12150.t7 8.90498
R25029 a_31083_12150.n4 a_31083_12150.t2 10.0462
R25030 a_31083_12150.n0 a_31083_12150.n1 18.263
R25031 a_31083_12150.n3 a_31083_12150.t5 17.0005
R25032 a_31083_12150.n1 a_31083_12150.n3 1.37206
R25033 a_31083_12150.n3 a_31083_12150.t1 18.9255
R25034 a_31083_12150.n2 a_31083_12150.t4 17.0005
R25035 a_31083_12150.n1 a_31083_12150.n2 1.37206
R25036 a_31083_12150.n2 a_31083_12150.t0 18.9255
R25037 a_31083_12150.n1 a_31083_12150.t6 17.6708
R25038 a_31083_12150.n0 a_31083_12150.t8 8.81561
R25039 a_24563_12150.t9 a_24563_12150.n5 8.90498
R25040 a_24563_12150.n5 a_24563_12150.t3 10.0462
R25041 a_24563_12150.n5 a_24563_12150.n0 1.09706
R25042 a_24563_12150.n0 a_24563_12150.n4 1.09706
R25043 a_24563_12150.n4 a_24563_12150.t7 8.90498
R25044 a_24563_12150.n4 a_24563_12150.t2 10.0462
R25045 a_24563_12150.n0 a_24563_12150.n1 18.263
R25046 a_24563_12150.n3 a_24563_12150.t5 17.0005
R25047 a_24563_12150.n1 a_24563_12150.n3 1.37206
R25048 a_24563_12150.n3 a_24563_12150.t1 18.9255
R25049 a_24563_12150.n2 a_24563_12150.t4 17.0005
R25050 a_24563_12150.n1 a_24563_12150.n2 1.37206
R25051 a_24563_12150.n2 a_24563_12150.t0 18.9255
R25052 a_24563_12150.n1 a_24563_12150.t6 17.6708
R25053 a_24563_12150.n0 a_24563_12150.t8 8.81561
R25054 a_18043_12150.t9 a_18043_12150.n5 8.90498
R25055 a_18043_12150.n5 a_18043_12150.t3 10.0462
R25056 a_18043_12150.n5 a_18043_12150.n0 1.09706
R25057 a_18043_12150.n0 a_18043_12150.n4 1.09706
R25058 a_18043_12150.n4 a_18043_12150.t7 8.90498
R25059 a_18043_12150.n4 a_18043_12150.t2 10.0462
R25060 a_18043_12150.n0 a_18043_12150.n1 18.263
R25061 a_18043_12150.n3 a_18043_12150.t5 17.0005
R25062 a_18043_12150.n1 a_18043_12150.n3 1.37206
R25063 a_18043_12150.n3 a_18043_12150.t1 18.9255
R25064 a_18043_12150.n2 a_18043_12150.t4 17.0005
R25065 a_18043_12150.n1 a_18043_12150.n2 1.37206
R25066 a_18043_12150.n2 a_18043_12150.t0 18.9255
R25067 a_18043_12150.n1 a_18043_12150.t6 17.6708
R25068 a_18043_12150.n0 a_18043_12150.t8 8.81561
R25069 a_11523_12150.t9 a_11523_12150.n5 8.90498
R25070 a_11523_12150.n5 a_11523_12150.t3 10.0462
R25071 a_11523_12150.n5 a_11523_12150.n0 1.09706
R25072 a_11523_12150.n0 a_11523_12150.n4 1.09706
R25073 a_11523_12150.n4 a_11523_12150.t7 8.90498
R25074 a_11523_12150.n4 a_11523_12150.t2 10.0462
R25075 a_11523_12150.n0 a_11523_12150.n1 18.263
R25076 a_11523_12150.n3 a_11523_12150.t6 17.0005
R25077 a_11523_12150.n1 a_11523_12150.n3 1.37206
R25078 a_11523_12150.n3 a_11523_12150.t1 18.9255
R25079 a_11523_12150.n2 a_11523_12150.t4 17.0005
R25080 a_11523_12150.n1 a_11523_12150.n2 1.37206
R25081 a_11523_12150.n2 a_11523_12150.t0 18.9255
R25082 a_11523_12150.n1 a_11523_12150.t5 17.6708
R25083 a_11523_12150.n0 a_11523_12150.t8 8.81561
R25084 a_5003_12150.t9 a_5003_12150.n5 8.90498
R25085 a_5003_12150.n5 a_5003_12150.t3 10.0462
R25086 a_5003_12150.n5 a_5003_12150.n0 1.09706
R25087 a_5003_12150.n0 a_5003_12150.n4 1.09706
R25088 a_5003_12150.n4 a_5003_12150.t7 8.90498
R25089 a_5003_12150.n4 a_5003_12150.t2 10.0462
R25090 a_5003_12150.n0 a_5003_12150.n1 18.263
R25091 a_5003_12150.n3 a_5003_12150.t6 17.0005
R25092 a_5003_12150.n1 a_5003_12150.n3 1.37206
R25093 a_5003_12150.n3 a_5003_12150.t1 18.9255
R25094 a_5003_12150.n2 a_5003_12150.t4 17.0005
R25095 a_5003_12150.n1 a_5003_12150.n2 1.37206
R25096 a_5003_12150.n2 a_5003_12150.t0 18.9255
R25097 a_5003_12150.n1 a_5003_12150.t5 17.6708
R25098 a_5003_12150.n0 a_5003_12150.t8 8.81561
R25099 a_49938_12114.t0 a_49938_12114.n0 8.53521
R25100 a_49938_12114.n0 a_49938_12114.t2 16.6582
R25101 a_49938_12114.n0 a_49938_12114.t1 6.13582
R25102 a_43418_12114.t0 a_43418_12114.n0 8.53521
R25103 a_43418_12114.n0 a_43418_12114.t2 16.6582
R25104 a_43418_12114.n0 a_43418_12114.t1 6.13582
R25105 a_49517_12094.t0 a_49517_12094.n0 8.53379
R25106 a_49517_12094.n0 a_49517_12094.t1 6.23476
R25107 a_49517_12094.n0 a_49517_12094.t2 35.9286
R25108 a_36898_12114.t0 a_36898_12114.n0 8.53521
R25109 a_36898_12114.n0 a_36898_12114.t2 16.6582
R25110 a_36898_12114.n0 a_36898_12114.t1 6.13582
R25111 a_42997_12094.t0 a_42997_12094.n0 8.53379
R25112 a_42997_12094.n0 a_42997_12094.t1 6.23476
R25113 a_42997_12094.n0 a_42997_12094.t2 35.9286
R25114 a_30378_12114.t0 a_30378_12114.n0 8.53521
R25115 a_30378_12114.n0 a_30378_12114.t2 16.6582
R25116 a_30378_12114.n0 a_30378_12114.t1 6.13582
R25117 a_36477_12094.t0 a_36477_12094.n0 8.53379
R25118 a_36477_12094.n0 a_36477_12094.t1 6.23476
R25119 a_36477_12094.n0 a_36477_12094.t2 35.9286
R25120 a_23858_12114.t0 a_23858_12114.n0 8.53521
R25121 a_23858_12114.n0 a_23858_12114.t2 16.6582
R25122 a_23858_12114.n0 a_23858_12114.t1 6.13582
R25123 a_29957_12094.t0 a_29957_12094.n0 8.53379
R25124 a_29957_12094.n0 a_29957_12094.t1 6.23476
R25125 a_29957_12094.n0 a_29957_12094.t2 35.9286
R25126 a_17338_12114.t0 a_17338_12114.n0 8.53521
R25127 a_17338_12114.n0 a_17338_12114.t2 16.6582
R25128 a_17338_12114.n0 a_17338_12114.t1 6.13582
R25129 a_23437_12094.t0 a_23437_12094.n0 8.53379
R25130 a_23437_12094.n0 a_23437_12094.t1 6.23476
R25131 a_23437_12094.n0 a_23437_12094.t2 35.9286
R25132 a_10818_12114.t0 a_10818_12114.n0 8.53521
R25133 a_10818_12114.n0 a_10818_12114.t2 16.6582
R25134 a_10818_12114.n0 a_10818_12114.t1 6.13582
R25135 a_16917_12094.t0 a_16917_12094.n0 8.53379
R25136 a_16917_12094.n0 a_16917_12094.t1 6.23476
R25137 a_16917_12094.n0 a_16917_12094.t2 35.9286
R25138 a_4298_12114.t0 a_4298_12114.n0 8.53521
R25139 a_4298_12114.n0 a_4298_12114.t2 16.6582
R25140 a_4298_12114.n0 a_4298_12114.t1 6.13582
R25141 a_10397_12094.t0 a_10397_12094.n0 8.53379
R25142 a_10397_12094.n0 a_10397_12094.t1 6.23476
R25143 a_10397_12094.n0 a_10397_12094.t2 35.9286
R25144 a_3877_12094.t0 a_3877_12094.n0 8.53379
R25145 a_3877_12094.n0 a_3877_12094.t1 6.23476
R25146 a_3877_12094.n0 a_3877_12094.t2 35.9286
R25147 a_50809_14690.t3 a_50809_14690.n0 8.8328
R25148 a_50809_14690.n2 a_50809_14690.n3 1.14175
R25149 a_50809_14690.n1 a_50809_14690.n2 1.14175
R25150 a_50809_14690.n0 a_50809_14690.n1 1.14175
R25151 a_50809_14690.n3 a_50809_14690.t0 8.8328
R25152 a_50809_14690.n3 a_50809_14690.t6 8.8328
R25153 a_50809_14690.n2 a_50809_14690.t1 8.8328
R25154 a_50809_14690.n2 a_50809_14690.t7 8.8318
R25155 a_50809_14690.n1 a_50809_14690.t2 8.8328
R25156 a_50809_14690.n1 a_50809_14690.t5 8.8318
R25157 a_50809_14690.n0 a_50809_14690.t4 8.8318
R25158 a_48826_14693.t0 a_48826_14693.t1 35.1591
R25159 a_47950_14629.t0 a_47950_14629.t1 35.2643
R25160 a_49721_14894.t0 a_49721_14894.n0 8.76769
R25161 a_49721_14894.n0 a_49721_14894.t2 15.0661
R25162 a_49721_14894.n0 a_49721_14894.t1 5.94842
R25163 a_49148_14833.n0 a_49148_14833.t1 17.0005
R25164 a_49148_14833.t0 a_49148_14833.n0 18.2612
R25165 a_49148_14833.n0 a_49148_14833.t2 15.5529
R25166 a_48920_14693.t1 a_48920_14693.n0 17.5293
R25167 a_48920_14693.n0 a_48920_14693.t0 17.726
R25168 a_48920_14693.n0 a_48920_14693.t2 15.773
R25169 a_46818_14617.t1 a_46818_14617.n0 8.46601
R25170 a_46818_14617.n0 a_46818_14617.t2 9.03504
R25171 a_46818_14617.n0 a_46818_14617.t0 9.14806
R25172 a_48172_14960.t0 a_48172_14960.n1 17.3368
R25173 a_48172_14960.n0 a_48172_14960.t1 8.47322
R25174 a_48172_14960.n1 a_48172_14960.n0 0.103627
R25175 a_48172_14960.n0 a_48172_14960.t2 17.4516
R25176 a_48172_14960.n1 a_48172_14960.t3 15.0435
R25177 a_48070_14873.n0 a_48070_14873.t3 15.0005
R25178 a_48070_14873.t0 a_48070_14873.n0 17.9114
R25179 a_48070_14873.n1 a_48070_14873.t1 17.0005
R25180 a_48070_14873.n0 a_48070_14873.n1 0.655551
R25181 a_48070_14873.n1 a_48070_14873.t2 15.2176
R25182 a_47661_14934.t0 a_47661_14934.n2 17.1232
R25183 a_47661_14934.n2 a_47661_14934.n0 0.498937
R25184 a_47661_14934.n2 a_47661_14934.t1 18.4279
R25185 a_47661_14934.n0 a_47661_14934.n1 3.38952
R25186 a_47661_14934.n1 a_47661_14934.t3 18.3531
R25187 a_47661_14934.n1 a_47661_14934.t2 17.9378
R25188 a_47661_14934.n0 a_47661_14934.t4 15.4204
R25189 a_47375_14616.n0 a_47375_14616.t1 17.0005
R25190 a_47375_14616.t0 a_47375_14616.n0 18.3191
R25191 a_47375_14616.n1 a_47375_14616.t2 17.0005
R25192 a_47375_14616.n0 a_47375_14616.n1 3.28463
R25193 a_47375_14616.n1 a_47375_14616.t3 18.6222
R25194 a_47635_14839.t0 a_47635_14839.n1 17.2651
R25195 a_47635_14839.n1 a_47635_14839.t1 17.3352
R25196 a_47635_14839.n1 a_47635_14839.n0 0.948441
R25197 a_47635_14839.n0 a_47635_14839.t2 17.3305
R25198 a_47635_14839.n0 a_47635_14839.t3 15.4436
R25199 a_46919_14914.t1 a_46919_14914.n1 17.1443
R25200 a_46919_14914.n1 a_46919_14914.n0 0.743
R25201 a_46919_14914.n0 a_46919_14914.t0 8.65706
R25202 a_46919_14914.n0 a_46919_14914.t2 8.71106
R25203 a_46919_14914.n1 a_46919_14914.t3 15.731
R25204 a_46530_14598.t0 a_46530_14598.n0 8.81393
R25205 a_46530_14598.n0 a_46530_14598.t2 15.4488
R25206 a_46530_14598.n0 a_46530_14598.t1 6.09623
R25207 a_44289_14690.t3 a_44289_14690.n0 8.8328
R25208 a_44289_14690.n2 a_44289_14690.n3 1.14175
R25209 a_44289_14690.n1 a_44289_14690.n2 1.14175
R25210 a_44289_14690.n0 a_44289_14690.n1 1.14175
R25211 a_44289_14690.n3 a_44289_14690.t0 8.8328
R25212 a_44289_14690.n3 a_44289_14690.t6 8.8328
R25213 a_44289_14690.n2 a_44289_14690.t1 8.8328
R25214 a_44289_14690.n2 a_44289_14690.t7 8.8318
R25215 a_44289_14690.n1 a_44289_14690.t2 8.8328
R25216 a_44289_14690.n1 a_44289_14690.t5 8.8318
R25217 a_44289_14690.n0 a_44289_14690.t4 8.8318
R25218 a_42306_14693.t0 a_42306_14693.t1 35.1591
R25219 a_41430_14629.t0 a_41430_14629.t1 35.2643
R25220 a_46225_14994.t0 a_46225_14994.n0 17.1718
R25221 a_46225_14994.n0 a_46225_14994.t1 9.7433
R25222 a_46225_14994.n0 a_46225_14994.t2 15.4943
R25223 a_43201_14894.t0 a_43201_14894.n0 8.76769
R25224 a_43201_14894.n0 a_43201_14894.t2 15.0661
R25225 a_43201_14894.n0 a_43201_14894.t1 5.94842
R25226 a_42628_14833.n0 a_42628_14833.t1 17.0005
R25227 a_42628_14833.t0 a_42628_14833.n0 18.2612
R25228 a_42628_14833.n0 a_42628_14833.t2 15.5529
R25229 a_42400_14693.t0 a_42400_14693.n0 17.5293
R25230 a_42400_14693.n0 a_42400_14693.t1 17.726
R25231 a_42400_14693.n0 a_42400_14693.t2 15.773
R25232 a_40298_14617.n0 a_40298_14617.t0 8.46601
R25233 a_40298_14617.t1 a_40298_14617.n0 9.03504
R25234 a_40298_14617.n0 a_40298_14617.t2 9.14806
R25235 a_41652_14960.t0 a_41652_14960.n1 17.3368
R25236 a_41652_14960.n0 a_41652_14960.t1 8.47322
R25237 a_41652_14960.n1 a_41652_14960.n0 0.103627
R25238 a_41652_14960.n0 a_41652_14960.t2 17.4516
R25239 a_41652_14960.n1 a_41652_14960.t3 15.0435
R25240 a_41550_14873.n0 a_41550_14873.t3 15.0005
R25241 a_41550_14873.t0 a_41550_14873.n0 17.9114
R25242 a_41550_14873.n1 a_41550_14873.t1 17.0005
R25243 a_41550_14873.n0 a_41550_14873.n1 0.655551
R25244 a_41550_14873.n1 a_41550_14873.t2 15.2176
R25245 a_41141_14934.t1 a_41141_14934.n2 17.9378
R25246 a_41141_14934.n2 a_41141_14934.t0 18.3531
R25247 a_41141_14934.n2 a_41141_14934.n1 3.38952
R25248 a_41141_14934.n1 a_41141_14934.n0 0.498937
R25249 a_41141_14934.n0 a_41141_14934.t2 17.1232
R25250 a_41141_14934.n0 a_41141_14934.t3 18.4279
R25251 a_41141_14934.n1 a_41141_14934.t4 15.4204
R25252 a_40855_14616.t0 a_40855_14616.n0 18.6222
R25253 a_40855_14616.n0 a_40855_14616.t1 17.0005
R25254 a_40855_14616.n1 a_40855_14616.t2 17.0005
R25255 a_40855_14616.n0 a_40855_14616.n1 3.28463
R25256 a_40855_14616.n1 a_40855_14616.t3 18.3191
R25257 a_41115_14839.t0 a_41115_14839.n1 17.2651
R25258 a_41115_14839.n1 a_41115_14839.t1 17.3352
R25259 a_41115_14839.n1 a_41115_14839.n0 0.948441
R25260 a_41115_14839.n0 a_41115_14839.t2 17.3305
R25261 a_41115_14839.n0 a_41115_14839.t3 15.4436
R25262 a_40399_14914.t0 a_40399_14914.n1 17.1443
R25263 a_40399_14914.n1 a_40399_14914.n0 0.743
R25264 a_40399_14914.n0 a_40399_14914.t2 8.65706
R25265 a_40399_14914.n0 a_40399_14914.t1 8.71106
R25266 a_40399_14914.n1 a_40399_14914.t3 15.731
R25267 a_40010_14598.t0 a_40010_14598.n0 8.81393
R25268 a_40010_14598.n0 a_40010_14598.t2 15.4488
R25269 a_40010_14598.n0 a_40010_14598.t1 6.09623
R25270 a_37769_14690.t3 a_37769_14690.n0 8.8328
R25271 a_37769_14690.n2 a_37769_14690.n3 1.14175
R25272 a_37769_14690.n1 a_37769_14690.n2 1.14175
R25273 a_37769_14690.n0 a_37769_14690.n1 1.14175
R25274 a_37769_14690.n3 a_37769_14690.t0 8.8328
R25275 a_37769_14690.n3 a_37769_14690.t4 8.8328
R25276 a_37769_14690.n2 a_37769_14690.t1 8.8328
R25277 a_37769_14690.n2 a_37769_14690.t5 8.8318
R25278 a_37769_14690.n1 a_37769_14690.t2 8.8328
R25279 a_37769_14690.n1 a_37769_14690.t7 8.8318
R25280 a_37769_14690.n0 a_37769_14690.t6 8.8318
R25281 a_35786_14693.t0 a_35786_14693.t1 35.1591
R25282 a_34910_14629.t0 a_34910_14629.t1 35.2643
R25283 a_39705_14994.t0 a_39705_14994.n0 17.1718
R25284 a_39705_14994.n0 a_39705_14994.t1 9.7433
R25285 a_39705_14994.n0 a_39705_14994.t2 15.4943
R25286 a_36681_14894.t0 a_36681_14894.n0 8.76769
R25287 a_36681_14894.n0 a_36681_14894.t2 15.0661
R25288 a_36681_14894.n0 a_36681_14894.t1 5.94842
R25289 a_36108_14833.n0 a_36108_14833.t1 17.0005
R25290 a_36108_14833.t0 a_36108_14833.n0 18.2612
R25291 a_36108_14833.n0 a_36108_14833.t2 15.5529
R25292 a_35880_14693.t1 a_35880_14693.n0 17.5293
R25293 a_35880_14693.n0 a_35880_14693.t0 17.726
R25294 a_35880_14693.n0 a_35880_14693.t2 15.773
R25295 a_33778_14617.n0 a_33778_14617.t0 8.46601
R25296 a_33778_14617.t1 a_33778_14617.n0 9.03504
R25297 a_33778_14617.n0 a_33778_14617.t2 9.14806
R25298 a_35132_14960.t0 a_35132_14960.n1 17.3368
R25299 a_35132_14960.n0 a_35132_14960.t1 8.47322
R25300 a_35132_14960.n1 a_35132_14960.n0 0.103627
R25301 a_35132_14960.n0 a_35132_14960.t2 17.4516
R25302 a_35132_14960.n1 a_35132_14960.t3 15.0435
R25303 a_35030_14873.n0 a_35030_14873.t3 15.0005
R25304 a_35030_14873.t0 a_35030_14873.n0 17.9114
R25305 a_35030_14873.n1 a_35030_14873.t1 17.0005
R25306 a_35030_14873.n0 a_35030_14873.n1 0.655551
R25307 a_35030_14873.n1 a_35030_14873.t2 15.2176
R25308 a_34621_14934.t1 a_34621_14934.n2 17.9378
R25309 a_34621_14934.n2 a_34621_14934.t0 18.3531
R25310 a_34621_14934.n2 a_34621_14934.n1 3.38952
R25311 a_34621_14934.n1 a_34621_14934.n0 0.498937
R25312 a_34621_14934.n0 a_34621_14934.t2 17.1232
R25313 a_34621_14934.n0 a_34621_14934.t3 18.4279
R25314 a_34621_14934.n1 a_34621_14934.t4 15.4204
R25315 a_34335_14616.t0 a_34335_14616.n1 17.0005
R25316 a_34335_14616.n1 a_34335_14616.t3 18.3191
R25317 a_34335_14616.n0 a_34335_14616.t2 17.0005
R25318 a_34335_14616.n1 a_34335_14616.n0 3.28463
R25319 a_34335_14616.n0 a_34335_14616.t1 18.6222
R25320 a_34595_14839.t0 a_34595_14839.n1 17.3305
R25321 a_34595_14839.n1 a_34595_14839.n0 0.948441
R25322 a_34595_14839.n0 a_34595_14839.t1 17.2651
R25323 a_34595_14839.n0 a_34595_14839.t2 17.3352
R25324 a_34595_14839.n1 a_34595_14839.t3 15.4436
R25325 a_33879_14914.t0 a_33879_14914.n1 17.1443
R25326 a_33879_14914.n1 a_33879_14914.n0 0.743
R25327 a_33879_14914.n0 a_33879_14914.t2 8.65706
R25328 a_33879_14914.n0 a_33879_14914.t1 8.71106
R25329 a_33879_14914.n1 a_33879_14914.t3 15.731
R25330 a_33490_14598.t0 a_33490_14598.n0 8.81393
R25331 a_33490_14598.n0 a_33490_14598.t2 15.4488
R25332 a_33490_14598.n0 a_33490_14598.t1 6.09623
R25333 a_31249_14690.t3 a_31249_14690.n0 8.8328
R25334 a_31249_14690.n2 a_31249_14690.n3 1.14175
R25335 a_31249_14690.n1 a_31249_14690.n2 1.14175
R25336 a_31249_14690.n0 a_31249_14690.n1 1.14175
R25337 a_31249_14690.n3 a_31249_14690.t0 8.8328
R25338 a_31249_14690.n3 a_31249_14690.t4 8.8328
R25339 a_31249_14690.n2 a_31249_14690.t1 8.8328
R25340 a_31249_14690.n2 a_31249_14690.t5 8.8318
R25341 a_31249_14690.n1 a_31249_14690.t2 8.8328
R25342 a_31249_14690.n1 a_31249_14690.t7 8.8318
R25343 a_31249_14690.n0 a_31249_14690.t6 8.8318
R25344 a_29266_14693.t0 a_29266_14693.t1 35.1591
R25345 a_28390_14629.t0 a_28390_14629.t1 35.2643
R25346 a_33185_14994.t0 a_33185_14994.n0 17.1718
R25347 a_33185_14994.n0 a_33185_14994.t1 9.7433
R25348 a_33185_14994.n0 a_33185_14994.t2 15.4943
R25349 a_30161_14894.t0 a_30161_14894.n0 8.76769
R25350 a_30161_14894.n0 a_30161_14894.t2 15.0661
R25351 a_30161_14894.n0 a_30161_14894.t1 5.94842
R25352 a_29588_14833.n0 a_29588_14833.t1 17.0005
R25353 a_29588_14833.t0 a_29588_14833.n0 18.2612
R25354 a_29588_14833.n0 a_29588_14833.t2 15.5529
R25355 a_29360_14693.t0 a_29360_14693.n0 17.5293
R25356 a_29360_14693.n0 a_29360_14693.t1 17.726
R25357 a_29360_14693.n0 a_29360_14693.t2 15.773
R25358 a_27258_14617.t1 a_27258_14617.n0 8.46601
R25359 a_27258_14617.n0 a_27258_14617.t2 9.03504
R25360 a_27258_14617.n0 a_27258_14617.t0 9.14806
R25361 a_28612_14960.t0 a_28612_14960.n1 17.3368
R25362 a_28612_14960.n0 a_28612_14960.t1 8.47322
R25363 a_28612_14960.n1 a_28612_14960.n0 0.103627
R25364 a_28612_14960.n0 a_28612_14960.t2 17.4516
R25365 a_28612_14960.n1 a_28612_14960.t3 15.0435
R25366 a_28510_14873.n0 a_28510_14873.t3 15.0005
R25367 a_28510_14873.t0 a_28510_14873.n0 17.9114
R25368 a_28510_14873.n1 a_28510_14873.t1 17.0005
R25369 a_28510_14873.n0 a_28510_14873.n1 0.655551
R25370 a_28510_14873.n1 a_28510_14873.t2 15.2176
R25371 a_28101_14934.t1 a_28101_14934.n2 17.1232
R25372 a_28101_14934.n2 a_28101_14934.n0 0.498937
R25373 a_28101_14934.n2 a_28101_14934.t2 18.4279
R25374 a_28101_14934.n0 a_28101_14934.n1 3.38952
R25375 a_28101_14934.n1 a_28101_14934.t0 18.3531
R25376 a_28101_14934.n1 a_28101_14934.t3 17.9378
R25377 a_28101_14934.n0 a_28101_14934.t4 15.4204
R25378 a_27815_14616.t0 a_27815_14616.n0 18.6222
R25379 a_27815_14616.n0 a_27815_14616.t3 17.0005
R25380 a_27815_14616.n1 a_27815_14616.t2 17.0005
R25381 a_27815_14616.n0 a_27815_14616.n1 3.28463
R25382 a_27815_14616.n1 a_27815_14616.t1 18.3191
R25383 a_28075_14839.t0 a_28075_14839.n1 17.3352
R25384 a_28075_14839.n1 a_28075_14839.t1 17.2651
R25385 a_28075_14839.n1 a_28075_14839.n0 0.948441
R25386 a_28075_14839.n0 a_28075_14839.t2 17.3305
R25387 a_28075_14839.n0 a_28075_14839.t3 15.4436
R25388 a_27359_14914.t2 a_27359_14914.n1 17.1443
R25389 a_27359_14914.n1 a_27359_14914.n0 0.743
R25390 a_27359_14914.n0 a_27359_14914.t0 8.65706
R25391 a_27359_14914.n0 a_27359_14914.t1 8.71106
R25392 a_27359_14914.n1 a_27359_14914.t3 15.731
R25393 a_26970_14598.t0 a_26970_14598.n0 8.81393
R25394 a_26970_14598.n0 a_26970_14598.t2 15.4488
R25395 a_26970_14598.n0 a_26970_14598.t1 6.09623
R25396 a_24729_14690.t3 a_24729_14690.n0 8.8328
R25397 a_24729_14690.n2 a_24729_14690.n3 1.14175
R25398 a_24729_14690.n1 a_24729_14690.n2 1.14175
R25399 a_24729_14690.n0 a_24729_14690.n1 1.14175
R25400 a_24729_14690.n3 a_24729_14690.t0 8.8328
R25401 a_24729_14690.n3 a_24729_14690.t5 8.8328
R25402 a_24729_14690.n2 a_24729_14690.t1 8.8328
R25403 a_24729_14690.n2 a_24729_14690.t6 8.8318
R25404 a_24729_14690.n1 a_24729_14690.t2 8.8328
R25405 a_24729_14690.n1 a_24729_14690.t7 8.8318
R25406 a_24729_14690.n0 a_24729_14690.t4 8.8318
R25407 a_22746_14693.t0 a_22746_14693.t1 35.1591
R25408 a_21870_14629.t0 a_21870_14629.t1 35.2643
R25409 a_26665_14994.t0 a_26665_14994.n0 17.1718
R25410 a_26665_14994.n0 a_26665_14994.t1 9.7433
R25411 a_26665_14994.n0 a_26665_14994.t2 15.4943
R25412 a_23641_14894.t0 a_23641_14894.n0 8.76769
R25413 a_23641_14894.n0 a_23641_14894.t2 15.0661
R25414 a_23641_14894.n0 a_23641_14894.t1 5.94842
R25415 a_23068_14833.n0 a_23068_14833.t1 17.0005
R25416 a_23068_14833.t0 a_23068_14833.n0 18.2612
R25417 a_23068_14833.n0 a_23068_14833.t2 15.5529
R25418 a_22840_14693.t0 a_22840_14693.n0 17.5293
R25419 a_22840_14693.n0 a_22840_14693.t1 17.726
R25420 a_22840_14693.n0 a_22840_14693.t2 15.773
R25421 a_20738_14617.t1 a_20738_14617.n0 8.46601
R25422 a_20738_14617.n0 a_20738_14617.t2 9.03504
R25423 a_20738_14617.n0 a_20738_14617.t0 9.14806
R25424 a_22092_14960.t0 a_22092_14960.n1 17.3368
R25425 a_22092_14960.n0 a_22092_14960.t1 8.47322
R25426 a_22092_14960.n1 a_22092_14960.n0 0.103627
R25427 a_22092_14960.n0 a_22092_14960.t2 17.4516
R25428 a_22092_14960.n1 a_22092_14960.t3 15.0435
R25429 a_21990_14873.n0 a_21990_14873.t3 15.0005
R25430 a_21990_14873.t0 a_21990_14873.n0 17.9114
R25431 a_21990_14873.n1 a_21990_14873.t1 17.0005
R25432 a_21990_14873.n0 a_21990_14873.n1 0.655551
R25433 a_21990_14873.n1 a_21990_14873.t2 15.2176
R25434 a_21581_14934.t0 a_21581_14934.n2 17.1232
R25435 a_21581_14934.n2 a_21581_14934.n0 0.498937
R25436 a_21581_14934.n2 a_21581_14934.t1 18.4279
R25437 a_21581_14934.n0 a_21581_14934.n1 3.38952
R25438 a_21581_14934.n1 a_21581_14934.t2 18.3531
R25439 a_21581_14934.n1 a_21581_14934.t3 17.9378
R25440 a_21581_14934.n0 a_21581_14934.t4 15.4204
R25441 a_21295_14616.n0 a_21295_14616.t1 17.0005
R25442 a_21295_14616.t0 a_21295_14616.n0 18.3191
R25443 a_21295_14616.n1 a_21295_14616.t3 17.0005
R25444 a_21295_14616.n0 a_21295_14616.n1 3.28463
R25445 a_21295_14616.n1 a_21295_14616.t2 18.6222
R25446 a_21555_14839.t0 a_21555_14839.n1 17.2651
R25447 a_21555_14839.n1 a_21555_14839.t1 17.3352
R25448 a_21555_14839.n1 a_21555_14839.n0 0.948441
R25449 a_21555_14839.n0 a_21555_14839.t2 17.3305
R25450 a_21555_14839.n0 a_21555_14839.t3 15.4436
R25451 a_20839_14914.t2 a_20839_14914.n1 17.1443
R25452 a_20839_14914.n1 a_20839_14914.n0 0.743
R25453 a_20839_14914.n0 a_20839_14914.t0 8.65706
R25454 a_20839_14914.n0 a_20839_14914.t1 8.71106
R25455 a_20839_14914.n1 a_20839_14914.t3 15.731
R25456 a_20450_14598.t0 a_20450_14598.n0 8.81393
R25457 a_20450_14598.n0 a_20450_14598.t2 15.4488
R25458 a_20450_14598.n0 a_20450_14598.t1 6.09623
R25459 a_18209_14690.t3 a_18209_14690.n0 8.8328
R25460 a_18209_14690.n2 a_18209_14690.n3 1.14175
R25461 a_18209_14690.n1 a_18209_14690.n2 1.14175
R25462 a_18209_14690.n0 a_18209_14690.n1 1.14175
R25463 a_18209_14690.n3 a_18209_14690.t0 8.8328
R25464 a_18209_14690.n3 a_18209_14690.t4 8.8328
R25465 a_18209_14690.n2 a_18209_14690.t1 8.8328
R25466 a_18209_14690.n2 a_18209_14690.t5 8.8318
R25467 a_18209_14690.n1 a_18209_14690.t2 8.8328
R25468 a_18209_14690.n1 a_18209_14690.t7 8.8318
R25469 a_18209_14690.n0 a_18209_14690.t6 8.8318
R25470 a_16226_14693.t0 a_16226_14693.t1 35.1591
R25471 a_15350_14629.t0 a_15350_14629.t1 35.2643
R25472 a_20145_14994.t0 a_20145_14994.n0 17.1718
R25473 a_20145_14994.n0 a_20145_14994.t1 9.7433
R25474 a_20145_14994.n0 a_20145_14994.t2 15.4943
R25475 a_17121_14894.t0 a_17121_14894.n0 8.76769
R25476 a_17121_14894.n0 a_17121_14894.t2 15.0661
R25477 a_17121_14894.n0 a_17121_14894.t1 5.94842
R25478 a_16548_14833.n0 a_16548_14833.t1 17.0005
R25479 a_16548_14833.t0 a_16548_14833.n0 18.2612
R25480 a_16548_14833.n0 a_16548_14833.t2 15.5529
R25481 a_16320_14693.t1 a_16320_14693.n0 17.5293
R25482 a_16320_14693.n0 a_16320_14693.t0 17.726
R25483 a_16320_14693.n0 a_16320_14693.t2 15.773
R25484 a_14218_14617.t1 a_14218_14617.n0 8.46601
R25485 a_14218_14617.n0 a_14218_14617.t2 9.03504
R25486 a_14218_14617.n0 a_14218_14617.t0 9.14806
R25487 a_15572_14960.t0 a_15572_14960.n1 17.3368
R25488 a_15572_14960.n0 a_15572_14960.t1 8.47322
R25489 a_15572_14960.n1 a_15572_14960.n0 0.103627
R25490 a_15572_14960.n0 a_15572_14960.t2 17.4516
R25491 a_15572_14960.n1 a_15572_14960.t3 15.0435
R25492 a_15470_14873.n0 a_15470_14873.t3 15.0005
R25493 a_15470_14873.t0 a_15470_14873.n0 17.9114
R25494 a_15470_14873.n1 a_15470_14873.t1 17.0005
R25495 a_15470_14873.n0 a_15470_14873.n1 0.655551
R25496 a_15470_14873.n1 a_15470_14873.t2 15.2176
R25497 a_15061_14934.t0 a_15061_14934.n2 17.1232
R25498 a_15061_14934.n2 a_15061_14934.n0 0.498937
R25499 a_15061_14934.n2 a_15061_14934.t1 18.4279
R25500 a_15061_14934.n0 a_15061_14934.n1 3.38952
R25501 a_15061_14934.n1 a_15061_14934.t3 18.3531
R25502 a_15061_14934.n1 a_15061_14934.t2 17.9378
R25503 a_15061_14934.n0 a_15061_14934.t4 15.4204
R25504 a_14775_14616.n0 a_14775_14616.t1 17.0005
R25505 a_14775_14616.t0 a_14775_14616.n0 18.3191
R25506 a_14775_14616.n1 a_14775_14616.t2 17.0005
R25507 a_14775_14616.n0 a_14775_14616.n1 3.28463
R25508 a_14775_14616.n1 a_14775_14616.t3 18.6222
R25509 a_15035_14839.t0 a_15035_14839.n1 17.3352
R25510 a_15035_14839.n1 a_15035_14839.t1 17.2651
R25511 a_15035_14839.n1 a_15035_14839.n0 0.948441
R25512 a_15035_14839.n0 a_15035_14839.t2 17.3305
R25513 a_15035_14839.n0 a_15035_14839.t3 15.4436
R25514 a_14319_14914.t1 a_14319_14914.n1 17.1443
R25515 a_14319_14914.n1 a_14319_14914.n0 0.743
R25516 a_14319_14914.n0 a_14319_14914.t0 8.65706
R25517 a_14319_14914.n0 a_14319_14914.t2 8.71106
R25518 a_14319_14914.n1 a_14319_14914.t3 15.731
R25519 a_13930_14598.t0 a_13930_14598.n0 8.81393
R25520 a_13930_14598.n0 a_13930_14598.t2 15.4488
R25521 a_13930_14598.n0 a_13930_14598.t1 6.09623
R25522 a_11689_14690.t3 a_11689_14690.n0 8.8328
R25523 a_11689_14690.n2 a_11689_14690.n3 1.14175
R25524 a_11689_14690.n1 a_11689_14690.n2 1.14175
R25525 a_11689_14690.n0 a_11689_14690.n1 1.14175
R25526 a_11689_14690.n3 a_11689_14690.t0 8.8328
R25527 a_11689_14690.n3 a_11689_14690.t6 8.8328
R25528 a_11689_14690.n2 a_11689_14690.t1 8.8328
R25529 a_11689_14690.n2 a_11689_14690.t7 8.8318
R25530 a_11689_14690.n1 a_11689_14690.t2 8.8328
R25531 a_11689_14690.n1 a_11689_14690.t5 8.8318
R25532 a_11689_14690.n0 a_11689_14690.t4 8.8318
R25533 a_9706_14693.t0 a_9706_14693.t1 35.1591
R25534 a_8830_14629.t0 a_8830_14629.t1 35.2643
R25535 a_13625_14994.t0 a_13625_14994.n0 17.1718
R25536 a_13625_14994.n0 a_13625_14994.t1 9.7433
R25537 a_13625_14994.n0 a_13625_14994.t2 15.4943
R25538 a_10601_14894.t0 a_10601_14894.n0 8.76769
R25539 a_10601_14894.n0 a_10601_14894.t2 15.0661
R25540 a_10601_14894.n0 a_10601_14894.t1 5.94842
R25541 a_10028_14833.n0 a_10028_14833.t1 17.0005
R25542 a_10028_14833.t0 a_10028_14833.n0 18.2612
R25543 a_10028_14833.n0 a_10028_14833.t2 15.5529
R25544 a_9800_14693.t0 a_9800_14693.n0 17.5293
R25545 a_9800_14693.n0 a_9800_14693.t1 17.726
R25546 a_9800_14693.n0 a_9800_14693.t2 15.773
R25547 a_7698_14617.n0 a_7698_14617.t0 8.46601
R25548 a_7698_14617.t1 a_7698_14617.n0 9.03504
R25549 a_7698_14617.n0 a_7698_14617.t2 9.14806
R25550 a_9052_14960.t0 a_9052_14960.n1 17.3368
R25551 a_9052_14960.n0 a_9052_14960.t1 8.47322
R25552 a_9052_14960.n1 a_9052_14960.n0 0.103627
R25553 a_9052_14960.n0 a_9052_14960.t2 17.4516
R25554 a_9052_14960.n1 a_9052_14960.t3 15.0435
R25555 a_8950_14873.n0 a_8950_14873.t3 15.0005
R25556 a_8950_14873.t0 a_8950_14873.n0 17.9114
R25557 a_8950_14873.n1 a_8950_14873.t1 17.0005
R25558 a_8950_14873.n0 a_8950_14873.n1 0.655551
R25559 a_8950_14873.n1 a_8950_14873.t2 15.2176
R25560 a_8541_14934.t0 a_8541_14934.n2 17.9378
R25561 a_8541_14934.n2 a_8541_14934.t1 18.3531
R25562 a_8541_14934.n2 a_8541_14934.n1 3.38952
R25563 a_8541_14934.n1 a_8541_14934.n0 0.498937
R25564 a_8541_14934.n0 a_8541_14934.t2 17.1232
R25565 a_8541_14934.n0 a_8541_14934.t3 18.4279
R25566 a_8541_14934.n1 a_8541_14934.t4 15.4204
R25567 a_8255_14616.t0 a_8255_14616.n1 17.0005
R25568 a_8255_14616.n1 a_8255_14616.t1 18.6222
R25569 a_8255_14616.n0 a_8255_14616.t2 17.0005
R25570 a_8255_14616.n1 a_8255_14616.n0 3.28463
R25571 a_8255_14616.n0 a_8255_14616.t3 18.3191
R25572 a_8515_14839.t0 a_8515_14839.n1 17.2651
R25573 a_8515_14839.n1 a_8515_14839.t1 17.3352
R25574 a_8515_14839.n1 a_8515_14839.n0 0.948441
R25575 a_8515_14839.n0 a_8515_14839.t2 17.3305
R25576 a_8515_14839.n0 a_8515_14839.t3 15.4436
R25577 a_7799_14914.t0 a_7799_14914.n1 17.1443
R25578 a_7799_14914.n1 a_7799_14914.n0 0.743
R25579 a_7799_14914.n0 a_7799_14914.t2 8.65706
R25580 a_7799_14914.n0 a_7799_14914.t1 8.71106
R25581 a_7799_14914.n1 a_7799_14914.t3 15.731
R25582 a_7410_14598.t0 a_7410_14598.n0 8.81393
R25583 a_7410_14598.n0 a_7410_14598.t2 15.4488
R25584 a_7410_14598.n0 a_7410_14598.t1 6.09623
R25585 a_5169_14690.t3 a_5169_14690.n0 8.8328
R25586 a_5169_14690.n2 a_5169_14690.n3 1.14175
R25587 a_5169_14690.n1 a_5169_14690.n2 1.14175
R25588 a_5169_14690.n0 a_5169_14690.n1 1.14175
R25589 a_5169_14690.n3 a_5169_14690.t0 8.8328
R25590 a_5169_14690.n3 a_5169_14690.t6 8.8328
R25591 a_5169_14690.n2 a_5169_14690.t1 8.8328
R25592 a_5169_14690.n2 a_5169_14690.t7 8.8318
R25593 a_5169_14690.n1 a_5169_14690.t2 8.8328
R25594 a_5169_14690.n1 a_5169_14690.t5 8.8318
R25595 a_5169_14690.n0 a_5169_14690.t4 8.8318
R25596 a_3186_14693.t0 a_3186_14693.t1 35.1591
R25597 a_2310_14629.t0 a_2310_14629.t1 35.2643
R25598 a_7105_14994.t0 a_7105_14994.n0 17.1718
R25599 a_7105_14994.n0 a_7105_14994.t1 9.7433
R25600 a_7105_14994.n0 a_7105_14994.t2 15.4943
R25601 a_4081_14894.t0 a_4081_14894.n0 8.76769
R25602 a_4081_14894.n0 a_4081_14894.t2 15.0661
R25603 a_4081_14894.n0 a_4081_14894.t1 5.94842
R25604 a_3508_14833.t0 a_3508_14833.n0 17.0005
R25605 a_3508_14833.n0 a_3508_14833.t1 18.2612
R25606 a_3508_14833.n0 a_3508_14833.t2 15.5529
R25607 a_3280_14693.t1 a_3280_14693.n0 17.5293
R25608 a_3280_14693.n0 a_3280_14693.t0 17.726
R25609 a_3280_14693.n0 a_3280_14693.t2 15.773
R25610 a_1178_14617.n0 a_1178_14617.t0 8.46601
R25611 a_1178_14617.t1 a_1178_14617.n0 9.03504
R25612 a_1178_14617.n0 a_1178_14617.t2 9.14806
R25613 a_2532_14960.t0 a_2532_14960.n1 17.3368
R25614 a_2532_14960.n0 a_2532_14960.t1 8.47322
R25615 a_2532_14960.n1 a_2532_14960.n0 0.103627
R25616 a_2532_14960.n0 a_2532_14960.t2 17.4516
R25617 a_2532_14960.n1 a_2532_14960.t3 15.0435
R25618 a_2430_14873.n0 a_2430_14873.t3 15.0005
R25619 a_2430_14873.t0 a_2430_14873.n0 17.9114
R25620 a_2430_14873.n1 a_2430_14873.t1 17.0005
R25621 a_2430_14873.n0 a_2430_14873.n1 0.655551
R25622 a_2430_14873.n1 a_2430_14873.t2 15.2176
R25623 a_2021_14934.t0 a_2021_14934.n2 17.1232
R25624 a_2021_14934.n2 a_2021_14934.n0 0.498937
R25625 a_2021_14934.n2 a_2021_14934.t1 18.4279
R25626 a_2021_14934.n0 a_2021_14934.n1 3.38952
R25627 a_2021_14934.n1 a_2021_14934.t2 18.3531
R25628 a_2021_14934.n1 a_2021_14934.t3 17.9378
R25629 a_2021_14934.n0 a_2021_14934.t4 15.4204
R25630 a_1735_14616.n0 a_1735_14616.t1 17.0005
R25631 a_1735_14616.t0 a_1735_14616.n0 18.3191
R25632 a_1735_14616.n1 a_1735_14616.t3 17.0005
R25633 a_1735_14616.n0 a_1735_14616.n1 3.28463
R25634 a_1735_14616.n1 a_1735_14616.t2 18.6222
R25635 a_1995_14839.t0 a_1995_14839.n1 17.2651
R25636 a_1995_14839.n1 a_1995_14839.t1 17.3352
R25637 a_1995_14839.n1 a_1995_14839.n0 0.948441
R25638 a_1995_14839.n0 a_1995_14839.t2 17.3305
R25639 a_1995_14839.n0 a_1995_14839.t3 15.4436
R25640 a_1279_14914.t0 a_1279_14914.n1 17.1443
R25641 a_1279_14914.n1 a_1279_14914.n0 0.743
R25642 a_1279_14914.n0 a_1279_14914.t2 8.65706
R25643 a_1279_14914.n0 a_1279_14914.t1 8.71106
R25644 a_1279_14914.n1 a_1279_14914.t3 15.731
R25645 a_n2044_1752.t0 a_n2044_1752.n0 8.787
R25646 a_n2044_1752.n0 a_n2044_1752.t1 5.98944
R25647 a_n2044_1752.n0 a_n2044_1752.n15 25.8698
R25648 a_n2044_1752.n15 a_n2044_1752.n14 0.557571
R25649 a_n2044_1752.n14 a_n2044_1752.n13 4.56629
R25650 a_n2044_1752.n13 a_n2044_1752.n12 0.557571
R25651 a_n2044_1752.n12 a_n2044_1752.n11 4.56629
R25652 a_n2044_1752.n11 a_n2044_1752.n10 0.557571
R25653 a_n2044_1752.n10 a_n2044_1752.n9 4.56629
R25654 a_n2044_1752.n9 a_n2044_1752.n8 0.557571
R25655 a_n2044_1752.n8 a_n2044_1752.n7 4.56629
R25656 a_n2044_1752.n7 a_n2044_1752.n6 0.557571
R25657 a_n2044_1752.n6 a_n2044_1752.n5 4.56629
R25658 a_n2044_1752.n5 a_n2044_1752.n4 0.557571
R25659 a_n2044_1752.n4 a_n2044_1752.n3 4.56629
R25660 a_n2044_1752.n3 a_n2044_1752.n2 0.557571
R25661 a_n2044_1752.n2 a_n2044_1752.n1 4.56629
R25662 a_n2044_1752.n1 a_n2044_1752.t10 30.2193
R25663 a_n2044_1752.n15 a_n2044_1752.t9 31.6835
R25664 a_n2044_1752.n14 a_n2044_1752.t17 29.6622
R25665 a_n2044_1752.n13 a_n2044_1752.t8 31.6835
R25666 a_n2044_1752.n12 a_n2044_1752.t16 29.6622
R25667 a_n2044_1752.n11 a_n2044_1752.t7 31.6835
R25668 a_n2044_1752.n10 a_n2044_1752.t15 29.6622
R25669 a_n2044_1752.n9 a_n2044_1752.t6 31.6835
R25670 a_n2044_1752.n8 a_n2044_1752.t14 29.6622
R25671 a_n2044_1752.n7 a_n2044_1752.t5 31.6835
R25672 a_n2044_1752.n6 a_n2044_1752.t13 29.6622
R25673 a_n2044_1752.n5 a_n2044_1752.t4 31.6835
R25674 a_n2044_1752.n4 a_n2044_1752.t12 29.6622
R25675 a_n2044_1752.n3 a_n2044_1752.t3 31.6835
R25676 a_n2044_1752.n2 a_n2044_1752.t11 29.6622
R25677 a_n2044_1752.n1 a_n2044_1752.t2 31.6835
R25678 a_890_14598.t0 a_890_14598.n0 8.81393
R25679 a_890_14598.n0 a_890_14598.t2 15.4488
R25680 a_890_14598.n0 a_890_14598.t1 6.09623
R25681 a_585_14994.t0 a_585_14994.n0 17.1718
R25682 a_585_14994.n0 a_585_14994.t1 9.7433
R25683 a_585_14994.n0 a_585_14994.t2 15.4943
R25684 a_50643_14950.t3 a_50643_14950.n5 10.0462
R25685 a_50643_14950.n5 a_50643_14950.t6 8.90498
R25686 a_50643_14950.n5 a_50643_14950.n0 1.09706
R25687 a_50643_14950.n0 a_50643_14950.n4 1.09706
R25688 a_50643_14950.n4 a_50643_14950.t4 8.90498
R25689 a_50643_14950.n4 a_50643_14950.t2 10.0462
R25690 a_50643_14950.n0 a_50643_14950.n1 18.263
R25691 a_50643_14950.n3 a_50643_14950.t8 17.0005
R25692 a_50643_14950.n1 a_50643_14950.n3 1.37206
R25693 a_50643_14950.n3 a_50643_14950.t1 18.9255
R25694 a_50643_14950.n2 a_50643_14950.t7 17.0005
R25695 a_50643_14950.n1 a_50643_14950.n2 1.37206
R25696 a_50643_14950.n2 a_50643_14950.t0 18.9255
R25697 a_50643_14950.n1 a_50643_14950.t9 17.6708
R25698 a_50643_14950.n0 a_50643_14950.t5 8.81561
R25699 a_44123_14950.t3 a_44123_14950.n5 10.0462
R25700 a_44123_14950.n5 a_44123_14950.t6 8.90498
R25701 a_44123_14950.n5 a_44123_14950.n0 1.09706
R25702 a_44123_14950.n0 a_44123_14950.n4 1.09706
R25703 a_44123_14950.n4 a_44123_14950.t4 8.90498
R25704 a_44123_14950.n4 a_44123_14950.t2 10.0462
R25705 a_44123_14950.n0 a_44123_14950.n1 18.263
R25706 a_44123_14950.n3 a_44123_14950.t7 17.0005
R25707 a_44123_14950.n1 a_44123_14950.n3 1.37206
R25708 a_44123_14950.n3 a_44123_14950.t1 18.9255
R25709 a_44123_14950.n2 a_44123_14950.t8 17.0005
R25710 a_44123_14950.n1 a_44123_14950.n2 1.37206
R25711 a_44123_14950.n2 a_44123_14950.t0 18.9255
R25712 a_44123_14950.n1 a_44123_14950.t9 17.6708
R25713 a_44123_14950.n0 a_44123_14950.t5 8.81561
R25714 a_37603_14950.t9 a_37603_14950.n5 8.90498
R25715 a_37603_14950.n5 a_37603_14950.t3 10.0462
R25716 a_37603_14950.n5 a_37603_14950.n0 1.09706
R25717 a_37603_14950.n0 a_37603_14950.n4 1.09706
R25718 a_37603_14950.n4 a_37603_14950.t7 8.90498
R25719 a_37603_14950.n4 a_37603_14950.t2 10.0462
R25720 a_37603_14950.n0 a_37603_14950.n1 18.263
R25721 a_37603_14950.n3 a_37603_14950.t5 17.0005
R25722 a_37603_14950.n1 a_37603_14950.n3 1.37206
R25723 a_37603_14950.n3 a_37603_14950.t1 18.9255
R25724 a_37603_14950.n2 a_37603_14950.t4 17.0005
R25725 a_37603_14950.n1 a_37603_14950.n2 1.37206
R25726 a_37603_14950.n2 a_37603_14950.t0 18.9255
R25727 a_37603_14950.n1 a_37603_14950.t6 17.6708
R25728 a_37603_14950.n0 a_37603_14950.t8 8.81561
R25729 a_31083_14950.t9 a_31083_14950.n5 8.90498
R25730 a_31083_14950.n5 a_31083_14950.t3 10.0462
R25731 a_31083_14950.n5 a_31083_14950.n0 1.09706
R25732 a_31083_14950.n0 a_31083_14950.n4 1.09706
R25733 a_31083_14950.n4 a_31083_14950.t7 8.90498
R25734 a_31083_14950.n4 a_31083_14950.t2 10.0462
R25735 a_31083_14950.n0 a_31083_14950.n1 18.263
R25736 a_31083_14950.n3 a_31083_14950.t5 17.0005
R25737 a_31083_14950.n1 a_31083_14950.n3 1.37206
R25738 a_31083_14950.n3 a_31083_14950.t1 18.9255
R25739 a_31083_14950.n2 a_31083_14950.t4 17.0005
R25740 a_31083_14950.n1 a_31083_14950.n2 1.37206
R25741 a_31083_14950.n2 a_31083_14950.t0 18.9255
R25742 a_31083_14950.n1 a_31083_14950.t6 17.6708
R25743 a_31083_14950.n0 a_31083_14950.t8 8.81561
R25744 a_24563_14950.t9 a_24563_14950.n5 8.90498
R25745 a_24563_14950.n5 a_24563_14950.t3 10.0462
R25746 a_24563_14950.n5 a_24563_14950.n0 1.09706
R25747 a_24563_14950.n0 a_24563_14950.n4 1.09706
R25748 a_24563_14950.n4 a_24563_14950.t7 8.90498
R25749 a_24563_14950.n4 a_24563_14950.t2 10.0462
R25750 a_24563_14950.n0 a_24563_14950.n1 18.263
R25751 a_24563_14950.n3 a_24563_14950.t5 17.0005
R25752 a_24563_14950.n1 a_24563_14950.n3 1.37206
R25753 a_24563_14950.n3 a_24563_14950.t1 18.9255
R25754 a_24563_14950.n2 a_24563_14950.t4 17.0005
R25755 a_24563_14950.n1 a_24563_14950.n2 1.37206
R25756 a_24563_14950.n2 a_24563_14950.t0 18.9255
R25757 a_24563_14950.n1 a_24563_14950.t6 17.6708
R25758 a_24563_14950.n0 a_24563_14950.t8 8.81561
R25759 a_18043_14950.t3 a_18043_14950.n5 10.0462
R25760 a_18043_14950.n5 a_18043_14950.t9 8.90498
R25761 a_18043_14950.n5 a_18043_14950.n0 1.09706
R25762 a_18043_14950.n0 a_18043_14950.n4 1.09706
R25763 a_18043_14950.n4 a_18043_14950.t7 8.90498
R25764 a_18043_14950.n4 a_18043_14950.t2 10.0462
R25765 a_18043_14950.n0 a_18043_14950.n1 18.263
R25766 a_18043_14950.n3 a_18043_14950.t6 17.0005
R25767 a_18043_14950.n1 a_18043_14950.n3 1.37206
R25768 a_18043_14950.n3 a_18043_14950.t1 18.9255
R25769 a_18043_14950.n2 a_18043_14950.t4 17.0005
R25770 a_18043_14950.n1 a_18043_14950.n2 1.37206
R25771 a_18043_14950.n2 a_18043_14950.t0 18.9255
R25772 a_18043_14950.n1 a_18043_14950.t5 17.6708
R25773 a_18043_14950.n0 a_18043_14950.t8 8.81561
R25774 a_11523_14950.t3 a_11523_14950.n5 10.0462
R25775 a_11523_14950.n5 a_11523_14950.t6 8.90498
R25776 a_11523_14950.n5 a_11523_14950.n0 1.09706
R25777 a_11523_14950.n0 a_11523_14950.n4 1.09706
R25778 a_11523_14950.n4 a_11523_14950.t4 8.90498
R25779 a_11523_14950.n4 a_11523_14950.t2 10.0462
R25780 a_11523_14950.n0 a_11523_14950.n1 18.263
R25781 a_11523_14950.n3 a_11523_14950.t8 17.0005
R25782 a_11523_14950.n1 a_11523_14950.n3 1.37206
R25783 a_11523_14950.n3 a_11523_14950.t1 18.9255
R25784 a_11523_14950.n2 a_11523_14950.t7 17.0005
R25785 a_11523_14950.n1 a_11523_14950.n2 1.37206
R25786 a_11523_14950.n2 a_11523_14950.t0 18.9255
R25787 a_11523_14950.n1 a_11523_14950.t9 17.6708
R25788 a_11523_14950.n0 a_11523_14950.t5 8.81561
R25789 a_5003_14950.t3 a_5003_14950.n5 10.0462
R25790 a_5003_14950.n5 a_5003_14950.t6 8.90498
R25791 a_5003_14950.n5 a_5003_14950.n0 1.09706
R25792 a_5003_14950.n0 a_5003_14950.n4 1.09706
R25793 a_5003_14950.n4 a_5003_14950.t4 8.90498
R25794 a_5003_14950.n4 a_5003_14950.t2 10.0462
R25795 a_5003_14950.n0 a_5003_14950.n1 18.263
R25796 a_5003_14950.n3 a_5003_14950.t9 17.0005
R25797 a_5003_14950.n1 a_5003_14950.n3 1.37206
R25798 a_5003_14950.n3 a_5003_14950.t1 18.9255
R25799 a_5003_14950.n2 a_5003_14950.t7 17.0005
R25800 a_5003_14950.n1 a_5003_14950.n2 1.37206
R25801 a_5003_14950.n2 a_5003_14950.t0 18.9255
R25802 a_5003_14950.n1 a_5003_14950.t8 17.6708
R25803 a_5003_14950.n0 a_5003_14950.t5 8.81561
R25804 a_49938_14914.t0 a_49938_14914.n0 8.53521
R25805 a_49938_14914.n0 a_49938_14914.t2 16.6582
R25806 a_49938_14914.n0 a_49938_14914.t1 6.13582
R25807 a_43418_14914.t0 a_43418_14914.n0 8.53521
R25808 a_43418_14914.n0 a_43418_14914.t2 16.6582
R25809 a_43418_14914.n0 a_43418_14914.t1 6.13582
R25810 a_49517_14894.t0 a_49517_14894.n0 8.53379
R25811 a_49517_14894.n0 a_49517_14894.t1 6.23476
R25812 a_49517_14894.n0 a_49517_14894.t2 35.9286
R25813 a_36898_14914.t0 a_36898_14914.n0 8.53521
R25814 a_36898_14914.n0 a_36898_14914.t2 16.6582
R25815 a_36898_14914.n0 a_36898_14914.t1 6.13582
R25816 a_42997_14894.t0 a_42997_14894.n0 8.53379
R25817 a_42997_14894.n0 a_42997_14894.t1 6.23476
R25818 a_42997_14894.n0 a_42997_14894.t2 35.9286
R25819 a_30378_14914.t0 a_30378_14914.n0 8.53521
R25820 a_30378_14914.n0 a_30378_14914.t2 16.6582
R25821 a_30378_14914.n0 a_30378_14914.t1 6.13582
R25822 a_36477_14894.t0 a_36477_14894.n0 8.53379
R25823 a_36477_14894.n0 a_36477_14894.t1 6.23476
R25824 a_36477_14894.n0 a_36477_14894.t2 35.9286
R25825 a_23858_14914.t0 a_23858_14914.n0 8.53521
R25826 a_23858_14914.n0 a_23858_14914.t2 16.6582
R25827 a_23858_14914.n0 a_23858_14914.t1 6.13582
R25828 a_29957_14894.t0 a_29957_14894.n0 8.53379
R25829 a_29957_14894.n0 a_29957_14894.t1 6.23476
R25830 a_29957_14894.n0 a_29957_14894.t2 35.9286
R25831 a_17338_14914.t0 a_17338_14914.n0 8.53521
R25832 a_17338_14914.n0 a_17338_14914.t2 16.6582
R25833 a_17338_14914.n0 a_17338_14914.t1 6.13582
R25834 a_23437_14894.t0 a_23437_14894.n0 8.53379
R25835 a_23437_14894.n0 a_23437_14894.t1 6.23476
R25836 a_23437_14894.n0 a_23437_14894.t2 35.9286
R25837 a_10818_14914.t0 a_10818_14914.n0 8.53521
R25838 a_10818_14914.n0 a_10818_14914.t2 16.6582
R25839 a_10818_14914.n0 a_10818_14914.t1 6.13582
R25840 a_16917_14894.t0 a_16917_14894.n0 8.53379
R25841 a_16917_14894.n0 a_16917_14894.t1 6.23476
R25842 a_16917_14894.n0 a_16917_14894.t2 35.9286
R25843 a_4298_14914.t0 a_4298_14914.n0 8.53521
R25844 a_4298_14914.n0 a_4298_14914.t2 16.6582
R25845 a_4298_14914.n0 a_4298_14914.t1 6.13582
R25846 a_10397_14894.t0 a_10397_14894.n0 8.53379
R25847 a_10397_14894.n0 a_10397_14894.t1 6.23476
R25848 a_10397_14894.n0 a_10397_14894.t2 35.9286
R25849 a_3877_14894.t0 a_3877_14894.n0 8.53379
R25850 a_3877_14894.n0 a_3877_14894.t1 6.23476
R25851 a_3877_14894.n0 a_3877_14894.t2 35.9286
R25852 a_50809_17490.t3 a_50809_17490.n0 8.8328
R25853 a_50809_17490.n2 a_50809_17490.n3 1.14175
R25854 a_50809_17490.n1 a_50809_17490.n2 1.14175
R25855 a_50809_17490.n0 a_50809_17490.n1 1.14175
R25856 a_50809_17490.n3 a_50809_17490.t0 8.8328
R25857 a_50809_17490.n3 a_50809_17490.t6 8.8328
R25858 a_50809_17490.n2 a_50809_17490.t1 8.8328
R25859 a_50809_17490.n2 a_50809_17490.t7 8.8318
R25860 a_50809_17490.n1 a_50809_17490.t2 8.8328
R25861 a_50809_17490.n1 a_50809_17490.t5 8.8318
R25862 a_50809_17490.n0 a_50809_17490.t4 8.8318
R25863 a_48826_17493.t0 a_48826_17493.t1 35.1591
R25864 a_47950_17429.t0 a_47950_17429.t1 35.2643
R25865 a_49721_17694.t0 a_49721_17694.n0 8.76769
R25866 a_49721_17694.n0 a_49721_17694.t2 15.0661
R25867 a_49721_17694.n0 a_49721_17694.t1 5.94842
R25868 a_49148_17633.n0 a_49148_17633.t1 17.0005
R25869 a_49148_17633.t0 a_49148_17633.n0 18.2612
R25870 a_49148_17633.n0 a_49148_17633.t2 15.5529
R25871 a_48920_17493.t0 a_48920_17493.n0 17.5293
R25872 a_48920_17493.n0 a_48920_17493.t1 17.726
R25873 a_48920_17493.n0 a_48920_17493.t2 15.773
R25874 a_46818_17417.n0 a_46818_17417.t0 8.46601
R25875 a_46818_17417.t1 a_46818_17417.n0 9.03504
R25876 a_46818_17417.n0 a_46818_17417.t2 9.14806
R25877 a_48172_17760.t0 a_48172_17760.n1 17.3368
R25878 a_48172_17760.n0 a_48172_17760.t1 8.47322
R25879 a_48172_17760.n1 a_48172_17760.n0 0.103627
R25880 a_48172_17760.n0 a_48172_17760.t2 17.4516
R25881 a_48172_17760.n1 a_48172_17760.t3 15.0435
R25882 a_48070_17673.n0 a_48070_17673.t3 15.0005
R25883 a_48070_17673.t0 a_48070_17673.n0 17.9114
R25884 a_48070_17673.n1 a_48070_17673.t1 17.0005
R25885 a_48070_17673.n0 a_48070_17673.n1 0.655551
R25886 a_48070_17673.n1 a_48070_17673.t2 15.2176
R25887 a_47661_17734.t1 a_47661_17734.n2 17.9378
R25888 a_47661_17734.n2 a_47661_17734.t0 18.3531
R25889 a_47661_17734.n2 a_47661_17734.n1 3.38952
R25890 a_47661_17734.n1 a_47661_17734.n0 0.498937
R25891 a_47661_17734.n0 a_47661_17734.t2 17.1232
R25892 a_47661_17734.n0 a_47661_17734.t3 18.4279
R25893 a_47661_17734.n1 a_47661_17734.t4 15.4204
R25894 a_47375_17416.t0 a_47375_17416.n0 18.6222
R25895 a_47375_17416.n0 a_47375_17416.t2 17.0005
R25896 a_47375_17416.n1 a_47375_17416.t1 17.0005
R25897 a_47375_17416.n0 a_47375_17416.n1 3.28463
R25898 a_47375_17416.n1 a_47375_17416.t3 18.3191
R25899 a_47635_17639.t0 a_47635_17639.n1 17.3352
R25900 a_47635_17639.n1 a_47635_17639.t1 17.2651
R25901 a_47635_17639.n1 a_47635_17639.n0 0.948441
R25902 a_47635_17639.n0 a_47635_17639.t2 17.3305
R25903 a_47635_17639.n0 a_47635_17639.t3 15.4436
R25904 a_46919_17714.t0 a_46919_17714.n1 17.1443
R25905 a_46919_17714.n1 a_46919_17714.n0 0.743
R25906 a_46919_17714.n0 a_46919_17714.t2 8.65706
R25907 a_46919_17714.n0 a_46919_17714.t1 8.71106
R25908 a_46919_17714.n1 a_46919_17714.t3 15.731
R25909 a_46530_17398.t0 a_46530_17398.n0 8.81393
R25910 a_46530_17398.n0 a_46530_17398.t2 15.4488
R25911 a_46530_17398.n0 a_46530_17398.t1 6.09623
R25912 a_44289_17490.t3 a_44289_17490.n0 8.8328
R25913 a_44289_17490.n2 a_44289_17490.n3 1.14175
R25914 a_44289_17490.n1 a_44289_17490.n2 1.14175
R25915 a_44289_17490.n0 a_44289_17490.n1 1.14175
R25916 a_44289_17490.n3 a_44289_17490.t0 8.8328
R25917 a_44289_17490.n3 a_44289_17490.t6 8.8328
R25918 a_44289_17490.n2 a_44289_17490.t1 8.8328
R25919 a_44289_17490.n2 a_44289_17490.t7 8.8318
R25920 a_44289_17490.n1 a_44289_17490.t2 8.8328
R25921 a_44289_17490.n1 a_44289_17490.t5 8.8318
R25922 a_44289_17490.n0 a_44289_17490.t4 8.8318
R25923 a_42306_17493.t0 a_42306_17493.t1 35.1591
R25924 a_41430_17429.t0 a_41430_17429.t1 35.2643
R25925 a_46225_17794.t0 a_46225_17794.n0 17.1718
R25926 a_46225_17794.n0 a_46225_17794.t1 9.7433
R25927 a_46225_17794.n0 a_46225_17794.t2 15.4943
R25928 a_43201_17694.t0 a_43201_17694.n0 8.76769
R25929 a_43201_17694.n0 a_43201_17694.t2 15.0661
R25930 a_43201_17694.n0 a_43201_17694.t1 5.94842
R25931 a_42628_17633.t0 a_42628_17633.n0 17.0005
R25932 a_42628_17633.n0 a_42628_17633.t1 18.2612
R25933 a_42628_17633.n0 a_42628_17633.t2 15.5529
R25934 a_42400_17493.t1 a_42400_17493.n0 17.5293
R25935 a_42400_17493.n0 a_42400_17493.t0 17.726
R25936 a_42400_17493.n0 a_42400_17493.t2 15.773
R25937 a_40298_17417.n0 a_40298_17417.t0 8.46601
R25938 a_40298_17417.t1 a_40298_17417.n0 9.03504
R25939 a_40298_17417.n0 a_40298_17417.t2 9.14806
R25940 a_41652_17760.t0 a_41652_17760.n1 17.3368
R25941 a_41652_17760.n0 a_41652_17760.t1 8.47322
R25942 a_41652_17760.n1 a_41652_17760.n0 0.103627
R25943 a_41652_17760.n0 a_41652_17760.t2 17.4516
R25944 a_41652_17760.n1 a_41652_17760.t3 15.0435
R25945 a_41550_17673.n0 a_41550_17673.t3 15.0005
R25946 a_41550_17673.t0 a_41550_17673.n0 17.9114
R25947 a_41550_17673.n1 a_41550_17673.t1 17.0005
R25948 a_41550_17673.n0 a_41550_17673.n1 0.655551
R25949 a_41550_17673.n1 a_41550_17673.t2 15.2176
R25950 a_41141_17734.t0 a_41141_17734.n2 17.1232
R25951 a_41141_17734.n2 a_41141_17734.n0 0.498937
R25952 a_41141_17734.n2 a_41141_17734.t1 18.4279
R25953 a_41141_17734.n0 a_41141_17734.n1 3.38952
R25954 a_41141_17734.n1 a_41141_17734.t3 18.3531
R25955 a_41141_17734.n1 a_41141_17734.t2 17.9378
R25956 a_41141_17734.n0 a_41141_17734.t4 15.4204
R25957 a_40855_17416.t0 a_40855_17416.n1 17.0005
R25958 a_40855_17416.n1 a_40855_17416.t1 18.3191
R25959 a_40855_17416.n0 a_40855_17416.t2 17.0005
R25960 a_40855_17416.n1 a_40855_17416.n0 3.28463
R25961 a_40855_17416.n0 a_40855_17416.t3 18.6222
R25962 a_41115_17639.t0 a_41115_17639.n1 17.3305
R25963 a_41115_17639.n1 a_41115_17639.n0 0.948441
R25964 a_41115_17639.n0 a_41115_17639.t1 17.2651
R25965 a_41115_17639.n0 a_41115_17639.t2 17.3352
R25966 a_41115_17639.n1 a_41115_17639.t3 15.4436
R25967 a_40399_17714.t0 a_40399_17714.n1 17.1443
R25968 a_40399_17714.n1 a_40399_17714.n0 0.743
R25969 a_40399_17714.n0 a_40399_17714.t2 8.65706
R25970 a_40399_17714.n0 a_40399_17714.t1 8.71106
R25971 a_40399_17714.n1 a_40399_17714.t3 15.731
R25972 a_40010_17398.t0 a_40010_17398.n0 8.81393
R25973 a_40010_17398.n0 a_40010_17398.t2 15.4488
R25974 a_40010_17398.n0 a_40010_17398.t1 6.09623
R25975 a_37769_17490.t3 a_37769_17490.n0 8.8328
R25976 a_37769_17490.n2 a_37769_17490.n3 1.14175
R25977 a_37769_17490.n1 a_37769_17490.n2 1.14175
R25978 a_37769_17490.n0 a_37769_17490.n1 1.14175
R25979 a_37769_17490.n3 a_37769_17490.t0 8.8328
R25980 a_37769_17490.n3 a_37769_17490.t4 8.8328
R25981 a_37769_17490.n2 a_37769_17490.t1 8.8328
R25982 a_37769_17490.n2 a_37769_17490.t5 8.8318
R25983 a_37769_17490.n1 a_37769_17490.t2 8.8328
R25984 a_37769_17490.n1 a_37769_17490.t7 8.8318
R25985 a_37769_17490.n0 a_37769_17490.t6 8.8318
R25986 a_35786_17493.t0 a_35786_17493.t1 35.1591
R25987 a_34910_17429.t0 a_34910_17429.t1 35.2643
R25988 a_39705_17794.t0 a_39705_17794.n0 17.1718
R25989 a_39705_17794.n0 a_39705_17794.t1 9.7433
R25990 a_39705_17794.n0 a_39705_17794.t2 15.4943
R25991 a_36681_17694.t0 a_36681_17694.n0 8.76769
R25992 a_36681_17694.n0 a_36681_17694.t2 15.0661
R25993 a_36681_17694.n0 a_36681_17694.t1 5.94842
R25994 a_36108_17633.t0 a_36108_17633.n0 17.0005
R25995 a_36108_17633.n0 a_36108_17633.t1 18.2612
R25996 a_36108_17633.n0 a_36108_17633.t2 15.5529
R25997 a_35880_17493.t1 a_35880_17493.n0 17.5293
R25998 a_35880_17493.n0 a_35880_17493.t0 17.726
R25999 a_35880_17493.n0 a_35880_17493.t2 15.773
R26000 a_33778_17417.t1 a_33778_17417.n0 8.46601
R26001 a_33778_17417.n0 a_33778_17417.t2 9.03504
R26002 a_33778_17417.n0 a_33778_17417.t0 9.14806
R26003 a_35132_17760.t0 a_35132_17760.n1 17.3368
R26004 a_35132_17760.n0 a_35132_17760.t1 8.47322
R26005 a_35132_17760.n1 a_35132_17760.n0 0.103627
R26006 a_35132_17760.n0 a_35132_17760.t2 17.4516
R26007 a_35132_17760.n1 a_35132_17760.t3 15.0435
R26008 a_35030_17673.n0 a_35030_17673.t3 15.0005
R26009 a_35030_17673.t0 a_35030_17673.n0 17.9114
R26010 a_35030_17673.n1 a_35030_17673.t1 17.0005
R26011 a_35030_17673.n0 a_35030_17673.n1 0.655551
R26012 a_35030_17673.n1 a_35030_17673.t2 15.2176
R26013 a_34621_17734.t0 a_34621_17734.n2 17.9378
R26014 a_34621_17734.n2 a_34621_17734.t1 18.3531
R26015 a_34621_17734.n2 a_34621_17734.n1 3.38952
R26016 a_34621_17734.n1 a_34621_17734.n0 0.498937
R26017 a_34621_17734.n0 a_34621_17734.t2 17.1232
R26018 a_34621_17734.n0 a_34621_17734.t3 18.4279
R26019 a_34621_17734.n1 a_34621_17734.t4 15.4204
R26020 a_34335_17416.t0 a_34335_17416.n1 17.0005
R26021 a_34335_17416.n1 a_34335_17416.t1 18.6222
R26022 a_34335_17416.n0 a_34335_17416.t3 17.0005
R26023 a_34335_17416.n1 a_34335_17416.n0 3.28463
R26024 a_34335_17416.n0 a_34335_17416.t2 18.3191
R26025 a_34595_17639.t0 a_34595_17639.n1 17.3352
R26026 a_34595_17639.n1 a_34595_17639.t1 17.2651
R26027 a_34595_17639.n1 a_34595_17639.n0 0.948441
R26028 a_34595_17639.n0 a_34595_17639.t2 17.3305
R26029 a_34595_17639.n0 a_34595_17639.t3 15.4436
R26030 a_33879_17714.t1 a_33879_17714.n1 17.1443
R26031 a_33879_17714.n1 a_33879_17714.n0 0.743
R26032 a_33879_17714.n0 a_33879_17714.t0 8.65706
R26033 a_33879_17714.n0 a_33879_17714.t2 8.71106
R26034 a_33879_17714.n1 a_33879_17714.t3 15.731
R26035 a_33490_17398.t0 a_33490_17398.n0 8.81393
R26036 a_33490_17398.n0 a_33490_17398.t2 15.4488
R26037 a_33490_17398.n0 a_33490_17398.t1 6.09623
R26038 a_31249_17490.t3 a_31249_17490.n0 8.8328
R26039 a_31249_17490.n2 a_31249_17490.n3 1.14175
R26040 a_31249_17490.n1 a_31249_17490.n2 1.14175
R26041 a_31249_17490.n0 a_31249_17490.n1 1.14175
R26042 a_31249_17490.n3 a_31249_17490.t0 8.8328
R26043 a_31249_17490.n3 a_31249_17490.t4 8.8328
R26044 a_31249_17490.n2 a_31249_17490.t1 8.8328
R26045 a_31249_17490.n2 a_31249_17490.t5 8.8318
R26046 a_31249_17490.n1 a_31249_17490.t2 8.8328
R26047 a_31249_17490.n1 a_31249_17490.t7 8.8318
R26048 a_31249_17490.n0 a_31249_17490.t6 8.8318
R26049 a_29266_17493.t0 a_29266_17493.t1 35.1591
R26050 a_28390_17429.t0 a_28390_17429.t1 35.2643
R26051 a_33185_17794.t0 a_33185_17794.n0 17.1718
R26052 a_33185_17794.n0 a_33185_17794.t1 9.7433
R26053 a_33185_17794.n0 a_33185_17794.t2 15.4943
R26054 a_30161_17694.t0 a_30161_17694.n0 8.76769
R26055 a_30161_17694.n0 a_30161_17694.t2 15.0661
R26056 a_30161_17694.n0 a_30161_17694.t1 5.94842
R26057 a_29588_17633.t0 a_29588_17633.n0 17.0005
R26058 a_29588_17633.n0 a_29588_17633.t1 18.2612
R26059 a_29588_17633.n0 a_29588_17633.t2 15.5529
R26060 a_29360_17493.t1 a_29360_17493.n0 17.5293
R26061 a_29360_17493.n0 a_29360_17493.t0 17.726
R26062 a_29360_17493.n0 a_29360_17493.t2 15.773
R26063 a_27258_17417.n0 a_27258_17417.t0 8.46601
R26064 a_27258_17417.t1 a_27258_17417.n0 9.03504
R26065 a_27258_17417.n0 a_27258_17417.t2 9.14806
R26066 a_28612_17760.t0 a_28612_17760.n1 17.3368
R26067 a_28612_17760.n0 a_28612_17760.t1 8.47322
R26068 a_28612_17760.n1 a_28612_17760.n0 0.103627
R26069 a_28612_17760.n0 a_28612_17760.t2 17.4516
R26070 a_28612_17760.n1 a_28612_17760.t3 15.0435
R26071 a_28510_17673.n0 a_28510_17673.t3 15.0005
R26072 a_28510_17673.t0 a_28510_17673.n0 17.9114
R26073 a_28510_17673.n1 a_28510_17673.t1 17.0005
R26074 a_28510_17673.n0 a_28510_17673.n1 0.655551
R26075 a_28510_17673.n1 a_28510_17673.t2 15.2176
R26076 a_28101_17734.t0 a_28101_17734.n2 17.9378
R26077 a_28101_17734.n2 a_28101_17734.t1 18.3531
R26078 a_28101_17734.n2 a_28101_17734.n1 3.38952
R26079 a_28101_17734.n1 a_28101_17734.n0 0.498937
R26080 a_28101_17734.n0 a_28101_17734.t2 17.1232
R26081 a_28101_17734.n0 a_28101_17734.t3 18.4279
R26082 a_28101_17734.n1 a_28101_17734.t4 15.4204
R26083 a_27815_17416.t0 a_27815_17416.n1 17.0005
R26084 a_27815_17416.n1 a_27815_17416.t1 18.6222
R26085 a_27815_17416.n0 a_27815_17416.t2 17.0005
R26086 a_27815_17416.n1 a_27815_17416.n0 3.28463
R26087 a_27815_17416.n0 a_27815_17416.t3 18.3191
R26088 a_28075_17639.t0 a_28075_17639.n1 17.3352
R26089 a_28075_17639.n1 a_28075_17639.t1 17.2651
R26090 a_28075_17639.n1 a_28075_17639.n0 0.948441
R26091 a_28075_17639.n0 a_28075_17639.t2 17.3305
R26092 a_28075_17639.n0 a_28075_17639.t3 15.4436
R26093 a_27359_17714.t1 a_27359_17714.n1 17.1443
R26094 a_27359_17714.n1 a_27359_17714.n0 0.743
R26095 a_27359_17714.n0 a_27359_17714.t2 8.65706
R26096 a_27359_17714.n0 a_27359_17714.t0 8.71106
R26097 a_27359_17714.n1 a_27359_17714.t3 15.731
R26098 a_26970_17398.t0 a_26970_17398.n0 8.81393
R26099 a_26970_17398.n0 a_26970_17398.t2 15.4488
R26100 a_26970_17398.n0 a_26970_17398.t1 6.09623
R26101 a_24729_17490.t3 a_24729_17490.n0 8.8328
R26102 a_24729_17490.n2 a_24729_17490.n3 1.14175
R26103 a_24729_17490.n1 a_24729_17490.n2 1.14175
R26104 a_24729_17490.n0 a_24729_17490.n1 1.14175
R26105 a_24729_17490.n3 a_24729_17490.t0 8.8328
R26106 a_24729_17490.n3 a_24729_17490.t5 8.8328
R26107 a_24729_17490.n2 a_24729_17490.t1 8.8328
R26108 a_24729_17490.n2 a_24729_17490.t6 8.8318
R26109 a_24729_17490.n1 a_24729_17490.t2 8.8328
R26110 a_24729_17490.n1 a_24729_17490.t7 8.8318
R26111 a_24729_17490.n0 a_24729_17490.t4 8.8318
R26112 a_22746_17493.t0 a_22746_17493.t1 35.1591
R26113 a_21870_17429.t0 a_21870_17429.t1 35.2643
R26114 a_26665_17794.t0 a_26665_17794.n0 17.1718
R26115 a_26665_17794.n0 a_26665_17794.t1 9.7433
R26116 a_26665_17794.n0 a_26665_17794.t2 15.4943
R26117 a_23641_17694.t0 a_23641_17694.n0 8.76769
R26118 a_23641_17694.n0 a_23641_17694.t2 15.0661
R26119 a_23641_17694.n0 a_23641_17694.t1 5.94842
R26120 a_23068_17633.n0 a_23068_17633.t1 17.0005
R26121 a_23068_17633.t0 a_23068_17633.n0 18.2612
R26122 a_23068_17633.n0 a_23068_17633.t2 15.5529
R26123 a_22840_17493.t0 a_22840_17493.n0 17.5293
R26124 a_22840_17493.n0 a_22840_17493.t1 17.726
R26125 a_22840_17493.n0 a_22840_17493.t2 15.773
R26126 a_20738_17417.t1 a_20738_17417.n0 8.46601
R26127 a_20738_17417.n0 a_20738_17417.t2 9.03504
R26128 a_20738_17417.n0 a_20738_17417.t0 9.14806
R26129 a_22092_17760.t0 a_22092_17760.n1 17.3368
R26130 a_22092_17760.n0 a_22092_17760.t1 8.47322
R26131 a_22092_17760.n1 a_22092_17760.n0 0.103627
R26132 a_22092_17760.n0 a_22092_17760.t2 17.4516
R26133 a_22092_17760.n1 a_22092_17760.t3 15.0435
R26134 a_21990_17673.n0 a_21990_17673.t3 15.0005
R26135 a_21990_17673.t0 a_21990_17673.n0 17.9114
R26136 a_21990_17673.n1 a_21990_17673.t1 17.0005
R26137 a_21990_17673.n0 a_21990_17673.n1 0.655551
R26138 a_21990_17673.n1 a_21990_17673.t2 15.2176
R26139 a_21581_17734.t0 a_21581_17734.n2 17.1232
R26140 a_21581_17734.n2 a_21581_17734.n0 0.498937
R26141 a_21581_17734.n2 a_21581_17734.t1 18.4279
R26142 a_21581_17734.n0 a_21581_17734.n1 3.38952
R26143 a_21581_17734.n1 a_21581_17734.t3 18.3531
R26144 a_21581_17734.n1 a_21581_17734.t2 17.9378
R26145 a_21581_17734.n0 a_21581_17734.t4 15.4204
R26146 a_21295_17416.n0 a_21295_17416.t1 17.0005
R26147 a_21295_17416.t0 a_21295_17416.n0 18.3191
R26148 a_21295_17416.n1 a_21295_17416.t2 17.0005
R26149 a_21295_17416.n0 a_21295_17416.n1 3.28463
R26150 a_21295_17416.n1 a_21295_17416.t3 18.6222
R26151 a_21555_17639.t0 a_21555_17639.n1 17.2651
R26152 a_21555_17639.n1 a_21555_17639.t1 17.3352
R26153 a_21555_17639.n1 a_21555_17639.n0 0.948441
R26154 a_21555_17639.n0 a_21555_17639.t2 17.3305
R26155 a_21555_17639.n0 a_21555_17639.t3 15.4436
R26156 a_20839_17714.t1 a_20839_17714.n1 17.1443
R26157 a_20839_17714.n1 a_20839_17714.n0 0.743
R26158 a_20839_17714.n0 a_20839_17714.t0 8.65706
R26159 a_20839_17714.n0 a_20839_17714.t2 8.71106
R26160 a_20839_17714.n1 a_20839_17714.t3 15.731
R26161 a_20450_17398.t0 a_20450_17398.n0 8.81393
R26162 a_20450_17398.n0 a_20450_17398.t2 15.4488
R26163 a_20450_17398.n0 a_20450_17398.t1 6.09623
R26164 a_18209_17490.t3 a_18209_17490.n0 8.8328
R26165 a_18209_17490.n2 a_18209_17490.n3 1.14175
R26166 a_18209_17490.n1 a_18209_17490.n2 1.14175
R26167 a_18209_17490.n0 a_18209_17490.n1 1.14175
R26168 a_18209_17490.n3 a_18209_17490.t0 8.8328
R26169 a_18209_17490.n3 a_18209_17490.t5 8.8328
R26170 a_18209_17490.n2 a_18209_17490.t1 8.8328
R26171 a_18209_17490.n2 a_18209_17490.t6 8.8318
R26172 a_18209_17490.n1 a_18209_17490.t2 8.8328
R26173 a_18209_17490.n1 a_18209_17490.t7 8.8318
R26174 a_18209_17490.n0 a_18209_17490.t4 8.8318
R26175 a_16226_17493.t0 a_16226_17493.t1 35.1591
R26176 a_15350_17429.t0 a_15350_17429.t1 35.2643
R26177 a_20145_17794.t0 a_20145_17794.n0 17.1718
R26178 a_20145_17794.n0 a_20145_17794.t1 9.7433
R26179 a_20145_17794.n0 a_20145_17794.t2 15.4943
R26180 a_17121_17694.t0 a_17121_17694.n0 8.76769
R26181 a_17121_17694.n0 a_17121_17694.t2 15.0661
R26182 a_17121_17694.n0 a_17121_17694.t1 5.94842
R26183 a_16548_17633.n0 a_16548_17633.t1 17.0005
R26184 a_16548_17633.t0 a_16548_17633.n0 18.2612
R26185 a_16548_17633.n0 a_16548_17633.t2 15.5529
R26186 a_16320_17493.t1 a_16320_17493.n0 17.5293
R26187 a_16320_17493.n0 a_16320_17493.t0 17.726
R26188 a_16320_17493.n0 a_16320_17493.t2 15.773
R26189 a_14218_17417.t1 a_14218_17417.n0 8.46601
R26190 a_14218_17417.n0 a_14218_17417.t2 9.03504
R26191 a_14218_17417.n0 a_14218_17417.t0 9.14806
R26192 a_15572_17760.t0 a_15572_17760.n1 17.3368
R26193 a_15572_17760.n0 a_15572_17760.t1 8.47322
R26194 a_15572_17760.n1 a_15572_17760.n0 0.103627
R26195 a_15572_17760.n0 a_15572_17760.t2 17.4516
R26196 a_15572_17760.n1 a_15572_17760.t3 15.0435
R26197 a_15470_17673.n0 a_15470_17673.t3 15.0005
R26198 a_15470_17673.t0 a_15470_17673.n0 17.9114
R26199 a_15470_17673.n1 a_15470_17673.t1 17.0005
R26200 a_15470_17673.n0 a_15470_17673.n1 0.655551
R26201 a_15470_17673.n1 a_15470_17673.t2 15.2176
R26202 a_15061_17734.t0 a_15061_17734.n2 17.9378
R26203 a_15061_17734.n2 a_15061_17734.t3 18.3531
R26204 a_15061_17734.n2 a_15061_17734.n1 3.38952
R26205 a_15061_17734.n1 a_15061_17734.n0 0.498937
R26206 a_15061_17734.n0 a_15061_17734.t1 17.1232
R26207 a_15061_17734.n0 a_15061_17734.t2 18.4279
R26208 a_15061_17734.n1 a_15061_17734.t4 15.4204
R26209 a_14775_17416.t0 a_14775_17416.n1 17.0005
R26210 a_14775_17416.n1 a_14775_17416.t3 18.6222
R26211 a_14775_17416.n0 a_14775_17416.t2 17.0005
R26212 a_14775_17416.n1 a_14775_17416.n0 3.28463
R26213 a_14775_17416.n0 a_14775_17416.t1 18.3191
R26214 a_15035_17639.t0 a_15035_17639.n1 17.2651
R26215 a_15035_17639.n1 a_15035_17639.t1 17.3352
R26216 a_15035_17639.n1 a_15035_17639.n0 0.948441
R26217 a_15035_17639.n0 a_15035_17639.t2 17.3305
R26218 a_15035_17639.n0 a_15035_17639.t3 15.4436
R26219 a_14319_17714.t1 a_14319_17714.n1 17.1443
R26220 a_14319_17714.n1 a_14319_17714.n0 0.743
R26221 a_14319_17714.n0 a_14319_17714.t0 8.65706
R26222 a_14319_17714.n0 a_14319_17714.t2 8.71106
R26223 a_14319_17714.n1 a_14319_17714.t3 15.731
R26224 a_13930_17398.t0 a_13930_17398.n0 8.81393
R26225 a_13930_17398.n0 a_13930_17398.t2 15.4488
R26226 a_13930_17398.n0 a_13930_17398.t1 6.09623
R26227 a_11689_17490.t3 a_11689_17490.n0 8.8328
R26228 a_11689_17490.n2 a_11689_17490.n3 1.14175
R26229 a_11689_17490.n1 a_11689_17490.n2 1.14175
R26230 a_11689_17490.n0 a_11689_17490.n1 1.14175
R26231 a_11689_17490.n3 a_11689_17490.t0 8.8328
R26232 a_11689_17490.n3 a_11689_17490.t6 8.8328
R26233 a_11689_17490.n2 a_11689_17490.t1 8.8328
R26234 a_11689_17490.n2 a_11689_17490.t7 8.8318
R26235 a_11689_17490.n1 a_11689_17490.t2 8.8328
R26236 a_11689_17490.n1 a_11689_17490.t5 8.8318
R26237 a_11689_17490.n0 a_11689_17490.t4 8.8318
R26238 a_9706_17493.t0 a_9706_17493.t1 35.1591
R26239 a_8830_17429.t0 a_8830_17429.t1 35.2643
R26240 a_13625_17794.t0 a_13625_17794.n0 17.1718
R26241 a_13625_17794.n0 a_13625_17794.t1 9.7433
R26242 a_13625_17794.n0 a_13625_17794.t2 15.4943
R26243 a_10601_17694.t0 a_10601_17694.n0 8.76769
R26244 a_10601_17694.n0 a_10601_17694.t2 15.0661
R26245 a_10601_17694.n0 a_10601_17694.t1 5.94842
R26246 a_10028_17633.n0 a_10028_17633.t1 17.0005
R26247 a_10028_17633.t0 a_10028_17633.n0 18.2612
R26248 a_10028_17633.n0 a_10028_17633.t2 15.5529
R26249 a_9800_17493.t0 a_9800_17493.n0 17.5293
R26250 a_9800_17493.n0 a_9800_17493.t1 17.726
R26251 a_9800_17493.n0 a_9800_17493.t2 15.773
R26252 a_7698_17417.n0 a_7698_17417.t0 8.46601
R26253 a_7698_17417.t1 a_7698_17417.n0 9.03504
R26254 a_7698_17417.n0 a_7698_17417.t2 9.14806
R26255 a_9052_17760.t0 a_9052_17760.n1 17.3368
R26256 a_9052_17760.n0 a_9052_17760.t1 8.47322
R26257 a_9052_17760.n1 a_9052_17760.n0 0.103627
R26258 a_9052_17760.n0 a_9052_17760.t2 17.4516
R26259 a_9052_17760.n1 a_9052_17760.t3 15.0435
R26260 a_8950_17673.n0 a_8950_17673.t3 15.0005
R26261 a_8950_17673.t0 a_8950_17673.n0 17.9114
R26262 a_8950_17673.n1 a_8950_17673.t1 17.0005
R26263 a_8950_17673.n0 a_8950_17673.n1 0.655551
R26264 a_8950_17673.n1 a_8950_17673.t2 15.2176
R26265 a_8541_17734.t0 a_8541_17734.n2 17.9378
R26266 a_8541_17734.n2 a_8541_17734.t1 18.3531
R26267 a_8541_17734.n2 a_8541_17734.n1 3.38952
R26268 a_8541_17734.n1 a_8541_17734.n0 0.498937
R26269 a_8541_17734.n0 a_8541_17734.t2 17.1232
R26270 a_8541_17734.n0 a_8541_17734.t3 18.4279
R26271 a_8541_17734.n1 a_8541_17734.t4 15.4204
R26272 a_8255_17416.t0 a_8255_17416.n1 17.0005
R26273 a_8255_17416.n1 a_8255_17416.t1 18.6222
R26274 a_8255_17416.n0 a_8255_17416.t3 17.0005
R26275 a_8255_17416.n1 a_8255_17416.n0 3.28463
R26276 a_8255_17416.n0 a_8255_17416.t2 18.3191
R26277 a_8515_17639.t0 a_8515_17639.n1 17.3352
R26278 a_8515_17639.n1 a_8515_17639.t1 17.2651
R26279 a_8515_17639.n1 a_8515_17639.n0 0.948441
R26280 a_8515_17639.n0 a_8515_17639.t2 17.3305
R26281 a_8515_17639.n0 a_8515_17639.t3 15.4436
R26282 a_7799_17714.t0 a_7799_17714.n1 17.1443
R26283 a_7799_17714.n1 a_7799_17714.n0 0.743
R26284 a_7799_17714.n0 a_7799_17714.t2 8.65706
R26285 a_7799_17714.n0 a_7799_17714.t1 8.71106
R26286 a_7799_17714.n1 a_7799_17714.t3 15.731
R26287 a_7410_17398.t0 a_7410_17398.n0 8.81393
R26288 a_7410_17398.n0 a_7410_17398.t2 15.4488
R26289 a_7410_17398.n0 a_7410_17398.t1 6.09623
R26290 a_5169_17490.t3 a_5169_17490.n0 8.8328
R26291 a_5169_17490.n2 a_5169_17490.n3 1.14175
R26292 a_5169_17490.n1 a_5169_17490.n2 1.14175
R26293 a_5169_17490.n0 a_5169_17490.n1 1.14175
R26294 a_5169_17490.n3 a_5169_17490.t0 8.8328
R26295 a_5169_17490.n3 a_5169_17490.t4 8.8328
R26296 a_5169_17490.n2 a_5169_17490.t1 8.8328
R26297 a_5169_17490.n2 a_5169_17490.t5 8.8318
R26298 a_5169_17490.n1 a_5169_17490.t2 8.8328
R26299 a_5169_17490.n1 a_5169_17490.t7 8.8318
R26300 a_5169_17490.n0 a_5169_17490.t6 8.8318
R26301 a_3186_17493.t0 a_3186_17493.t1 35.1591
R26302 a_2310_17429.t0 a_2310_17429.t1 35.2643
R26303 a_7105_17794.t0 a_7105_17794.n0 17.1718
R26304 a_7105_17794.n0 a_7105_17794.t1 9.7433
R26305 a_7105_17794.n0 a_7105_17794.t2 15.4943
R26306 a_4081_17694.t0 a_4081_17694.n0 8.76769
R26307 a_4081_17694.n0 a_4081_17694.t2 15.0661
R26308 a_4081_17694.n0 a_4081_17694.t1 5.94842
R26309 a_3508_17633.n0 a_3508_17633.t1 17.0005
R26310 a_3508_17633.t0 a_3508_17633.n0 18.2612
R26311 a_3508_17633.n0 a_3508_17633.t2 15.5529
R26312 a_3280_17493.t1 a_3280_17493.n0 17.5293
R26313 a_3280_17493.n0 a_3280_17493.t0 17.726
R26314 a_3280_17493.n0 a_3280_17493.t2 15.773
R26315 a_1178_17417.t1 a_1178_17417.n0 8.46601
R26316 a_1178_17417.n0 a_1178_17417.t2 9.03504
R26317 a_1178_17417.n0 a_1178_17417.t0 9.14806
R26318 a_2532_17760.t0 a_2532_17760.n1 17.3368
R26319 a_2532_17760.n0 a_2532_17760.t1 8.47322
R26320 a_2532_17760.n1 a_2532_17760.n0 0.103627
R26321 a_2532_17760.n0 a_2532_17760.t2 17.4516
R26322 a_2532_17760.n1 a_2532_17760.t3 15.0435
R26323 a_2430_17673.n0 a_2430_17673.t3 15.0005
R26324 a_2430_17673.t0 a_2430_17673.n0 17.9114
R26325 a_2430_17673.n1 a_2430_17673.t1 17.0005
R26326 a_2430_17673.n0 a_2430_17673.n1 0.655551
R26327 a_2430_17673.n1 a_2430_17673.t2 15.2176
R26328 a_2021_17734.t0 a_2021_17734.n2 17.1232
R26329 a_2021_17734.n2 a_2021_17734.n0 0.498937
R26330 a_2021_17734.n2 a_2021_17734.t1 18.4279
R26331 a_2021_17734.n0 a_2021_17734.n1 3.38952
R26332 a_2021_17734.n1 a_2021_17734.t3 18.3531
R26333 a_2021_17734.n1 a_2021_17734.t2 17.9378
R26334 a_2021_17734.n0 a_2021_17734.t4 15.4204
R26335 a_1735_17416.t0 a_1735_17416.n1 17.0005
R26336 a_1735_17416.n1 a_1735_17416.t3 18.6222
R26337 a_1735_17416.n0 a_1735_17416.t2 17.0005
R26338 a_1735_17416.n1 a_1735_17416.n0 3.28463
R26339 a_1735_17416.n0 a_1735_17416.t1 18.3191
R26340 a_1995_17639.t0 a_1995_17639.n1 17.2651
R26341 a_1995_17639.n1 a_1995_17639.t1 17.3352
R26342 a_1995_17639.n1 a_1995_17639.n0 0.948441
R26343 a_1995_17639.n0 a_1995_17639.t2 17.3305
R26344 a_1995_17639.n0 a_1995_17639.t3 15.4436
R26345 a_1279_17714.t2 a_1279_17714.n1 17.1443
R26346 a_1279_17714.n1 a_1279_17714.n0 0.743
R26347 a_1279_17714.n0 a_1279_17714.t0 8.65706
R26348 a_1279_17714.n0 a_1279_17714.t1 8.71106
R26349 a_1279_17714.n1 a_1279_17714.t3 15.731
R26350 a_n2648_3264.t0 a_n2648_3264.n0 8.76917
R26351 a_n2648_3264.n0 a_n2648_3264.t1 6.00728
R26352 a_n2648_3264.n0 a_n2648_3264.n15 27.6619
R26353 a_n2648_3264.n15 a_n2648_3264.n14 0.557571
R26354 a_n2648_3264.n14 a_n2648_3264.n13 4.56629
R26355 a_n2648_3264.n13 a_n2648_3264.n12 0.557571
R26356 a_n2648_3264.n12 a_n2648_3264.n11 4.56629
R26357 a_n2648_3264.n11 a_n2648_3264.n10 0.557571
R26358 a_n2648_3264.n10 a_n2648_3264.n9 4.56629
R26359 a_n2648_3264.n9 a_n2648_3264.n8 0.557571
R26360 a_n2648_3264.n8 a_n2648_3264.n7 4.56629
R26361 a_n2648_3264.n7 a_n2648_3264.n6 0.557571
R26362 a_n2648_3264.n6 a_n2648_3264.n5 4.56629
R26363 a_n2648_3264.n5 a_n2648_3264.n4 0.557571
R26364 a_n2648_3264.n4 a_n2648_3264.n3 4.56629
R26365 a_n2648_3264.n3 a_n2648_3264.n2 0.557571
R26366 a_n2648_3264.n2 a_n2648_3264.n1 4.56629
R26367 a_n2648_3264.n1 a_n2648_3264.t10 30.2193
R26368 a_n2648_3264.n15 a_n2648_3264.t9 31.6835
R26369 a_n2648_3264.n14 a_n2648_3264.t17 29.6622
R26370 a_n2648_3264.n13 a_n2648_3264.t8 31.6835
R26371 a_n2648_3264.n12 a_n2648_3264.t16 29.6622
R26372 a_n2648_3264.n11 a_n2648_3264.t7 31.6835
R26373 a_n2648_3264.n10 a_n2648_3264.t15 29.6622
R26374 a_n2648_3264.n9 a_n2648_3264.t6 31.6835
R26375 a_n2648_3264.n8 a_n2648_3264.t14 29.6622
R26376 a_n2648_3264.n7 a_n2648_3264.t5 31.6835
R26377 a_n2648_3264.n6 a_n2648_3264.t13 29.6622
R26378 a_n2648_3264.n5 a_n2648_3264.t4 31.6835
R26379 a_n2648_3264.n4 a_n2648_3264.t12 29.6622
R26380 a_n2648_3264.n3 a_n2648_3264.t3 31.6835
R26381 a_n2648_3264.n2 a_n2648_3264.t11 29.6622
R26382 a_n2648_3264.n1 a_n2648_3264.t2 31.6835
R26383 a_890_17398.t0 a_890_17398.n0 8.81393
R26384 a_890_17398.n0 a_890_17398.t2 15.4488
R26385 a_890_17398.n0 a_890_17398.t1 6.09623
R26386 a_585_17794.t0 a_585_17794.n0 17.1718
R26387 a_585_17794.n0 a_585_17794.t1 9.7433
R26388 a_585_17794.n0 a_585_17794.t2 15.4943
R26389 a_50643_17750.t3 a_50643_17750.n5 10.0462
R26390 a_50643_17750.n5 a_50643_17750.t6 8.90498
R26391 a_50643_17750.n5 a_50643_17750.n0 1.09706
R26392 a_50643_17750.n0 a_50643_17750.n4 1.09706
R26393 a_50643_17750.n4 a_50643_17750.t4 8.90498
R26394 a_50643_17750.n4 a_50643_17750.t2 10.0462
R26395 a_50643_17750.n0 a_50643_17750.n1 18.263
R26396 a_50643_17750.n3 a_50643_17750.t9 17.0005
R26397 a_50643_17750.n1 a_50643_17750.n3 1.37206
R26398 a_50643_17750.n3 a_50643_17750.t1 18.9255
R26399 a_50643_17750.n2 a_50643_17750.t7 17.0005
R26400 a_50643_17750.n1 a_50643_17750.n2 1.37206
R26401 a_50643_17750.n2 a_50643_17750.t0 18.9255
R26402 a_50643_17750.n1 a_50643_17750.t8 17.6708
R26403 a_50643_17750.n0 a_50643_17750.t5 8.81561
R26404 a_44123_17750.t3 a_44123_17750.n5 10.0462
R26405 a_44123_17750.n5 a_44123_17750.t6 8.90498
R26406 a_44123_17750.n5 a_44123_17750.n0 1.09706
R26407 a_44123_17750.n0 a_44123_17750.n4 1.09706
R26408 a_44123_17750.n4 a_44123_17750.t4 8.90498
R26409 a_44123_17750.n4 a_44123_17750.t2 10.0462
R26410 a_44123_17750.n0 a_44123_17750.n1 18.263
R26411 a_44123_17750.n3 a_44123_17750.t9 17.0005
R26412 a_44123_17750.n1 a_44123_17750.n3 1.37206
R26413 a_44123_17750.n3 a_44123_17750.t1 18.9255
R26414 a_44123_17750.n2 a_44123_17750.t7 17.0005
R26415 a_44123_17750.n1 a_44123_17750.n2 1.37206
R26416 a_44123_17750.n2 a_44123_17750.t0 18.9255
R26417 a_44123_17750.n1 a_44123_17750.t8 17.6708
R26418 a_44123_17750.n0 a_44123_17750.t5 8.81561
R26419 a_37603_17750.t9 a_37603_17750.n5 8.90498
R26420 a_37603_17750.n5 a_37603_17750.t3 10.0462
R26421 a_37603_17750.n5 a_37603_17750.n0 1.09706
R26422 a_37603_17750.n0 a_37603_17750.n4 1.09706
R26423 a_37603_17750.n4 a_37603_17750.t7 8.90498
R26424 a_37603_17750.n4 a_37603_17750.t2 10.0462
R26425 a_37603_17750.n0 a_37603_17750.n1 18.263
R26426 a_37603_17750.n3 a_37603_17750.t5 17.0005
R26427 a_37603_17750.n1 a_37603_17750.n3 1.37206
R26428 a_37603_17750.n3 a_37603_17750.t1 18.9255
R26429 a_37603_17750.n2 a_37603_17750.t4 17.0005
R26430 a_37603_17750.n1 a_37603_17750.n2 1.37206
R26431 a_37603_17750.n2 a_37603_17750.t0 18.9255
R26432 a_37603_17750.n1 a_37603_17750.t6 17.6708
R26433 a_37603_17750.n0 a_37603_17750.t8 8.81561
R26434 a_31083_17750.t3 a_31083_17750.n5 10.0462
R26435 a_31083_17750.n5 a_31083_17750.t9 8.90498
R26436 a_31083_17750.n5 a_31083_17750.n0 1.09706
R26437 a_31083_17750.n0 a_31083_17750.n4 1.09706
R26438 a_31083_17750.n4 a_31083_17750.t7 8.90498
R26439 a_31083_17750.n4 a_31083_17750.t2 10.0462
R26440 a_31083_17750.n0 a_31083_17750.n1 18.263
R26441 a_31083_17750.n3 a_31083_17750.t6 17.0005
R26442 a_31083_17750.n1 a_31083_17750.n3 1.37206
R26443 a_31083_17750.n3 a_31083_17750.t1 18.9255
R26444 a_31083_17750.n2 a_31083_17750.t4 17.0005
R26445 a_31083_17750.n1 a_31083_17750.n2 1.37206
R26446 a_31083_17750.n2 a_31083_17750.t0 18.9255
R26447 a_31083_17750.n1 a_31083_17750.t5 17.6708
R26448 a_31083_17750.n0 a_31083_17750.t8 8.81561
R26449 a_24563_17750.t3 a_24563_17750.n5 10.0462
R26450 a_24563_17750.n5 a_24563_17750.t8 8.90498
R26451 a_24563_17750.n5 a_24563_17750.n0 1.09706
R26452 a_24563_17750.n0 a_24563_17750.n4 1.09706
R26453 a_24563_17750.n4 a_24563_17750.t6 8.90498
R26454 a_24563_17750.n4 a_24563_17750.t2 10.0462
R26455 a_24563_17750.n0 a_24563_17750.n1 18.263
R26456 a_24563_17750.n3 a_24563_17750.t5 17.0005
R26457 a_24563_17750.n1 a_24563_17750.n3 1.37206
R26458 a_24563_17750.n3 a_24563_17750.t1 18.9255
R26459 a_24563_17750.n2 a_24563_17750.t4 17.0005
R26460 a_24563_17750.n1 a_24563_17750.n2 1.37206
R26461 a_24563_17750.n2 a_24563_17750.t0 18.9255
R26462 a_24563_17750.n1 a_24563_17750.t9 17.6708
R26463 a_24563_17750.n0 a_24563_17750.t7 8.81561
R26464 a_18043_17750.t3 a_18043_17750.n5 10.0462
R26465 a_18043_17750.n5 a_18043_17750.t8 8.90498
R26466 a_18043_17750.n5 a_18043_17750.n0 1.09706
R26467 a_18043_17750.n0 a_18043_17750.n4 1.09706
R26468 a_18043_17750.n4 a_18043_17750.t6 8.90498
R26469 a_18043_17750.n4 a_18043_17750.t2 10.0462
R26470 a_18043_17750.n0 a_18043_17750.n1 18.263
R26471 a_18043_17750.n3 a_18043_17750.t4 17.0005
R26472 a_18043_17750.n1 a_18043_17750.n3 1.37206
R26473 a_18043_17750.n3 a_18043_17750.t1 18.9255
R26474 a_18043_17750.n2 a_18043_17750.t5 17.0005
R26475 a_18043_17750.n1 a_18043_17750.n2 1.37206
R26476 a_18043_17750.n2 a_18043_17750.t0 18.9255
R26477 a_18043_17750.n1 a_18043_17750.t9 17.6708
R26478 a_18043_17750.n0 a_18043_17750.t7 8.81561
R26479 a_11523_17750.t3 a_11523_17750.n5 10.0462
R26480 a_11523_17750.n5 a_11523_17750.t6 8.90498
R26481 a_11523_17750.n5 a_11523_17750.n0 1.09706
R26482 a_11523_17750.n0 a_11523_17750.n4 1.09706
R26483 a_11523_17750.n4 a_11523_17750.t4 8.90498
R26484 a_11523_17750.n4 a_11523_17750.t2 10.0462
R26485 a_11523_17750.n0 a_11523_17750.n1 18.263
R26486 a_11523_17750.n3 a_11523_17750.t8 17.0005
R26487 a_11523_17750.n1 a_11523_17750.n3 1.37206
R26488 a_11523_17750.n3 a_11523_17750.t1 18.9255
R26489 a_11523_17750.n2 a_11523_17750.t7 17.0005
R26490 a_11523_17750.n1 a_11523_17750.n2 1.37206
R26491 a_11523_17750.n2 a_11523_17750.t0 18.9255
R26492 a_11523_17750.n1 a_11523_17750.t9 17.6708
R26493 a_11523_17750.n0 a_11523_17750.t5 8.81561
R26494 a_5003_17750.t3 a_5003_17750.n5 10.0462
R26495 a_5003_17750.n5 a_5003_17750.t9 8.90498
R26496 a_5003_17750.n5 a_5003_17750.n0 1.09706
R26497 a_5003_17750.n0 a_5003_17750.n4 1.09706
R26498 a_5003_17750.n4 a_5003_17750.t7 8.90498
R26499 a_5003_17750.n4 a_5003_17750.t2 10.0462
R26500 a_5003_17750.n0 a_5003_17750.n1 18.263
R26501 a_5003_17750.n3 a_5003_17750.t6 17.0005
R26502 a_5003_17750.n1 a_5003_17750.n3 1.37206
R26503 a_5003_17750.n3 a_5003_17750.t1 18.9255
R26504 a_5003_17750.n2 a_5003_17750.t4 17.0005
R26505 a_5003_17750.n1 a_5003_17750.n2 1.37206
R26506 a_5003_17750.n2 a_5003_17750.t0 18.9255
R26507 a_5003_17750.n1 a_5003_17750.t5 17.6708
R26508 a_5003_17750.n0 a_5003_17750.t8 8.81561
R26509 a_49938_17714.t0 a_49938_17714.n0 8.53521
R26510 a_49938_17714.n0 a_49938_17714.t2 16.6582
R26511 a_49938_17714.n0 a_49938_17714.t1 6.13582
R26512 a_43418_17714.t0 a_43418_17714.n0 8.53521
R26513 a_43418_17714.n0 a_43418_17714.t2 16.6582
R26514 a_43418_17714.n0 a_43418_17714.t1 6.13582
R26515 a_49517_17694.t0 a_49517_17694.n0 8.53379
R26516 a_49517_17694.n0 a_49517_17694.t1 6.23476
R26517 a_49517_17694.n0 a_49517_17694.t2 35.9286
R26518 a_36898_17714.t0 a_36898_17714.n0 8.53521
R26519 a_36898_17714.n0 a_36898_17714.t2 16.6582
R26520 a_36898_17714.n0 a_36898_17714.t1 6.13582
R26521 a_42997_17694.t0 a_42997_17694.n0 8.53379
R26522 a_42997_17694.n0 a_42997_17694.t1 6.23476
R26523 a_42997_17694.n0 a_42997_17694.t2 35.9286
R26524 a_30378_17714.t0 a_30378_17714.n0 8.53521
R26525 a_30378_17714.n0 a_30378_17714.t2 16.6582
R26526 a_30378_17714.n0 a_30378_17714.t1 6.13582
R26527 a_36477_17694.t0 a_36477_17694.n0 8.53379
R26528 a_36477_17694.n0 a_36477_17694.t1 6.23476
R26529 a_36477_17694.n0 a_36477_17694.t2 35.9286
R26530 a_23858_17714.t0 a_23858_17714.n0 8.53521
R26531 a_23858_17714.n0 a_23858_17714.t2 16.6582
R26532 a_23858_17714.n0 a_23858_17714.t1 6.13582
R26533 a_29957_17694.t0 a_29957_17694.n0 8.53379
R26534 a_29957_17694.n0 a_29957_17694.t1 6.23476
R26535 a_29957_17694.n0 a_29957_17694.t2 35.9286
R26536 a_17338_17714.t0 a_17338_17714.n0 8.53521
R26537 a_17338_17714.n0 a_17338_17714.t2 16.6582
R26538 a_17338_17714.n0 a_17338_17714.t1 6.13582
R26539 a_23437_17694.t0 a_23437_17694.n0 8.53379
R26540 a_23437_17694.n0 a_23437_17694.t1 6.23476
R26541 a_23437_17694.n0 a_23437_17694.t2 35.9286
R26542 a_10818_17714.t0 a_10818_17714.n0 8.53521
R26543 a_10818_17714.n0 a_10818_17714.t2 16.6582
R26544 a_10818_17714.n0 a_10818_17714.t1 6.13582
R26545 a_16917_17694.t0 a_16917_17694.n0 8.53379
R26546 a_16917_17694.n0 a_16917_17694.t1 6.23476
R26547 a_16917_17694.n0 a_16917_17694.t2 35.9286
R26548 a_4298_17714.t0 a_4298_17714.n0 8.53521
R26549 a_4298_17714.n0 a_4298_17714.t2 16.6582
R26550 a_4298_17714.n0 a_4298_17714.t1 6.13582
R26551 a_10397_17694.t0 a_10397_17694.n0 8.53379
R26552 a_10397_17694.n0 a_10397_17694.t1 6.23476
R26553 a_10397_17694.n0 a_10397_17694.t2 35.9286
R26554 a_3877_17694.t0 a_3877_17694.n0 8.53379
R26555 a_3877_17694.n0 a_3877_17694.t1 6.23476
R26556 a_3877_17694.n0 a_3877_17694.t2 35.9286
R26557 a_44289_20290.t3 a_44289_20290.n0 8.8328
R26558 a_44289_20290.n2 a_44289_20290.n3 1.14175
R26559 a_44289_20290.n1 a_44289_20290.n2 1.14175
R26560 a_44289_20290.n0 a_44289_20290.n1 1.14175
R26561 a_44289_20290.n3 a_44289_20290.t0 8.8328
R26562 a_44289_20290.n3 a_44289_20290.t4 8.8328
R26563 a_44289_20290.n2 a_44289_20290.t1 8.8328
R26564 a_44289_20290.n2 a_44289_20290.t5 8.8318
R26565 a_44289_20290.n1 a_44289_20290.t2 8.8328
R26566 a_44289_20290.n1 a_44289_20290.t7 8.8318
R26567 a_44289_20290.n0 a_44289_20290.t6 8.8318
R26568 a_42306_20293.t0 a_42306_20293.t1 35.1591
R26569 a_41430_20229.t0 a_41430_20229.t1 35.2643
R26570 a_43201_20494.t0 a_43201_20494.n0 8.76769
R26571 a_43201_20494.n0 a_43201_20494.t2 15.0661
R26572 a_43201_20494.n0 a_43201_20494.t1 5.94842
R26573 a_42628_20433.n0 a_42628_20433.t1 17.0005
R26574 a_42628_20433.t0 a_42628_20433.n0 18.2612
R26575 a_42628_20433.n0 a_42628_20433.t2 15.5529
R26576 a_42400_20293.t1 a_42400_20293.n0 17.5293
R26577 a_42400_20293.n0 a_42400_20293.t0 17.726
R26578 a_42400_20293.n0 a_42400_20293.t2 15.773
R26579 a_40298_20217.t1 a_40298_20217.n0 8.46601
R26580 a_40298_20217.n0 a_40298_20217.t2 9.03504
R26581 a_40298_20217.n0 a_40298_20217.t0 9.14806
R26582 a_41652_20560.t0 a_41652_20560.n1 17.3368
R26583 a_41652_20560.n0 a_41652_20560.t1 8.47322
R26584 a_41652_20560.n1 a_41652_20560.n0 0.103627
R26585 a_41652_20560.n0 a_41652_20560.t2 17.4516
R26586 a_41652_20560.n1 a_41652_20560.t3 15.0435
R26587 a_41550_20473.n0 a_41550_20473.t3 15.0005
R26588 a_41550_20473.t0 a_41550_20473.n0 17.9114
R26589 a_41550_20473.n1 a_41550_20473.t1 17.0005
R26590 a_41550_20473.n0 a_41550_20473.n1 0.655551
R26591 a_41550_20473.n1 a_41550_20473.t2 15.2176
R26592 a_41141_20534.t0 a_41141_20534.n2 17.9378
R26593 a_41141_20534.n2 a_41141_20534.t3 18.3531
R26594 a_41141_20534.n2 a_41141_20534.n1 3.38952
R26595 a_41141_20534.n1 a_41141_20534.n0 0.498937
R26596 a_41141_20534.n0 a_41141_20534.t1 17.1232
R26597 a_41141_20534.n0 a_41141_20534.t2 18.4279
R26598 a_41141_20534.n1 a_41141_20534.t4 15.4204
R26599 a_40855_20216.t0 a_40855_20216.n1 17.0005
R26600 a_40855_20216.n1 a_40855_20216.t3 18.6222
R26601 a_40855_20216.n0 a_40855_20216.t2 17.0005
R26602 a_40855_20216.n1 a_40855_20216.n0 3.28463
R26603 a_40855_20216.n0 a_40855_20216.t1 18.3191
R26604 a_41115_20439.t0 a_41115_20439.n1 17.2651
R26605 a_41115_20439.n1 a_41115_20439.t1 17.3352
R26606 a_41115_20439.n1 a_41115_20439.n0 0.948441
R26607 a_41115_20439.n0 a_41115_20439.t2 17.3305
R26608 a_41115_20439.n0 a_41115_20439.t3 15.4436
R26609 a_40399_20514.t2 a_40399_20514.n1 17.1443
R26610 a_40399_20514.n1 a_40399_20514.n0 0.743
R26611 a_40399_20514.n0 a_40399_20514.t0 8.65706
R26612 a_40399_20514.n0 a_40399_20514.t1 8.71106
R26613 a_40399_20514.n1 a_40399_20514.t3 15.731
R26614 a_40010_20198.t0 a_40010_20198.n0 8.81393
R26615 a_40010_20198.n0 a_40010_20198.t2 15.4488
R26616 a_40010_20198.n0 a_40010_20198.t1 6.09623
R26617 a_37769_20290.t3 a_37769_20290.n0 8.8328
R26618 a_37769_20290.n2 a_37769_20290.n3 1.14175
R26619 a_37769_20290.n1 a_37769_20290.n2 1.14175
R26620 a_37769_20290.n0 a_37769_20290.n1 1.14175
R26621 a_37769_20290.n3 a_37769_20290.t0 8.8328
R26622 a_37769_20290.n3 a_37769_20290.t6 8.8328
R26623 a_37769_20290.n2 a_37769_20290.t1 8.8328
R26624 a_37769_20290.n2 a_37769_20290.t7 8.8318
R26625 a_37769_20290.n1 a_37769_20290.t2 8.8328
R26626 a_37769_20290.n1 a_37769_20290.t5 8.8318
R26627 a_37769_20290.n0 a_37769_20290.t4 8.8318
R26628 a_35786_20293.t0 a_35786_20293.t1 35.1591
R26629 a_34910_20229.t0 a_34910_20229.t1 35.2643
R26630 a_39705_20594.t0 a_39705_20594.n0 17.1718
R26631 a_39705_20594.n0 a_39705_20594.t1 9.7433
R26632 a_39705_20594.n0 a_39705_20594.t2 15.4943
R26633 a_36681_20494.t0 a_36681_20494.n0 8.76769
R26634 a_36681_20494.n0 a_36681_20494.t2 15.0661
R26635 a_36681_20494.n0 a_36681_20494.t1 5.94842
R26636 a_36108_20433.n0 a_36108_20433.t1 17.0005
R26637 a_36108_20433.t0 a_36108_20433.n0 18.2612
R26638 a_36108_20433.n0 a_36108_20433.t2 15.5529
R26639 a_35880_20293.t0 a_35880_20293.n0 17.5293
R26640 a_35880_20293.n0 a_35880_20293.t1 17.726
R26641 a_35880_20293.n0 a_35880_20293.t2 15.773
R26642 a_33778_20217.t1 a_33778_20217.n0 8.46601
R26643 a_33778_20217.n0 a_33778_20217.t2 9.03504
R26644 a_33778_20217.n0 a_33778_20217.t0 9.14806
R26645 a_35132_20560.t0 a_35132_20560.n1 17.3368
R26646 a_35132_20560.n0 a_35132_20560.t1 8.47322
R26647 a_35132_20560.n1 a_35132_20560.n0 0.103627
R26648 a_35132_20560.n0 a_35132_20560.t2 17.4516
R26649 a_35132_20560.n1 a_35132_20560.t3 15.0435
R26650 a_35030_20473.n0 a_35030_20473.t3 15.0005
R26651 a_35030_20473.t0 a_35030_20473.n0 17.9114
R26652 a_35030_20473.n1 a_35030_20473.t1 17.0005
R26653 a_35030_20473.n0 a_35030_20473.n1 0.655551
R26654 a_35030_20473.n1 a_35030_20473.t2 15.2176
R26655 a_34621_20534.t0 a_34621_20534.n2 17.9378
R26656 a_34621_20534.n2 a_34621_20534.t3 18.3531
R26657 a_34621_20534.n2 a_34621_20534.n1 3.38952
R26658 a_34621_20534.n1 a_34621_20534.n0 0.498937
R26659 a_34621_20534.n0 a_34621_20534.t1 17.1232
R26660 a_34621_20534.n0 a_34621_20534.t2 18.4279
R26661 a_34621_20534.n1 a_34621_20534.t4 15.4204
R26662 a_34335_20216.n0 a_34335_20216.t1 17.0005
R26663 a_34335_20216.t0 a_34335_20216.n0 18.3191
R26664 a_34335_20216.n1 a_34335_20216.t2 17.0005
R26665 a_34335_20216.n0 a_34335_20216.n1 3.28463
R26666 a_34335_20216.n1 a_34335_20216.t3 18.6222
R26667 a_34595_20439.t0 a_34595_20439.n1 17.3352
R26668 a_34595_20439.n1 a_34595_20439.t1 17.2651
R26669 a_34595_20439.n1 a_34595_20439.n0 0.948441
R26670 a_34595_20439.n0 a_34595_20439.t2 17.3305
R26671 a_34595_20439.n0 a_34595_20439.t3 15.4436
R26672 a_33879_20514.t2 a_33879_20514.n1 17.1443
R26673 a_33879_20514.n1 a_33879_20514.n0 0.743
R26674 a_33879_20514.n0 a_33879_20514.t0 8.65706
R26675 a_33879_20514.n0 a_33879_20514.t1 8.71106
R26676 a_33879_20514.n1 a_33879_20514.t3 15.731
R26677 a_33490_20198.t0 a_33490_20198.n0 8.81393
R26678 a_33490_20198.n0 a_33490_20198.t2 15.4488
R26679 a_33490_20198.n0 a_33490_20198.t1 6.09623
R26680 a_31249_20290.t3 a_31249_20290.n0 8.8328
R26681 a_31249_20290.n2 a_31249_20290.n3 1.14175
R26682 a_31249_20290.n1 a_31249_20290.n2 1.14175
R26683 a_31249_20290.n0 a_31249_20290.n1 1.14175
R26684 a_31249_20290.n3 a_31249_20290.t0 8.8328
R26685 a_31249_20290.n3 a_31249_20290.t4 8.8328
R26686 a_31249_20290.n2 a_31249_20290.t1 8.8328
R26687 a_31249_20290.n2 a_31249_20290.t5 8.8318
R26688 a_31249_20290.n1 a_31249_20290.t2 8.8328
R26689 a_31249_20290.n1 a_31249_20290.t6 8.8318
R26690 a_31249_20290.n0 a_31249_20290.t7 8.8318
R26691 a_29266_20293.t0 a_29266_20293.t1 35.1591
R26692 a_28390_20229.t0 a_28390_20229.t1 35.2643
R26693 a_33185_20594.t0 a_33185_20594.n0 17.1718
R26694 a_33185_20594.n0 a_33185_20594.t1 9.7433
R26695 a_33185_20594.n0 a_33185_20594.t2 15.4943
R26696 a_30161_20494.t0 a_30161_20494.n0 8.76769
R26697 a_30161_20494.n0 a_30161_20494.t2 15.0661
R26698 a_30161_20494.n0 a_30161_20494.t1 5.94842
R26699 a_29588_20433.t0 a_29588_20433.n0 17.0005
R26700 a_29588_20433.n0 a_29588_20433.t1 18.2612
R26701 a_29588_20433.n0 a_29588_20433.t2 15.5529
R26702 a_29360_20293.t0 a_29360_20293.n0 17.5293
R26703 a_29360_20293.n0 a_29360_20293.t1 17.726
R26704 a_29360_20293.n0 a_29360_20293.t2 15.773
R26705 a_27258_20217.t1 a_27258_20217.n0 8.46601
R26706 a_27258_20217.n0 a_27258_20217.t2 9.03504
R26707 a_27258_20217.n0 a_27258_20217.t0 9.14806
R26708 a_28612_20560.t0 a_28612_20560.n1 17.3368
R26709 a_28612_20560.n0 a_28612_20560.t1 8.47322
R26710 a_28612_20560.n1 a_28612_20560.n0 0.103627
R26711 a_28612_20560.n0 a_28612_20560.t2 17.4516
R26712 a_28612_20560.n1 a_28612_20560.t3 15.0435
R26713 a_28510_20473.n0 a_28510_20473.t3 15.0005
R26714 a_28510_20473.t0 a_28510_20473.n0 17.9114
R26715 a_28510_20473.n1 a_28510_20473.t1 17.0005
R26716 a_28510_20473.n0 a_28510_20473.n1 0.655551
R26717 a_28510_20473.n1 a_28510_20473.t2 15.2176
R26718 a_28101_20534.t1 a_28101_20534.n2 17.9378
R26719 a_28101_20534.n2 a_28101_20534.t0 18.3531
R26720 a_28101_20534.n2 a_28101_20534.n1 3.38952
R26721 a_28101_20534.n1 a_28101_20534.n0 0.498937
R26722 a_28101_20534.n0 a_28101_20534.t2 17.1232
R26723 a_28101_20534.n0 a_28101_20534.t3 18.4279
R26724 a_28101_20534.n1 a_28101_20534.t4 15.4204
R26725 a_27815_20216.t0 a_27815_20216.n0 18.6222
R26726 a_27815_20216.n0 a_27815_20216.t1 17.0005
R26727 a_27815_20216.n1 a_27815_20216.t2 17.0005
R26728 a_27815_20216.n0 a_27815_20216.n1 3.28463
R26729 a_27815_20216.n1 a_27815_20216.t3 18.3191
R26730 a_28075_20439.t0 a_28075_20439.n1 17.2651
R26731 a_28075_20439.n1 a_28075_20439.t1 17.3352
R26732 a_28075_20439.n1 a_28075_20439.n0 0.948441
R26733 a_28075_20439.n0 a_28075_20439.t2 17.3305
R26734 a_28075_20439.n0 a_28075_20439.t3 15.4436
R26735 a_27359_20514.t1 a_27359_20514.n1 17.1443
R26736 a_27359_20514.n1 a_27359_20514.n0 0.743
R26737 a_27359_20514.n0 a_27359_20514.t0 8.65706
R26738 a_27359_20514.n0 a_27359_20514.t2 8.71106
R26739 a_27359_20514.n1 a_27359_20514.t3 15.731
R26740 a_26970_20198.t0 a_26970_20198.n0 8.81393
R26741 a_26970_20198.n0 a_26970_20198.t2 15.4488
R26742 a_26970_20198.n0 a_26970_20198.t1 6.09623
R26743 a_24729_20290.t3 a_24729_20290.n0 8.8328
R26744 a_24729_20290.n2 a_24729_20290.n3 1.14175
R26745 a_24729_20290.n1 a_24729_20290.n2 1.14175
R26746 a_24729_20290.n0 a_24729_20290.n1 1.14175
R26747 a_24729_20290.n3 a_24729_20290.t0 8.8328
R26748 a_24729_20290.n3 a_24729_20290.t7 8.8328
R26749 a_24729_20290.n2 a_24729_20290.t1 8.8328
R26750 a_24729_20290.n2 a_24729_20290.t4 8.8318
R26751 a_24729_20290.n1 a_24729_20290.t2 8.8328
R26752 a_24729_20290.n1 a_24729_20290.t5 8.8318
R26753 a_24729_20290.n0 a_24729_20290.t6 8.8318
R26754 a_22746_20293.t0 a_22746_20293.t1 35.1591
R26755 a_21870_20229.t0 a_21870_20229.t1 35.2643
R26756 a_26665_20594.t0 a_26665_20594.n0 17.1718
R26757 a_26665_20594.n0 a_26665_20594.t1 9.7433
R26758 a_26665_20594.n0 a_26665_20594.t2 15.4943
R26759 a_23641_20494.t0 a_23641_20494.n0 8.76769
R26760 a_23641_20494.n0 a_23641_20494.t2 15.0661
R26761 a_23641_20494.n0 a_23641_20494.t1 5.94842
R26762 a_23068_20433.t0 a_23068_20433.n0 17.0005
R26763 a_23068_20433.n0 a_23068_20433.t1 18.2612
R26764 a_23068_20433.n0 a_23068_20433.t2 15.5529
R26765 a_22840_20293.t0 a_22840_20293.n0 17.5293
R26766 a_22840_20293.n0 a_22840_20293.t1 17.726
R26767 a_22840_20293.n0 a_22840_20293.t2 15.773
R26768 a_20738_20217.t1 a_20738_20217.n0 8.46601
R26769 a_20738_20217.n0 a_20738_20217.t2 9.03504
R26770 a_20738_20217.n0 a_20738_20217.t0 9.14806
R26771 a_22092_20560.t0 a_22092_20560.n1 17.3368
R26772 a_22092_20560.n0 a_22092_20560.t1 8.47322
R26773 a_22092_20560.n1 a_22092_20560.n0 0.103627
R26774 a_22092_20560.n0 a_22092_20560.t2 17.4516
R26775 a_22092_20560.n1 a_22092_20560.t3 15.0435
R26776 a_21990_20473.n0 a_21990_20473.t3 15.0005
R26777 a_21990_20473.t0 a_21990_20473.n0 17.9114
R26778 a_21990_20473.n1 a_21990_20473.t1 17.0005
R26779 a_21990_20473.n0 a_21990_20473.n1 0.655551
R26780 a_21990_20473.n1 a_21990_20473.t2 15.2176
R26781 a_21581_20534.t1 a_21581_20534.n2 17.9378
R26782 a_21581_20534.n2 a_21581_20534.t0 18.3531
R26783 a_21581_20534.n2 a_21581_20534.n1 3.38952
R26784 a_21581_20534.n1 a_21581_20534.n0 0.498937
R26785 a_21581_20534.n0 a_21581_20534.t2 17.1232
R26786 a_21581_20534.n0 a_21581_20534.t3 18.4279
R26787 a_21581_20534.n1 a_21581_20534.t4 15.4204
R26788 a_21295_20216.t0 a_21295_20216.n0 18.6222
R26789 a_21295_20216.n0 a_21295_20216.t1 17.0005
R26790 a_21295_20216.n1 a_21295_20216.t3 17.0005
R26791 a_21295_20216.n0 a_21295_20216.n1 3.28463
R26792 a_21295_20216.n1 a_21295_20216.t2 18.3191
R26793 a_21555_20439.t0 a_21555_20439.n1 17.2651
R26794 a_21555_20439.n1 a_21555_20439.t1 17.3352
R26795 a_21555_20439.n1 a_21555_20439.n0 0.948441
R26796 a_21555_20439.n0 a_21555_20439.t2 17.3305
R26797 a_21555_20439.n0 a_21555_20439.t3 15.4436
R26798 a_20839_20514.t1 a_20839_20514.n1 17.1443
R26799 a_20839_20514.n1 a_20839_20514.n0 0.743
R26800 a_20839_20514.n0 a_20839_20514.t0 8.65706
R26801 a_20839_20514.n0 a_20839_20514.t2 8.71106
R26802 a_20839_20514.n1 a_20839_20514.t3 15.731
R26803 a_20450_20198.t0 a_20450_20198.n0 8.81393
R26804 a_20450_20198.n0 a_20450_20198.t2 15.4488
R26805 a_20450_20198.n0 a_20450_20198.t1 6.09623
R26806 a_18209_20290.t3 a_18209_20290.n0 8.8328
R26807 a_18209_20290.n2 a_18209_20290.n3 1.14175
R26808 a_18209_20290.n1 a_18209_20290.n2 1.14175
R26809 a_18209_20290.n0 a_18209_20290.n1 1.14175
R26810 a_18209_20290.n3 a_18209_20290.t0 8.8328
R26811 a_18209_20290.n3 a_18209_20290.t6 8.8328
R26812 a_18209_20290.n2 a_18209_20290.t1 8.8328
R26813 a_18209_20290.n2 a_18209_20290.t7 8.8318
R26814 a_18209_20290.n1 a_18209_20290.t2 8.8328
R26815 a_18209_20290.n1 a_18209_20290.t5 8.8318
R26816 a_18209_20290.n0 a_18209_20290.t4 8.8318
R26817 a_16226_20293.t0 a_16226_20293.t1 35.1591
R26818 a_15350_20229.t0 a_15350_20229.t1 35.2643
R26819 a_20145_20594.t0 a_20145_20594.n0 17.1718
R26820 a_20145_20594.n0 a_20145_20594.t1 9.7433
R26821 a_20145_20594.n0 a_20145_20594.t2 15.4943
R26822 a_17121_20494.t0 a_17121_20494.n0 8.76769
R26823 a_17121_20494.n0 a_17121_20494.t2 15.0661
R26824 a_17121_20494.n0 a_17121_20494.t1 5.94842
R26825 a_16548_20433.n0 a_16548_20433.t1 17.0005
R26826 a_16548_20433.t0 a_16548_20433.n0 18.2612
R26827 a_16548_20433.n0 a_16548_20433.t2 15.5529
R26828 a_16320_20293.t1 a_16320_20293.n0 17.5293
R26829 a_16320_20293.n0 a_16320_20293.t0 17.726
R26830 a_16320_20293.n0 a_16320_20293.t2 15.773
R26831 a_14218_20217.t1 a_14218_20217.n0 8.46601
R26832 a_14218_20217.n0 a_14218_20217.t2 9.03504
R26833 a_14218_20217.n0 a_14218_20217.t0 9.14806
R26834 a_15572_20560.t0 a_15572_20560.n1 17.3368
R26835 a_15572_20560.n0 a_15572_20560.t1 8.47322
R26836 a_15572_20560.n1 a_15572_20560.n0 0.103627
R26837 a_15572_20560.n0 a_15572_20560.t2 17.4516
R26838 a_15572_20560.n1 a_15572_20560.t3 15.0435
R26839 a_15470_20473.n0 a_15470_20473.t3 15.0005
R26840 a_15470_20473.t0 a_15470_20473.n0 17.9114
R26841 a_15470_20473.n1 a_15470_20473.t1 17.0005
R26842 a_15470_20473.n0 a_15470_20473.n1 0.655551
R26843 a_15470_20473.n1 a_15470_20473.t2 15.2176
R26844 a_15061_20534.t0 a_15061_20534.n2 17.9378
R26845 a_15061_20534.n2 a_15061_20534.t1 18.3531
R26846 a_15061_20534.n2 a_15061_20534.n1 3.38952
R26847 a_15061_20534.n1 a_15061_20534.n0 0.498937
R26848 a_15061_20534.n0 a_15061_20534.t2 17.1232
R26849 a_15061_20534.n0 a_15061_20534.t3 18.4279
R26850 a_15061_20534.n1 a_15061_20534.t4 15.4204
R26851 a_14775_20216.t0 a_14775_20216.n1 17.0005
R26852 a_14775_20216.n1 a_14775_20216.t1 18.6222
R26853 a_14775_20216.n0 a_14775_20216.t2 17.0005
R26854 a_14775_20216.n1 a_14775_20216.n0 3.28463
R26855 a_14775_20216.n0 a_14775_20216.t3 18.3191
R26856 a_15035_20439.t0 a_15035_20439.n1 17.3352
R26857 a_15035_20439.n1 a_15035_20439.t1 17.2651
R26858 a_15035_20439.n1 a_15035_20439.n0 0.948441
R26859 a_15035_20439.n0 a_15035_20439.t2 17.3305
R26860 a_15035_20439.n0 a_15035_20439.t3 15.4436
R26861 a_14319_20514.t1 a_14319_20514.n1 17.1443
R26862 a_14319_20514.n1 a_14319_20514.n0 0.743
R26863 a_14319_20514.n0 a_14319_20514.t0 8.65706
R26864 a_14319_20514.n0 a_14319_20514.t2 8.71106
R26865 a_14319_20514.n1 a_14319_20514.t3 15.731
R26866 a_13930_20198.t0 a_13930_20198.n0 8.81393
R26867 a_13930_20198.n0 a_13930_20198.t2 15.4488
R26868 a_13930_20198.n0 a_13930_20198.t1 6.09623
R26869 a_11689_20290.t3 a_11689_20290.n0 8.8328
R26870 a_11689_20290.n2 a_11689_20290.n3 1.14175
R26871 a_11689_20290.n1 a_11689_20290.n2 1.14175
R26872 a_11689_20290.n0 a_11689_20290.n1 1.14175
R26873 a_11689_20290.n3 a_11689_20290.t0 8.8328
R26874 a_11689_20290.n3 a_11689_20290.t4 8.8328
R26875 a_11689_20290.n2 a_11689_20290.t1 8.8328
R26876 a_11689_20290.n2 a_11689_20290.t5 8.8318
R26877 a_11689_20290.n1 a_11689_20290.t2 8.8328
R26878 a_11689_20290.n1 a_11689_20290.t7 8.8318
R26879 a_11689_20290.n0 a_11689_20290.t6 8.8318
R26880 a_9706_20293.t0 a_9706_20293.t1 35.1591
R26881 a_8830_20229.t0 a_8830_20229.t1 35.2643
R26882 a_13625_20594.t0 a_13625_20594.n0 17.1718
R26883 a_13625_20594.n0 a_13625_20594.t1 9.7433
R26884 a_13625_20594.n0 a_13625_20594.t2 15.4943
R26885 a_10601_20494.t0 a_10601_20494.n0 8.76769
R26886 a_10601_20494.n0 a_10601_20494.t2 15.0661
R26887 a_10601_20494.n0 a_10601_20494.t1 5.94842
R26888 a_10028_20433.t0 a_10028_20433.n0 17.0005
R26889 a_10028_20433.n0 a_10028_20433.t1 18.2612
R26890 a_10028_20433.n0 a_10028_20433.t2 15.5529
R26891 a_9800_20293.t0 a_9800_20293.n0 17.5293
R26892 a_9800_20293.n0 a_9800_20293.t1 17.726
R26893 a_9800_20293.n0 a_9800_20293.t2 15.773
R26894 a_7698_20217.t1 a_7698_20217.n0 8.46601
R26895 a_7698_20217.n0 a_7698_20217.t2 9.03504
R26896 a_7698_20217.n0 a_7698_20217.t0 9.14806
R26897 a_9052_20560.t0 a_9052_20560.n1 17.3368
R26898 a_9052_20560.n0 a_9052_20560.t1 8.47322
R26899 a_9052_20560.n1 a_9052_20560.n0 0.103627
R26900 a_9052_20560.n0 a_9052_20560.t2 17.4516
R26901 a_9052_20560.n1 a_9052_20560.t3 15.0435
R26902 a_8950_20473.n0 a_8950_20473.t3 15.0005
R26903 a_8950_20473.t0 a_8950_20473.n0 17.9114
R26904 a_8950_20473.n1 a_8950_20473.t1 17.0005
R26905 a_8950_20473.n0 a_8950_20473.n1 0.655551
R26906 a_8950_20473.n1 a_8950_20473.t2 15.2176
R26907 a_8541_20534.t1 a_8541_20534.n2 17.9378
R26908 a_8541_20534.n2 a_8541_20534.t0 18.3531
R26909 a_8541_20534.n2 a_8541_20534.n1 3.38952
R26910 a_8541_20534.n1 a_8541_20534.n0 0.498937
R26911 a_8541_20534.n0 a_8541_20534.t2 17.1232
R26912 a_8541_20534.n0 a_8541_20534.t3 18.4279
R26913 a_8541_20534.n1 a_8541_20534.t4 15.4204
R26914 a_8255_20216.t0 a_8255_20216.n0 18.6222
R26915 a_8255_20216.n0 a_8255_20216.t1 17.0005
R26916 a_8255_20216.n1 a_8255_20216.t3 17.0005
R26917 a_8255_20216.n0 a_8255_20216.n1 3.28463
R26918 a_8255_20216.n1 a_8255_20216.t2 18.3191
R26919 a_8515_20439.t0 a_8515_20439.n1 17.3352
R26920 a_8515_20439.n1 a_8515_20439.t1 17.2651
R26921 a_8515_20439.n1 a_8515_20439.n0 0.948441
R26922 a_8515_20439.n0 a_8515_20439.t2 17.3305
R26923 a_8515_20439.n0 a_8515_20439.t3 15.4436
R26924 a_7799_20514.t1 a_7799_20514.n1 17.1443
R26925 a_7799_20514.n1 a_7799_20514.n0 0.743
R26926 a_7799_20514.n0 a_7799_20514.t0 8.65706
R26927 a_7799_20514.n0 a_7799_20514.t2 8.71106
R26928 a_7799_20514.n1 a_7799_20514.t3 15.731
R26929 a_7410_20198.t0 a_7410_20198.n0 8.81393
R26930 a_7410_20198.n0 a_7410_20198.t2 15.4488
R26931 a_7410_20198.n0 a_7410_20198.t1 6.09623
R26932 a_5169_20290.t3 a_5169_20290.n0 8.8328
R26933 a_5169_20290.n2 a_5169_20290.n3 1.14175
R26934 a_5169_20290.n1 a_5169_20290.n2 1.14175
R26935 a_5169_20290.n0 a_5169_20290.n1 1.14175
R26936 a_5169_20290.n3 a_5169_20290.t0 8.8328
R26937 a_5169_20290.n3 a_5169_20290.t6 8.8328
R26938 a_5169_20290.n2 a_5169_20290.t1 8.8328
R26939 a_5169_20290.n2 a_5169_20290.t7 8.8318
R26940 a_5169_20290.n1 a_5169_20290.t2 8.8328
R26941 a_5169_20290.n1 a_5169_20290.t5 8.8318
R26942 a_5169_20290.n0 a_5169_20290.t4 8.8318
R26943 a_3186_20293.t0 a_3186_20293.t1 35.1591
R26944 a_2310_20229.t0 a_2310_20229.t1 35.2643
R26945 a_7105_20594.t0 a_7105_20594.n0 17.1718
R26946 a_7105_20594.n0 a_7105_20594.t1 9.7433
R26947 a_7105_20594.n0 a_7105_20594.t2 15.4943
R26948 a_4081_20494.t0 a_4081_20494.n0 8.76769
R26949 a_4081_20494.n0 a_4081_20494.t2 15.0661
R26950 a_4081_20494.n0 a_4081_20494.t1 5.94842
R26951 a_3508_20433.n0 a_3508_20433.t1 17.0005
R26952 a_3508_20433.t0 a_3508_20433.n0 18.2612
R26953 a_3508_20433.n0 a_3508_20433.t2 15.5529
R26954 a_3280_20293.t0 a_3280_20293.n0 17.5293
R26955 a_3280_20293.n0 a_3280_20293.t1 17.726
R26956 a_3280_20293.n0 a_3280_20293.t2 15.773
R26957 a_1178_20217.t1 a_1178_20217.n0 8.46601
R26958 a_1178_20217.n0 a_1178_20217.t2 9.03504
R26959 a_1178_20217.n0 a_1178_20217.t0 9.14806
R26960 a_2532_20560.t0 a_2532_20560.n1 17.3368
R26961 a_2532_20560.n0 a_2532_20560.t1 8.47322
R26962 a_2532_20560.n1 a_2532_20560.n0 0.103627
R26963 a_2532_20560.n0 a_2532_20560.t2 17.4516
R26964 a_2532_20560.n1 a_2532_20560.t3 15.0435
R26965 a_2430_20473.n0 a_2430_20473.t3 15.0005
R26966 a_2430_20473.t0 a_2430_20473.n0 17.9114
R26967 a_2430_20473.n1 a_2430_20473.t1 17.0005
R26968 a_2430_20473.n0 a_2430_20473.n1 0.655551
R26969 a_2430_20473.n1 a_2430_20473.t2 15.2176
R26970 a_2021_20534.t0 a_2021_20534.n2 17.9378
R26971 a_2021_20534.n2 a_2021_20534.t3 18.3531
R26972 a_2021_20534.n2 a_2021_20534.n1 3.38952
R26973 a_2021_20534.n1 a_2021_20534.n0 0.498937
R26974 a_2021_20534.n0 a_2021_20534.t1 17.1232
R26975 a_2021_20534.n0 a_2021_20534.t2 18.4279
R26976 a_2021_20534.n1 a_2021_20534.t4 15.4204
R26977 a_1735_20216.t0 a_1735_20216.n1 17.0005
R26978 a_1735_20216.n1 a_1735_20216.t3 18.6222
R26979 a_1735_20216.n0 a_1735_20216.t2 17.0005
R26980 a_1735_20216.n1 a_1735_20216.n0 3.28463
R26981 a_1735_20216.n0 a_1735_20216.t1 18.3191
R26982 a_1995_20439.t0 a_1995_20439.n1 17.2651
R26983 a_1995_20439.n1 a_1995_20439.t1 17.3352
R26984 a_1995_20439.n1 a_1995_20439.n0 0.948441
R26985 a_1995_20439.n0 a_1995_20439.t2 17.3305
R26986 a_1995_20439.n0 a_1995_20439.t3 15.4436
R26987 a_1279_20514.t1 a_1279_20514.n1 17.1443
R26988 a_1279_20514.n1 a_1279_20514.n0 0.743
R26989 a_1279_20514.n0 a_1279_20514.t0 8.65706
R26990 a_1279_20514.n0 a_1279_20514.t2 8.71106
R26991 a_1279_20514.n1 a_1279_20514.t3 15.731
R26992 a_n2044_4040.t0 a_n2044_4040.n0 8.80881
R26993 a_n2044_4040.n0 a_n2044_4040.t1 5.96819
R26994 a_n2044_4040.n0 a_n2044_4040.n14 28.2567
R26995 a_n2044_4040.n14 a_n2044_4040.n13 0.557571
R26996 a_n2044_4040.n13 a_n2044_4040.n12 4.56629
R26997 a_n2044_4040.n12 a_n2044_4040.n11 0.557571
R26998 a_n2044_4040.n11 a_n2044_4040.n10 4.56629
R26999 a_n2044_4040.n10 a_n2044_4040.n9 0.557571
R27000 a_n2044_4040.n9 a_n2044_4040.n8 4.56629
R27001 a_n2044_4040.n8 a_n2044_4040.n7 0.557571
R27002 a_n2044_4040.n7 a_n2044_4040.n6 4.56629
R27003 a_n2044_4040.n6 a_n2044_4040.n5 0.557571
R27004 a_n2044_4040.n5 a_n2044_4040.n4 4.56629
R27005 a_n2044_4040.n4 a_n2044_4040.n3 0.557571
R27006 a_n2044_4040.n3 a_n2044_4040.n2 4.56629
R27007 a_n2044_4040.n2 a_n2044_4040.n1 0.557571
R27008 a_n2044_4040.n1 a_n2044_4040.t2 36.2493
R27009 a_n2044_4040.n14 a_n2044_4040.t9 31.6835
R27010 a_n2044_4040.n13 a_n2044_4040.t16 29.6622
R27011 a_n2044_4040.n12 a_n2044_4040.t8 31.6835
R27012 a_n2044_4040.n11 a_n2044_4040.t15 29.6622
R27013 a_n2044_4040.n10 a_n2044_4040.t7 31.6835
R27014 a_n2044_4040.n9 a_n2044_4040.t14 29.6622
R27015 a_n2044_4040.n8 a_n2044_4040.t6 31.6835
R27016 a_n2044_4040.n7 a_n2044_4040.t13 29.6622
R27017 a_n2044_4040.n6 a_n2044_4040.t5 31.6835
R27018 a_n2044_4040.n5 a_n2044_4040.t12 29.6622
R27019 a_n2044_4040.n4 a_n2044_4040.t4 31.6835
R27020 a_n2044_4040.n3 a_n2044_4040.t11 29.6622
R27021 a_n2044_4040.n2 a_n2044_4040.t3 31.6835
R27022 a_n2044_4040.n1 a_n2044_4040.t10 29.6622
R27023 a_890_20198.t0 a_890_20198.n0 8.81393
R27024 a_890_20198.n0 a_890_20198.t2 15.4488
R27025 a_890_20198.n0 a_890_20198.t1 6.09623
R27026 a_585_20594.t0 a_585_20594.n0 17.1718
R27027 a_585_20594.n0 a_585_20594.t1 9.7433
R27028 a_585_20594.n0 a_585_20594.t2 15.4943
R27029 a_44123_20550.t9 a_44123_20550.n5 8.90498
R27030 a_44123_20550.n5 a_44123_20550.t3 10.0462
R27031 a_44123_20550.n5 a_44123_20550.n0 1.09706
R27032 a_44123_20550.n0 a_44123_20550.n4 1.09706
R27033 a_44123_20550.n4 a_44123_20550.t7 8.90498
R27034 a_44123_20550.n4 a_44123_20550.t2 10.0462
R27035 a_44123_20550.n0 a_44123_20550.n1 18.263
R27036 a_44123_20550.n3 a_44123_20550.t6 17.0005
R27037 a_44123_20550.n1 a_44123_20550.n3 1.37206
R27038 a_44123_20550.n3 a_44123_20550.t1 18.9255
R27039 a_44123_20550.n2 a_44123_20550.t4 17.0005
R27040 a_44123_20550.n1 a_44123_20550.n2 1.37206
R27041 a_44123_20550.n2 a_44123_20550.t0 18.9255
R27042 a_44123_20550.n1 a_44123_20550.t5 17.6708
R27043 a_44123_20550.n0 a_44123_20550.t8 8.81561
R27044 a_37603_20550.t3 a_37603_20550.n5 10.0462
R27045 a_37603_20550.n5 a_37603_20550.t6 8.90498
R27046 a_37603_20550.n5 a_37603_20550.n0 1.09706
R27047 a_37603_20550.n0 a_37603_20550.n4 1.09706
R27048 a_37603_20550.n4 a_37603_20550.t4 8.90498
R27049 a_37603_20550.n4 a_37603_20550.t2 10.0462
R27050 a_37603_20550.n0 a_37603_20550.n1 18.263
R27051 a_37603_20550.n3 a_37603_20550.t8 17.0005
R27052 a_37603_20550.n1 a_37603_20550.n3 1.37206
R27053 a_37603_20550.n3 a_37603_20550.t1 18.9255
R27054 a_37603_20550.n2 a_37603_20550.t7 17.0005
R27055 a_37603_20550.n1 a_37603_20550.n2 1.37206
R27056 a_37603_20550.n2 a_37603_20550.t0 18.9255
R27057 a_37603_20550.n1 a_37603_20550.t9 17.6708
R27058 a_37603_20550.n0 a_37603_20550.t5 8.81561
R27059 a_31083_20550.t9 a_31083_20550.n5 8.90498
R27060 a_31083_20550.n5 a_31083_20550.t3 10.0462
R27061 a_31083_20550.n5 a_31083_20550.n0 1.09706
R27062 a_31083_20550.n0 a_31083_20550.n4 1.09706
R27063 a_31083_20550.n4 a_31083_20550.t7 8.90498
R27064 a_31083_20550.n4 a_31083_20550.t2 10.0462
R27065 a_31083_20550.n0 a_31083_20550.n1 18.263
R27066 a_31083_20550.n3 a_31083_20550.t6 17.0005
R27067 a_31083_20550.n1 a_31083_20550.n3 1.37206
R27068 a_31083_20550.n3 a_31083_20550.t1 18.9255
R27069 a_31083_20550.n2 a_31083_20550.t4 17.0005
R27070 a_31083_20550.n1 a_31083_20550.n2 1.37206
R27071 a_31083_20550.n2 a_31083_20550.t0 18.9255
R27072 a_31083_20550.n1 a_31083_20550.t5 17.6708
R27073 a_31083_20550.n0 a_31083_20550.t8 8.81561
R27074 a_24563_20550.t3 a_24563_20550.n5 10.0462
R27075 a_24563_20550.n5 a_24563_20550.t8 8.90498
R27076 a_24563_20550.n5 a_24563_20550.n0 1.09706
R27077 a_24563_20550.n0 a_24563_20550.n4 1.09706
R27078 a_24563_20550.n4 a_24563_20550.t6 8.90498
R27079 a_24563_20550.n4 a_24563_20550.t2 10.0462
R27080 a_24563_20550.n0 a_24563_20550.n1 18.263
R27081 a_24563_20550.n3 a_24563_20550.t5 17.0005
R27082 a_24563_20550.n1 a_24563_20550.n3 1.37206
R27083 a_24563_20550.n3 a_24563_20550.t1 18.9255
R27084 a_24563_20550.n2 a_24563_20550.t4 17.0005
R27085 a_24563_20550.n1 a_24563_20550.n2 1.37206
R27086 a_24563_20550.n2 a_24563_20550.t0 18.9255
R27087 a_24563_20550.n1 a_24563_20550.t9 17.6708
R27088 a_24563_20550.n0 a_24563_20550.t7 8.81561
R27089 a_18043_20550.t3 a_18043_20550.n5 10.0462
R27090 a_18043_20550.n5 a_18043_20550.t6 8.90498
R27091 a_18043_20550.n5 a_18043_20550.n0 1.09706
R27092 a_18043_20550.n0 a_18043_20550.n4 1.09706
R27093 a_18043_20550.n4 a_18043_20550.t4 8.90498
R27094 a_18043_20550.n4 a_18043_20550.t2 10.0462
R27095 a_18043_20550.n0 a_18043_20550.n1 18.263
R27096 a_18043_20550.n3 a_18043_20550.t8 17.0005
R27097 a_18043_20550.n1 a_18043_20550.n3 1.37206
R27098 a_18043_20550.n3 a_18043_20550.t1 18.9255
R27099 a_18043_20550.n2 a_18043_20550.t7 17.0005
R27100 a_18043_20550.n1 a_18043_20550.n2 1.37206
R27101 a_18043_20550.n2 a_18043_20550.t0 18.9255
R27102 a_18043_20550.n1 a_18043_20550.t9 17.6708
R27103 a_18043_20550.n0 a_18043_20550.t5 8.81561
R27104 a_11523_20550.t3 a_11523_20550.n5 10.0462
R27105 a_11523_20550.n5 a_11523_20550.t9 8.90498
R27106 a_11523_20550.n5 a_11523_20550.n0 1.09706
R27107 a_11523_20550.n0 a_11523_20550.n4 1.09706
R27108 a_11523_20550.n4 a_11523_20550.t7 8.90498
R27109 a_11523_20550.n4 a_11523_20550.t2 10.0462
R27110 a_11523_20550.n0 a_11523_20550.n1 18.263
R27111 a_11523_20550.n3 a_11523_20550.t6 17.0005
R27112 a_11523_20550.n1 a_11523_20550.n3 1.37206
R27113 a_11523_20550.n3 a_11523_20550.t1 18.9255
R27114 a_11523_20550.n2 a_11523_20550.t4 17.0005
R27115 a_11523_20550.n1 a_11523_20550.n2 1.37206
R27116 a_11523_20550.n2 a_11523_20550.t0 18.9255
R27117 a_11523_20550.n1 a_11523_20550.t5 17.6708
R27118 a_11523_20550.n0 a_11523_20550.t8 8.81561
R27119 a_5003_20550.t3 a_5003_20550.n5 10.0462
R27120 a_5003_20550.n5 a_5003_20550.t6 8.90498
R27121 a_5003_20550.n5 a_5003_20550.n0 1.09706
R27122 a_5003_20550.n0 a_5003_20550.n4 1.09706
R27123 a_5003_20550.n4 a_5003_20550.t4 8.90498
R27124 a_5003_20550.n4 a_5003_20550.t2 10.0462
R27125 a_5003_20550.n0 a_5003_20550.n1 18.263
R27126 a_5003_20550.n3 a_5003_20550.t8 17.0005
R27127 a_5003_20550.n1 a_5003_20550.n3 1.37206
R27128 a_5003_20550.n3 a_5003_20550.t1 18.9255
R27129 a_5003_20550.n2 a_5003_20550.t7 17.0005
R27130 a_5003_20550.n1 a_5003_20550.n2 1.37206
R27131 a_5003_20550.n2 a_5003_20550.t0 18.9255
R27132 a_5003_20550.n1 a_5003_20550.t9 17.6708
R27133 a_5003_20550.n0 a_5003_20550.t5 8.81561
R27134 a_43418_20514.t0 a_43418_20514.n0 8.53521
R27135 a_43418_20514.n0 a_43418_20514.t2 16.6582
R27136 a_43418_20514.n0 a_43418_20514.t1 6.13582
R27137 a_36898_20514.t0 a_36898_20514.n0 8.53521
R27138 a_36898_20514.n0 a_36898_20514.t2 16.6582
R27139 a_36898_20514.n0 a_36898_20514.t1 6.13582
R27140 a_42997_20494.t0 a_42997_20494.n0 8.53379
R27141 a_42997_20494.n0 a_42997_20494.t1 6.23476
R27142 a_42997_20494.n0 a_42997_20494.t2 35.9286
R27143 a_30378_20514.t0 a_30378_20514.n0 8.53521
R27144 a_30378_20514.n0 a_30378_20514.t2 16.6582
R27145 a_30378_20514.n0 a_30378_20514.t1 6.13582
R27146 a_36477_20494.t0 a_36477_20494.n0 8.53379
R27147 a_36477_20494.n0 a_36477_20494.t1 6.23476
R27148 a_36477_20494.n0 a_36477_20494.t2 35.9286
R27149 a_23858_20514.t0 a_23858_20514.n0 8.53521
R27150 a_23858_20514.n0 a_23858_20514.t2 16.6582
R27151 a_23858_20514.n0 a_23858_20514.t1 6.13582
R27152 a_29957_20494.t0 a_29957_20494.n0 8.53379
R27153 a_29957_20494.n0 a_29957_20494.t1 6.23476
R27154 a_29957_20494.n0 a_29957_20494.t2 35.9286
R27155 a_17338_20514.t0 a_17338_20514.n0 8.53521
R27156 a_17338_20514.n0 a_17338_20514.t2 16.6582
R27157 a_17338_20514.n0 a_17338_20514.t1 6.13582
R27158 a_23437_20494.t0 a_23437_20494.n0 8.53379
R27159 a_23437_20494.n0 a_23437_20494.t1 6.23476
R27160 a_23437_20494.n0 a_23437_20494.t2 35.9286
R27161 a_10818_20514.t0 a_10818_20514.n0 8.53521
R27162 a_10818_20514.n0 a_10818_20514.t2 16.6582
R27163 a_10818_20514.n0 a_10818_20514.t1 6.13582
R27164 a_16917_20494.t0 a_16917_20494.n0 8.53379
R27165 a_16917_20494.n0 a_16917_20494.t1 6.23476
R27166 a_16917_20494.n0 a_16917_20494.t2 35.9286
R27167 a_4298_20514.t0 a_4298_20514.n0 8.53521
R27168 a_4298_20514.n0 a_4298_20514.t2 16.6582
R27169 a_4298_20514.n0 a_4298_20514.t1 6.13582
R27170 a_10397_20494.t0 a_10397_20494.n0 8.53379
R27171 a_10397_20494.n0 a_10397_20494.t1 6.23476
R27172 a_10397_20494.n0 a_10397_20494.t2 35.9286
R27173 a_3877_20494.t0 a_3877_20494.n0 8.53379
R27174 a_3877_20494.n0 a_3877_20494.t1 6.23476
R27175 a_3877_20494.n0 a_3877_20494.t2 35.9286
R27176 a_51453_23453.n0 a_51453_23453.t4 17.0005
R27177 a_51453_23453.t1 a_51453_23453.n0 18.9255
R27178 a_51453_23453.n0 a_51453_23453.n1 1.37206
R27179 a_51453_23453.n3 a_51453_23453.t2 17.0005
R27180 a_51453_23453.n1 a_51453_23453.n3 1.37206
R27181 a_51453_23453.n3 a_51453_23453.t0 18.9255
R27182 a_51453_23453.n1 a_51453_23453.n2 18.2615
R27183 a_51453_23453.n2 a_51453_23453.t6 17.963
R27184 a_51453_23453.n2 a_51453_23453.t5 17.963
R27185 a_51453_23453.n1 a_51453_23453.t3 17.6708
R27186 a_51517_23976.t3 a_51517_23976.n0 17.413
R27187 a_51517_23976.n1 a_51517_23976.n2 1.183
R27188 a_51517_23976.n0 a_51517_23976.n1 1.183
R27189 a_51517_23976.n2 a_51517_23976.t2 17.413
R27190 a_51517_23976.n2 a_51517_23976.t0 17.4199
R27191 a_51517_23976.n1 a_51517_23976.t5 17.413
R27192 a_51517_23976.n1 a_51517_23976.t4 17.4199
R27193 a_51517_23976.n0 a_51517_23976.t1 17.4199
R27194 a_50626_23927.t0 a_50626_23927.n0 8.53521
R27195 a_50626_23927.n0 a_50626_23927.t2 16.6822
R27196 a_50626_23927.n0 a_50626_23927.t1 6.13626
R27197 a_50205_23947.t0 a_50205_23947.n0 8.53379
R27198 a_50205_23947.n0 a_50205_23947.t1 6.23454
R27199 a_50205_23947.n0 a_50205_23947.t2 35.7494
R27200 a_49514_24288.t0 a_49514_24288.t1 35.1591
R27201 a_50409_23971.t0 a_50409_23971.n0 8.76769
R27202 a_50409_23971.n0 a_50409_23971.t2 15.0661
R27203 a_50409_23971.n0 a_50409_23971.t1 5.94842
R27204 a_49608_24288.t0 a_49608_24288.n0 17.726
R27205 a_49608_24288.n0 a_49608_24288.t2 15.773
R27206 a_49608_24288.n0 a_49608_24288.t1 17.5293
R27207 a_49836_24166.t0 a_49836_24166.n0 17.0005
R27208 a_49836_24166.n0 a_49836_24166.t1 18.2612
R27209 a_49836_24166.n0 a_49836_24166.t2 15.5529
R27210 a_48860_23938.t0 a_48860_23938.n1 17.3368
R27211 a_48860_23938.n0 a_48860_23938.t1 8.47322
R27212 a_48860_23938.n0 a_48860_23938.t2 17.4516
R27213 a_48860_23938.n1 a_48860_23938.n0 0.103627
R27214 a_48860_23938.n1 a_48860_23938.t3 15.0435
R27215 a_48638_24352.t0 a_48638_24352.t1 35.2612
R27216 a_48758_23938.n0 a_48758_23938.t3 15.0005
R27217 a_48758_23938.t0 a_48758_23938.n0 17.9114
R27218 a_48758_23938.n1 a_48758_23938.t1 17.0005
R27219 a_48758_23938.n0 a_48758_23938.n1 0.655551
R27220 a_48758_23938.n1 a_48758_23938.t2 15.2176
R27221 a_48349_23931.t0 a_48349_23931.n2 17.9378
R27222 a_48349_23931.n2 a_48349_23931.t1 18.3531
R27223 a_48349_23931.n2 a_48349_23931.n1 3.38628
R27224 a_48349_23931.n1 a_48349_23931.n0 0.498937
R27225 a_48349_23931.n0 a_48349_23931.t2 17.1232
R27226 a_48349_23931.n0 a_48349_23931.t3 18.4279
R27227 a_48349_23931.n1 a_48349_23931.t4 15.4204
R27228 a_48323_23895.n1 a_48323_23895.t1 17.2651
R27229 a_48323_23895.t0 a_48323_23895.n1 17.3352
R27230 a_48323_23895.n1 a_48323_23895.n0 0.948441
R27231 a_48323_23895.n0 a_48323_23895.t2 17.3305
R27232 a_48323_23895.n0 a_48323_23895.t3 15.4436
R27233 a_48063_24365.t0 a_48063_24365.n1 17.0005
R27234 a_48063_24365.n1 a_48063_24365.t1 18.6222
R27235 a_48063_24365.n0 a_48063_24365.t2 17.0005
R27236 a_48063_24365.n1 a_48063_24365.n0 3.28463
R27237 a_48063_24365.n0 a_48063_24365.t3 18.3191
R27238 a_51516_24785.t3 a_51516_24785.n0 17.3167
R27239 a_51516_24785.n1 a_51516_24785.n2 1.14175
R27240 a_51516_24785.n0 a_51516_24785.n1 1.14175
R27241 a_51516_24785.n2 a_51516_24785.t2 17.3167
R27242 a_51516_24785.n2 a_51516_24785.t0 17.3099
R27243 a_51516_24785.n1 a_51516_24785.t4 17.3167
R27244 a_51516_24785.n1 a_51516_24785.t5 17.3099
R27245 a_51516_24785.n0 a_51516_24785.t1 17.3099
R27246 a_49514_24814.t0 a_49514_24814.t1 35.1591
R27247 a_48638_24750.t0 a_48638_24750.t1 35.2643
R27248 a_50409_25015.t0 a_50409_25015.n0 8.76769
R27249 a_50409_25015.n0 a_50409_25015.t2 15.0661
R27250 a_50409_25015.n0 a_50409_25015.t1 5.94842
R27251 a_49836_24954.t0 a_49836_24954.n0 17.0005
R27252 a_49836_24954.n0 a_49836_24954.t1 18.2612
R27253 a_49836_24954.n0 a_49836_24954.t2 15.5529
R27254 a_49608_24814.t0 a_49608_24814.n0 17.5293
R27255 a_49608_24814.n0 a_49608_24814.t1 17.726
R27256 a_49608_24814.n0 a_49608_24814.t2 15.773
R27257 a_4321_24727.t0 a_4321_24727.n0 8.7901
R27258 a_4321_24727.n0 a_4321_24727.n1 29.9877
R27259 a_4321_24727.n6 a_4321_24727.n7 1.7605
R27260 a_4321_24727.n5 a_4321_24727.n6 1.7605
R27261 a_4321_24727.n4 a_4321_24727.n5 1.7605
R27262 a_4321_24727.n3 a_4321_24727.n4 1.7605
R27263 a_4321_24727.n2 a_4321_24727.n3 1.7605
R27264 a_4321_24727.n1 a_4321_24727.n2 1.7605
R27265 a_4321_24727.n7 a_4321_24727.t2 26.2388
R27266 a_4321_24727.n7 a_4321_24727.t3 24.4788
R27267 a_4321_24727.n6 a_4321_24727.t4 24.4788
R27268 a_4321_24727.n5 a_4321_24727.t5 24.4788
R27269 a_4321_24727.n4 a_4321_24727.t6 24.4788
R27270 a_4321_24727.n3 a_4321_24727.t7 24.4788
R27271 a_4321_24727.n2 a_4321_24727.t8 24.4788
R27272 a_4321_24727.n1 a_4321_24727.t9 24.4788
R27273 a_4321_24727.n0 a_4321_24727.t1 5.92019
R27274 a_48860_25081.t0 a_48860_25081.n1 17.3368
R27275 a_48860_25081.n0 a_48860_25081.t1 8.47322
R27276 a_48860_25081.n1 a_48860_25081.n0 0.103627
R27277 a_48860_25081.n0 a_48860_25081.t2 17.4516
R27278 a_48860_25081.n1 a_48860_25081.t3 15.0435
R27279 a_48758_24994.n0 a_48758_24994.t3 15.0005
R27280 a_48758_24994.t0 a_48758_24994.n0 17.9114
R27281 a_48758_24994.n1 a_48758_24994.t1 17.0005
R27282 a_48758_24994.n0 a_48758_24994.n1 0.655551
R27283 a_48758_24994.n1 a_48758_24994.t2 15.2176
R27284 a_48349_25055.t0 a_48349_25055.n2 17.9378
R27285 a_48349_25055.n2 a_48349_25055.t1 18.3531
R27286 a_48349_25055.n2 a_48349_25055.n1 3.38952
R27287 a_48349_25055.n1 a_48349_25055.n0 0.498937
R27288 a_48349_25055.n0 a_48349_25055.t2 17.1232
R27289 a_48349_25055.n0 a_48349_25055.t3 18.4279
R27290 a_48349_25055.n1 a_48349_25055.t4 15.4204
R27291 a_48063_24737.t0 a_48063_24737.n1 17.0005
R27292 a_48063_24737.n1 a_48063_24737.t1 18.6222
R27293 a_48063_24737.n0 a_48063_24737.t3 17.0005
R27294 a_48063_24737.n1 a_48063_24737.n0 3.28463
R27295 a_48063_24737.n0 a_48063_24737.t2 18.3191
R27296 a_4285_24701.t0 a_4285_24701.n0 17.5197
R27297 a_4285_24701.n0 a_4285_24701.t1 8.76789
R27298 a_4285_24701.n0 a_4285_24701.t2 15.4262
R27299 a_48323_24960.t0 a_48323_24960.n1 17.2651
R27300 a_48323_24960.n1 a_48323_24960.t1 17.3352
R27301 a_48323_24960.n1 a_48323_24960.n0 0.948441
R27302 a_48323_24960.n0 a_48323_24960.t2 17.3305
R27303 a_48323_24960.n0 a_48323_24960.t3 15.4436
R27304 a_653_546.t0 a_653_546.n0 8.9106
R27305 a_653_546.n0 a_653_546.n1 9.07558
R27306 a_653_546.n6 a_653_546.n7 1.7605
R27307 a_653_546.n5 a_653_546.n6 1.7605
R27308 a_653_546.n4 a_653_546.n5 1.7605
R27309 a_653_546.n3 a_653_546.n4 1.7605
R27310 a_653_546.n2 a_653_546.n3 1.7605
R27311 a_653_546.n1 a_653_546.n2 1.7605
R27312 a_653_546.n7 a_653_546.t2 26.2388
R27313 a_653_546.n7 a_653_546.t3 24.4788
R27314 a_653_546.n6 a_653_546.t4 24.4788
R27315 a_653_546.n5 a_653_546.t5 24.4788
R27316 a_653_546.n4 a_653_546.t6 24.4788
R27317 a_653_546.n3 a_653_546.t7 24.4788
R27318 a_653_546.n2 a_653_546.t8 24.4788
R27319 a_653_546.n1 a_653_546.t9 24.4788
R27320 a_653_546.n0 a_653_546.t1 6.11623
R27321 a_2033_24727.t0 a_2033_24727.n0 8.72469
R27322 a_2033_24727.n0 a_2033_24727.n1 23.6951
R27323 a_2033_24727.n6 a_2033_24727.n7 1.7605
R27324 a_2033_24727.n5 a_2033_24727.n6 1.7605
R27325 a_2033_24727.n4 a_2033_24727.n5 1.7605
R27326 a_2033_24727.n3 a_2033_24727.n4 1.7605
R27327 a_2033_24727.n2 a_2033_24727.n3 1.7605
R27328 a_2033_24727.n1 a_2033_24727.n2 1.7605
R27329 a_2033_24727.n7 a_2033_24727.t2 26.2388
R27330 a_2033_24727.n7 a_2033_24727.t3 24.4788
R27331 a_2033_24727.n6 a_2033_24727.t4 24.4788
R27332 a_2033_24727.n5 a_2033_24727.t5 24.4788
R27333 a_2033_24727.n4 a_2033_24727.t6 24.4788
R27334 a_2033_24727.n3 a_2033_24727.t7 24.4788
R27335 a_2033_24727.n2 a_2033_24727.t8 24.4788
R27336 a_2033_24727.n1 a_2033_24727.t9 24.4788
R27337 a_2033_24727.n0 a_2033_24727.t1 5.98559
R27338 a_1253_24711.t0 a_1253_24711.n0 8.81727
R27339 a_1253_24711.n0 a_1253_24711.n1 16.5577
R27340 a_1253_24711.n6 a_1253_24711.n7 1.7605
R27341 a_1253_24711.n5 a_1253_24711.n6 1.7605
R27342 a_1253_24711.n4 a_1253_24711.n5 1.7605
R27343 a_1253_24711.n3 a_1253_24711.n4 1.7605
R27344 a_1253_24711.n2 a_1253_24711.n3 1.7605
R27345 a_1253_24711.n1 a_1253_24711.n2 1.7605
R27346 a_1253_24711.n7 a_1253_24711.t2 26.2388
R27347 a_1253_24711.n7 a_1253_24711.t3 24.4788
R27348 a_1253_24711.n6 a_1253_24711.t4 24.4788
R27349 a_1253_24711.n5 a_1253_24711.t5 24.4788
R27350 a_1253_24711.n4 a_1253_24711.t6 24.4788
R27351 a_1253_24711.n3 a_1253_24711.t7 24.4788
R27352 a_1253_24711.n2 a_1253_24711.t8 24.4788
R27353 a_1253_24711.n1 a_1253_24711.t9 24.4788
R27354 a_1253_24711.n0 a_1253_24711.t1 6.20956
R27355 a_2713_24685.t0 a_2713_24685.n0 17.1718
R27356 a_2713_24685.n0 a_2713_24685.t1 9.7423
R27357 a_2713_24685.n0 a_2713_24685.t2 15.4943
R27358 a_4305_24905.t0 a_4305_24905.n0 8.78861
R27359 a_4305_24905.n0 a_4305_24905.t1 6.03168
R27360 a_4305_24905.n0 a_4305_24905.t2 33.604
R27361 a_1997_24701.t0 a_1997_24701.n0 17.5197
R27362 a_1997_24701.n0 a_1997_24701.t1 8.76689
R27363 a_1997_24701.n0 a_1997_24701.t2 15.4262
R27364 a_1201_24685.t0 a_1201_24685.n0 17.1718
R27365 a_1201_24685.n0 a_1201_24685.t1 9.7423
R27366 a_1201_24685.n0 a_1201_24685.t2 15.4943
R27367 a_51440_25469.t6 a_51440_25469.n0 17.8083
R27368 a_51440_25469.n0 a_51440_25469.t5 17.8083
R27369 a_51440_25469.n0 a_51440_25469.n1 18.2455
R27370 a_51440_25469.n3 a_51440_25469.t4 17.0005
R27371 a_51440_25469.n1 a_51440_25469.n3 1.37206
R27372 a_51440_25469.n3 a_51440_25469.t1 18.9255
R27373 a_51440_25469.n2 a_51440_25469.t2 17.0005
R27374 a_51440_25469.n1 a_51440_25469.n2 1.37206
R27375 a_51440_25469.n2 a_51440_25469.t0 18.9255
R27376 a_51440_25469.n1 a_51440_25469.t3 17.6708
R27377 a_3545_25331.t0 a_3545_25331.n0 8.71577
R27378 a_3545_25331.n0 a_3545_25331.n1 27.733
R27379 a_3545_25331.n6 a_3545_25331.n7 1.7605
R27380 a_3545_25331.n5 a_3545_25331.n6 1.7605
R27381 a_3545_25331.n4 a_3545_25331.n5 1.7605
R27382 a_3545_25331.n3 a_3545_25331.n4 1.7605
R27383 a_3545_25331.n2 a_3545_25331.n3 1.7605
R27384 a_3545_25331.n1 a_3545_25331.n2 1.7605
R27385 a_3545_25331.n7 a_3545_25331.t2 26.2388
R27386 a_3545_25331.n7 a_3545_25331.t3 24.4788
R27387 a_3545_25331.n6 a_3545_25331.t4 24.4788
R27388 a_3545_25331.n5 a_3545_25331.t5 24.4788
R27389 a_3545_25331.n4 a_3545_25331.t6 24.4788
R27390 a_3545_25331.n3 a_3545_25331.t7 24.4788
R27391 a_3545_25331.n2 a_3545_25331.t8 24.4788
R27392 a_3545_25331.n1 a_3545_25331.t9 24.4788
R27393 a_3545_25331.n0 a_3545_25331.t1 5.99451
R27394 a_50626_25035.t0 a_50626_25035.n0 8.53521
R27395 a_50626_25035.n0 a_50626_25035.t2 16.0896
R27396 a_50626_25035.n0 a_50626_25035.t1 6.13582
R27397 a_2713_24910.t0 a_2713_24910.n0 8.98227
R27398 a_2713_24910.n0 a_2713_24910.t1 6.15456
R27399 a_2713_24910.n0 a_2713_24910.n1 9.21898
R27400 a_2713_24910.n1 a_2713_24910.n2 16.6392
R27401 a_2713_24910.n7 a_2713_24910.n8 1.7605
R27402 a_2713_24910.n6 a_2713_24910.n7 1.7605
R27403 a_2713_24910.n5 a_2713_24910.n6 1.7605
R27404 a_2713_24910.n4 a_2713_24910.n5 1.7605
R27405 a_2713_24910.n3 a_2713_24910.n4 1.7605
R27406 a_2713_24910.n2 a_2713_24910.n3 1.7605
R27407 a_2713_24910.n8 a_2713_24910.t2 26.2388
R27408 a_2713_24910.n8 a_2713_24910.t3 24.4788
R27409 a_2713_24910.n7 a_2713_24910.t4 24.4788
R27410 a_2713_24910.n6 a_2713_24910.t5 24.4788
R27411 a_2713_24910.n5 a_2713_24910.t6 24.4788
R27412 a_2713_24910.n4 a_2713_24910.t7 24.4788
R27413 a_2713_24910.n3 a_2713_24910.t8 24.4788
R27414 a_2713_24910.n2 a_2713_24910.t9 24.4788
R27415 a_2713_24910.n1 a_2713_24910.t10 24.2598
R27416 a_50205_25015.t0 a_50205_25015.n0 8.53379
R27417 a_50205_25015.n0 a_50205_25015.t1 6.23476
R27418 a_50205_25015.n0 a_50205_25015.t2 35.4854
R27419 a_4285_25305.t0 a_4285_25305.n0 17.5197
R27420 a_4285_25305.n0 a_4285_25305.t1 8.76789
R27421 a_4285_25305.n0 a_4285_25305.t2 15.4262
R27422 a_1997_24905.t0 a_1997_24905.n0 8.9656
R27423 a_1997_24905.n0 a_1997_24905.t1 6.17123
R27424 a_1997_24905.n0 a_1997_24905.t2 33.6161
R27425 a_1201_24910.t0 a_1201_24910.n0 8.74253
R27426 a_1201_24910.n0 a_1201_24910.t2 33.671
R27427 a_1201_24910.n0 a_1201_24910.t1 5.96776
R27428 a_3509_25305.t1 a_3509_25305.n0 17.5197
R27429 a_3509_25305.n0 a_3509_25305.t0 8.76689
R27430 a_3509_25305.n0 a_3509_25305.t2 15.4262
R27431 a_2713_25289.t0 a_2713_25289.n0 17.1718
R27432 a_2713_25289.n0 a_2713_25289.t1 9.7423
R27433 a_2713_25289.n0 a_2713_25289.t2 15.4943
R27434 a_521_25453.t0 a_521_25453.n0 8.72376
R27435 a_521_25453.n0 a_521_25453.t1 17.1849
R27436 a_521_25453.n6 a_521_25453.n7 1.7605
R27437 a_521_25453.n5 a_521_25453.n6 1.7605
R27438 a_521_25453.n4 a_521_25453.n5 1.7605
R27439 a_521_25453.n3 a_521_25453.n4 1.7605
R27440 a_521_25453.n2 a_521_25453.n3 1.7605
R27441 a_521_25453.n1 a_521_25453.n2 1.7605
R27442 a_521_25453.n0 a_521_25453.n1 25.3638
R27443 a_521_25453.n7 a_521_25453.t2 26.2388
R27444 a_521_25453.n7 a_521_25453.t3 24.4788
R27445 a_521_25453.n6 a_521_25453.t4 24.4788
R27446 a_521_25453.n5 a_521_25453.t5 24.4788
R27447 a_521_25453.n4 a_521_25453.t6 24.4788
R27448 a_521_25453.n3 a_521_25453.t7 24.4788
R27449 a_521_25453.n2 a_521_25453.t8 24.4788
R27450 a_521_25453.n1 a_521_25453.t9 24.4788
R27451 a_1963_25289.t0 a_1963_25289.n0 17.1718
R27452 a_1963_25289.n0 a_1963_25289.t1 9.7433
R27453 a_1963_25289.n0 a_1963_25289.t2 15.4943
R27454 a_1261_25305.t0 a_1261_25305.n0 17.5197
R27455 a_1261_25305.n0 a_1261_25305.t1 8.76789
R27456 a_1261_25305.n0 a_1261_25305.t2 15.4262
R27457 a_485_25427.t0 a_485_25427.n0 9.7993
R27458 a_485_25427.n0 a_485_25427.t1 5.96895
R27459 a_485_25427.n0 a_485_25427.t2 16.0183
R27460 a_51440_26253.n0 a_51440_26253.t3 17.0005
R27461 a_51440_26253.t1 a_51440_26253.n0 18.9255
R27462 a_51440_26253.n0 a_51440_26253.n1 1.26894
R27463 a_51440_26253.n2 a_51440_26253.t2 17.0005
R27464 a_51440_26253.n1 a_51440_26253.n2 1.26894
R27465 a_51440_26253.n2 a_51440_26253.t0 18.9255
R27466 a_51440_26253.n1 a_51440_26253.t5 35.2968
R27467 a_51440_26253.n1 a_51440_26253.t4 17.5677
R27468 a_51683_26669.t3 a_51683_26669.n0 17.2617
R27469 a_51683_26669.n0 a_51683_26669.n1 1.14175
R27470 a_51683_26669.n1 a_51683_26669.t2 17.2617
R27471 a_51683_26669.n1 a_51683_26669.t0 17.2755
R27472 a_51683_26669.n0 a_51683_26669.t1 17.2755
R27473 a_50817_26469.t0 a_50817_26469.n0 8.53521
R27474 a_50817_26469.n0 a_50817_26469.t2 15.9583
R27475 a_50817_26469.n0 a_50817_26469.t1 6.13626
R27476 a_50396_26489.t0 a_50396_26489.n0 8.53379
R27477 a_50396_26489.n0 a_50396_26489.t1 6.23454
R27478 a_50396_26489.n0 a_50396_26489.t2 35.0744
R27479 a_49705_26830.t0 a_49705_26830.t1 35.1591
R27480 a_50600_26513.t0 a_50600_26513.n0 8.76769
R27481 a_50600_26513.n0 a_50600_26513.t2 15.0661
R27482 a_50600_26513.n0 a_50600_26513.t1 5.94842
R27483 a_49799_26830.t0 a_49799_26830.n0 17.5293
R27484 a_49799_26830.n0 a_49799_26830.t1 17.726
R27485 a_49799_26830.n0 a_49799_26830.t2 15.773
R27486 a_50027_26708.n0 a_50027_26708.t1 17.0005
R27487 a_50027_26708.t0 a_50027_26708.n0 18.2612
R27488 a_50027_26708.n0 a_50027_26708.t2 15.5529
R27489 a_49051_26480.t0 a_49051_26480.n1 17.3368
R27490 a_49051_26480.n0 a_49051_26480.t1 8.47322
R27491 a_49051_26480.n0 a_49051_26480.t2 17.4516
R27492 a_49051_26480.n1 a_49051_26480.n0 0.103627
R27493 a_49051_26480.n1 a_49051_26480.t3 15.0435
R27494 a_48829_26894.t0 a_48829_26894.t1 35.2612
R27495 a_48949_26480.n0 a_48949_26480.t3 15.0005
R27496 a_48949_26480.t0 a_48949_26480.n0 17.9114
R27497 a_48949_26480.n1 a_48949_26480.t1 17.0005
R27498 a_48949_26480.n0 a_48949_26480.n1 0.655551
R27499 a_48949_26480.n1 a_48949_26480.t2 15.2176
R27500 a_48540_26473.t0 a_48540_26473.n2 17.9378
R27501 a_48540_26473.n2 a_48540_26473.t1 18.3531
R27502 a_48540_26473.n2 a_48540_26473.n1 3.38628
R27503 a_48540_26473.n1 a_48540_26473.n0 0.498937
R27504 a_48540_26473.n0 a_48540_26473.t2 17.1232
R27505 a_48540_26473.n0 a_48540_26473.t3 18.4279
R27506 a_48540_26473.n1 a_48540_26473.t4 15.4204
R27507 a_48514_26437.n1 a_48514_26437.t1 17.2651
R27508 a_48514_26437.t0 a_48514_26437.n1 17.3352
R27509 a_48514_26437.n1 a_48514_26437.n0 0.948441
R27510 a_48514_26437.n0 a_48514_26437.t2 17.3305
R27511 a_48514_26437.n0 a_48514_26437.t3 15.4436
R27512 a_48254_26907.t0 a_48254_26907.n1 17.0005
R27513 a_48254_26907.n1 a_48254_26907.t1 18.6222
R27514 a_48254_26907.n0 a_48254_26907.t3 17.0005
R27515 a_48254_26907.n1 a_48254_26907.n0 3.28463
R27516 a_48254_26907.n0 a_48254_26907.t2 18.3191
R27517 a_51768_27313.t1 a_51768_27313.t0 34.523
R27518 a_49705_27296.t0 a_49705_27296.t1 35.1591
R27519 a_48829_27232.t0 a_48829_27232.t1 35.2643
R27520 a_50600_27497.t0 a_50600_27497.n0 8.76769
R27521 a_50600_27497.n0 a_50600_27497.t2 15.0661
R27522 a_50600_27497.n0 a_50600_27497.t1 5.94842
R27523 a_50027_27436.t0 a_50027_27436.n0 17.0005
R27524 a_50027_27436.n0 a_50027_27436.t1 18.2612
R27525 a_50027_27436.n0 a_50027_27436.t2 15.5529
R27526 a_49799_27296.t0 a_49799_27296.n0 17.726
R27527 a_49799_27296.n0 a_49799_27296.t2 15.773
R27528 a_49799_27296.n0 a_49799_27296.t1 17.5293
R27529 a_49051_27563.t0 a_49051_27563.n1 17.3368
R27530 a_49051_27563.n0 a_49051_27563.t1 8.47322
R27531 a_49051_27563.n1 a_49051_27563.n0 0.103627
R27532 a_49051_27563.n0 a_49051_27563.t2 17.4516
R27533 a_49051_27563.n1 a_49051_27563.t3 15.0435
R27534 a_48949_27476.n0 a_48949_27476.t3 15.0005
R27535 a_48949_27476.t0 a_48949_27476.n0 17.9114
R27536 a_48949_27476.n1 a_48949_27476.t1 17.0005
R27537 a_48949_27476.n0 a_48949_27476.n1 0.655551
R27538 a_48949_27476.n1 a_48949_27476.t2 15.2176
R27539 a_48540_27537.t0 a_48540_27537.n2 17.1232
R27540 a_48540_27537.n2 a_48540_27537.n0 0.498937
R27541 a_48540_27537.n2 a_48540_27537.t1 18.4279
R27542 a_48540_27537.n0 a_48540_27537.n1 3.38952
R27543 a_48540_27537.n1 a_48540_27537.t3 18.3531
R27544 a_48540_27537.n1 a_48540_27537.t2 17.9378
R27545 a_48540_27537.n0 a_48540_27537.t4 15.4204
R27546 a_48254_27219.n0 a_48254_27219.t1 17.0005
R27547 a_48254_27219.t0 a_48254_27219.n0 18.3191
R27548 a_48254_27219.n1 a_48254_27219.t2 17.0005
R27549 a_48254_27219.n0 a_48254_27219.n1 3.28463
R27550 a_48254_27219.n1 a_48254_27219.t3 18.6222
R27551 a_48514_27442.t0 a_48514_27442.n1 17.3305
R27552 a_48514_27442.n1 a_48514_27442.n0 0.948441
R27553 a_48514_27442.n0 a_48514_27442.t2 17.2651
R27554 a_48514_27442.n0 a_48514_27442.t1 17.3352
R27555 a_48514_27442.n1 a_48514_27442.t3 15.4436
R27556 6MSB_0.OUTP.n187 6MSB_0.OUTP.t1 18.0077
R27557 6MSB_0.OUTP.n187 6MSB_0.OUTP.t0 20.1114
R27558 6MSB_0.OUTP.n186 6MSB_0.OUTP.n187 16.1014
R27559 6MSB_0.OUTP.n183 6MSB_0.OUTP.n185 21.2243
R27560 6MSB_0.OUTP.n181 6MSB_0.OUTP.n183 5.12336
R27561 6MSB_0.OUTP.n179 6MSB_0.OUTP.n181 5.12336
R27562 6MSB_0.OUTP.n177 6MSB_0.OUTP.n179 5.12336
R27563 6MSB_0.OUTP.n186 6MSB_0.OUTP.n177 5.12336
R27564 6MSB_0.OUTP.n175 6MSB_0.OUTP.n186 5.12336
R27565 6MSB_0.OUTP.n173 6MSB_0.OUTP.n175 5.12336
R27566 6MSB_0.OUTP.n3 6MSB_0.OUTP.n173 3.21449
R27567 6MSB_0.OUTP.n185 6MSB_0.OUTP.t58 20.1114
R27568 6MSB_0.OUTP.n185 6MSB_0.OUTP.t59 18.0077
R27569 6MSB_0.OUTP.n183 6MSB_0.OUTP.n184 16.1014
R27570 6MSB_0.OUTP.n184 6MSB_0.OUTP.t56 20.1114
R27571 6MSB_0.OUTP.n184 6MSB_0.OUTP.t57 18.0077
R27572 6MSB_0.OUTP.n181 6MSB_0.OUTP.n182 16.1014
R27573 6MSB_0.OUTP.n182 6MSB_0.OUTP.t44 20.1114
R27574 6MSB_0.OUTP.n182 6MSB_0.OUTP.t45 18.0077
R27575 6MSB_0.OUTP.n179 6MSB_0.OUTP.n180 16.1014
R27576 6MSB_0.OUTP.n180 6MSB_0.OUTP.t120 20.1114
R27577 6MSB_0.OUTP.n180 6MSB_0.OUTP.t121 18.0077
R27578 6MSB_0.OUTP.n177 6MSB_0.OUTP.n178 16.1014
R27579 6MSB_0.OUTP.n178 6MSB_0.OUTP.t72 20.1114
R27580 6MSB_0.OUTP.n178 6MSB_0.OUTP.t73 18.0077
R27581 6MSB_0.OUTP.n175 6MSB_0.OUTP.n176 16.1014
R27582 6MSB_0.OUTP.n176 6MSB_0.OUTP.t70 20.1114
R27583 6MSB_0.OUTP.n176 6MSB_0.OUTP.t71 18.0077
R27584 6MSB_0.OUTP.n173 6MSB_0.OUTP.n174 16.1014
R27585 6MSB_0.OUTP.n174 6MSB_0.OUTP.t2 20.1114
R27586 6MSB_0.OUTP.n174 6MSB_0.OUTP.t3 18.0077
R27587 6MSB_0.OUTP.n0 6MSB_0.OUTP.n1 4.501
R27588 6MSB_0.OUTP.n4 6MSB_0.OUTP.n2 4.49441
R27589 6MSB_0.OUTP.n0 6MSB_0.OUTP.n3 9.0005
R27590 6MSB_0.OUTP.n1 6MSB_0.OUTP.n2 0.0697368
R27591 6MSB_0.OUTP.n5 6MSB_0.OUTP.n4 0.0141807
R27592 6MSB_0.OUTP.n5 6MSB_0.OUTP.n3 9.0005
R27593 6MSB_0.OUTP.n2 6MSB_0.OUTP.n3 0.0553571
R27594 6MSB_0.OUTP.n5 6MSB_0.OUTP.n1 4.50175
R27595 6MSB_0.OUTP.n6 6MSB_0.OUTP.n7 9.0005
R27596 6MSB_0.OUTP.n10 6MSB_0.OUTP.n8 4.49441
R27597 6MSB_0.OUTP.n12 6MSB_0.OUTP.n9 0.0283452
R27598 6MSB_0.OUTP.n6 6MSB_0.OUTP.n12 4.48733
R27599 6MSB_0.OUTP.n11 6MSB_0.OUTP.n7 9.0005
R27600 6MSB_0.OUTP.n11 6MSB_0.OUTP.n10 0.0141807
R27601 6MSB_0.OUTP.n11 6MSB_0.OUTP.n9 9.0005
R27602 6MSB_0.OUTP.n11 6MSB_0.OUTP.n13 9.0005
R27603 6MSB_0.OUTP.n29 6MSB_0.OUTP.n30 9.0005
R27604 6MSB_0.OUTP.n33 6MSB_0.OUTP.n31 4.49441
R27605 6MSB_0.OUTP.n35 6MSB_0.OUTP.n32 0.0283452
R27606 6MSB_0.OUTP.n29 6MSB_0.OUTP.n35 4.48733
R27607 6MSB_0.OUTP.n34 6MSB_0.OUTP.n30 9.0005
R27608 6MSB_0.OUTP.n34 6MSB_0.OUTP.n33 0.0141807
R27609 6MSB_0.OUTP.n34 6MSB_0.OUTP.n32 9.0005
R27610 6MSB_0.OUTP.n34 6MSB_0.OUTP.n36 9.0005
R27611 6MSB_0.OUTP.n52 6MSB_0.OUTP.n53 9.0005
R27612 6MSB_0.OUTP.n56 6MSB_0.OUTP.n54 4.49441
R27613 6MSB_0.OUTP.n58 6MSB_0.OUTP.n55 0.0283452
R27614 6MSB_0.OUTP.n52 6MSB_0.OUTP.n58 4.48733
R27615 6MSB_0.OUTP.n57 6MSB_0.OUTP.n53 9.0005
R27616 6MSB_0.OUTP.n57 6MSB_0.OUTP.n56 0.0141807
R27617 6MSB_0.OUTP.n57 6MSB_0.OUTP.n55 9.0005
R27618 6MSB_0.OUTP.n57 6MSB_0.OUTP.n59 9.0005
R27619 6MSB_0.OUTP.n75 6MSB_0.OUTP.n76 9.0005
R27620 6MSB_0.OUTP.n79 6MSB_0.OUTP.n77 4.49441
R27621 6MSB_0.OUTP.n81 6MSB_0.OUTP.n78 0.0283452
R27622 6MSB_0.OUTP.n75 6MSB_0.OUTP.n81 4.48733
R27623 6MSB_0.OUTP.n80 6MSB_0.OUTP.n76 9.0005
R27624 6MSB_0.OUTP.n80 6MSB_0.OUTP.n79 0.0141807
R27625 6MSB_0.OUTP.n80 6MSB_0.OUTP.n78 9.0005
R27626 6MSB_0.OUTP.n80 6MSB_0.OUTP.n82 9.0005
R27627 6MSB_0.OUTP.n98 6MSB_0.OUTP.n99 9.0005
R27628 6MSB_0.OUTP.n102 6MSB_0.OUTP.n100 4.49441
R27629 6MSB_0.OUTP.n104 6MSB_0.OUTP.n101 0.0283452
R27630 6MSB_0.OUTP.n98 6MSB_0.OUTP.n104 4.48733
R27631 6MSB_0.OUTP.n103 6MSB_0.OUTP.n99 9.0005
R27632 6MSB_0.OUTP.n103 6MSB_0.OUTP.n102 0.0141807
R27633 6MSB_0.OUTP.n103 6MSB_0.OUTP.n101 9.0005
R27634 6MSB_0.OUTP.n103 6MSB_0.OUTP.n105 9.0005
R27635 6MSB_0.OUTP.n121 6MSB_0.OUTP.n122 9.0005
R27636 6MSB_0.OUTP.n125 6MSB_0.OUTP.n123 4.49441
R27637 6MSB_0.OUTP.n127 6MSB_0.OUTP.n124 0.0283452
R27638 6MSB_0.OUTP.n121 6MSB_0.OUTP.n127 4.48733
R27639 6MSB_0.OUTP.n126 6MSB_0.OUTP.n122 9.0005
R27640 6MSB_0.OUTP.n126 6MSB_0.OUTP.n125 0.0141807
R27641 6MSB_0.OUTP.n126 6MSB_0.OUTP.n124 9.0005
R27642 6MSB_0.OUTP.n126 6MSB_0.OUTP.n128 9.0005
R27643 6MSB_0.OUTP.n144 6MSB_0.OUTP.n145 9.0005
R27644 6MSB_0.OUTP.n148 6MSB_0.OUTP.n146 4.49441
R27645 6MSB_0.OUTP.n150 6MSB_0.OUTP.n147 0.0283452
R27646 6MSB_0.OUTP.n144 6MSB_0.OUTP.n150 4.48733
R27647 6MSB_0.OUTP.n149 6MSB_0.OUTP.n145 9.0005
R27648 6MSB_0.OUTP.n149 6MSB_0.OUTP.n148 0.0141807
R27649 6MSB_0.OUTP.n149 6MSB_0.OUTP.n147 9.0005
R27650 6MSB_0.OUTP.n149 6MSB_0.OUTP.n151 9.0005
R27651 6MSB_0.OUTP.n165 6MSB_0.OUTP.n166 14.05
R27652 6MSB_0.OUTP.n167 6MSB_0.OUTP.n168 14.0728
R27653 6MSB_0.OUTP.n169 6MSB_0.OUTP.n170 14.0713
R27654 6MSB_0.OUTP.n171 6MSB_0.OUTP.n172 14.0606
R27655 6MSB_0.OUTP.n10 6MSB_0.OUTP.n6 0.0141807
R27656 6MSB_0.OUTP.n29 6MSB_0.OUTP.n11 0.7441
R27657 6MSB_0.OUTP.n33 6MSB_0.OUTP.n29 0.0141807
R27658 6MSB_0.OUTP.n0 6MSB_0.OUTP.n34 0.7441
R27659 6MSB_0.OUTP.n4 6MSB_0.OUTP.n0 0.0141807
R27660 6MSB_0.OUTP.n52 6MSB_0.OUTP.n5 0.7441
R27661 6MSB_0.OUTP.n56 6MSB_0.OUTP.n52 0.0141807
R27662 6MSB_0.OUTP.n75 6MSB_0.OUTP.n57 0.7441
R27663 6MSB_0.OUTP.n79 6MSB_0.OUTP.n75 0.0141807
R27664 6MSB_0.OUTP.n98 6MSB_0.OUTP.n80 0.7441
R27665 6MSB_0.OUTP.n102 6MSB_0.OUTP.n98 0.0141807
R27666 6MSB_0.OUTP.n121 6MSB_0.OUTP.n103 0.7441
R27667 6MSB_0.OUTP.n125 6MSB_0.OUTP.n121 0.0141807
R27668 6MSB_0.OUTP.n144 6MSB_0.OUTP.n126 0.7441
R27669 6MSB_0.OUTP.n148 6MSB_0.OUTP.n144 0.0141807
R27670 6MSB_0.OUTP.n165 6MSB_0.OUTP.n149 0.34755
R27671 6MSB_0.OUTP.n167 6MSB_0.OUTP.n165 0.70615
R27672 6MSB_0.OUTP.n169 6MSB_0.OUTP.n167 0.06485
R27673 6MSB_0.OUTP.n171 6MSB_0.OUTP.n169 0.59285
R27674 6MSB_0.OUTP 6MSB_0.OUTP.n171 0.332425
R27675 6MSB_0.OUTP.n172 6MSB_0.OUTP.t69 17.8461
R27676 6MSB_0.OUTP.n172 6MSB_0.OUTP.t68 18.5474
R27677 6MSB_0.OUTP.n170 6MSB_0.OUTP.t20 18.5474
R27678 6MSB_0.OUTP.n170 6MSB_0.OUTP.t21 17.8461
R27679 6MSB_0.OUTP.n168 6MSB_0.OUTP.t33 17.8461
R27680 6MSB_0.OUTP.n168 6MSB_0.OUTP.t32 18.5474
R27681 6MSB_0.OUTP.n166 6MSB_0.OUTP.t38 18.5474
R27682 6MSB_0.OUTP.n166 6MSB_0.OUTP.t39 17.8461
R27683 6MSB_0.OUTP.n150 6MSB_0.OUTP.n151 0.0283452
R27684 6MSB_0.OUTP.n147 6MSB_0.OUTP.n146 0.0553571
R27685 6MSB_0.OUTP.n146 6MSB_0.OUTP.n145 0.0553571
R27686 6MSB_0.OUTP.n162 6MSB_0.OUTP.n164 21.2243
R27687 6MSB_0.OUTP.n160 6MSB_0.OUTP.n162 5.12336
R27688 6MSB_0.OUTP.n158 6MSB_0.OUTP.n160 5.12336
R27689 6MSB_0.OUTP.n156 6MSB_0.OUTP.n158 5.12336
R27690 6MSB_0.OUTP.n154 6MSB_0.OUTP.n156 5.12336
R27691 6MSB_0.OUTP.n152 6MSB_0.OUTP.n154 5.12336
R27692 6MSB_0.OUTP.n151 6MSB_0.OUTP.n152 8.33483
R27693 6MSB_0.OUTP.n164 6MSB_0.OUTP.t76 20.1114
R27694 6MSB_0.OUTP.n164 6MSB_0.OUTP.t77 18.0077
R27695 6MSB_0.OUTP.n162 6MSB_0.OUTP.n163 16.1014
R27696 6MSB_0.OUTP.n163 6MSB_0.OUTP.t60 20.1114
R27697 6MSB_0.OUTP.n163 6MSB_0.OUTP.t61 18.0077
R27698 6MSB_0.OUTP.n160 6MSB_0.OUTP.n161 16.1014
R27699 6MSB_0.OUTP.n161 6MSB_0.OUTP.t24 20.1114
R27700 6MSB_0.OUTP.n161 6MSB_0.OUTP.t25 18.0077
R27701 6MSB_0.OUTP.n158 6MSB_0.OUTP.n159 16.1014
R27702 6MSB_0.OUTP.n159 6MSB_0.OUTP.t22 20.1114
R27703 6MSB_0.OUTP.n159 6MSB_0.OUTP.t23 18.0077
R27704 6MSB_0.OUTP.n156 6MSB_0.OUTP.n157 16.1014
R27705 6MSB_0.OUTP.n157 6MSB_0.OUTP.t122 20.1114
R27706 6MSB_0.OUTP.n157 6MSB_0.OUTP.t123 18.0077
R27707 6MSB_0.OUTP.n154 6MSB_0.OUTP.n155 16.1014
R27708 6MSB_0.OUTP.n155 6MSB_0.OUTP.t26 20.1114
R27709 6MSB_0.OUTP.n155 6MSB_0.OUTP.t27 18.0077
R27710 6MSB_0.OUTP.n152 6MSB_0.OUTP.n153 16.1014
R27711 6MSB_0.OUTP.n153 6MSB_0.OUTP.t100 20.1114
R27712 6MSB_0.OUTP.n153 6MSB_0.OUTP.t101 18.0077
R27713 6MSB_0.OUTP.n127 6MSB_0.OUTP.n128 0.0283452
R27714 6MSB_0.OUTP.n124 6MSB_0.OUTP.n123 0.0553571
R27715 6MSB_0.OUTP.n123 6MSB_0.OUTP.n122 0.0553571
R27716 6MSB_0.OUTP.n141 6MSB_0.OUTP.n143 21.2243
R27717 6MSB_0.OUTP.n139 6MSB_0.OUTP.n141 5.12336
R27718 6MSB_0.OUTP.n137 6MSB_0.OUTP.n139 5.12336
R27719 6MSB_0.OUTP.n135 6MSB_0.OUTP.n137 5.12336
R27720 6MSB_0.OUTP.n133 6MSB_0.OUTP.n135 5.12336
R27721 6MSB_0.OUTP.n131 6MSB_0.OUTP.n133 5.12336
R27722 6MSB_0.OUTP.n129 6MSB_0.OUTP.n131 5.12336
R27723 6MSB_0.OUTP.n128 6MSB_0.OUTP.n129 3.21511
R27724 6MSB_0.OUTP.n143 6MSB_0.OUTP.t94 20.1114
R27725 6MSB_0.OUTP.n143 6MSB_0.OUTP.t95 18.0077
R27726 6MSB_0.OUTP.n141 6MSB_0.OUTP.n142 16.1014
R27727 6MSB_0.OUTP.n142 6MSB_0.OUTP.t52 20.1114
R27728 6MSB_0.OUTP.n142 6MSB_0.OUTP.t53 18.0077
R27729 6MSB_0.OUTP.n139 6MSB_0.OUTP.n140 16.1014
R27730 6MSB_0.OUTP.n140 6MSB_0.OUTP.t126 20.1114
R27731 6MSB_0.OUTP.n140 6MSB_0.OUTP.t127 18.0077
R27732 6MSB_0.OUTP.n137 6MSB_0.OUTP.n138 16.1014
R27733 6MSB_0.OUTP.n138 6MSB_0.OUTP.t124 20.1114
R27734 6MSB_0.OUTP.n138 6MSB_0.OUTP.t125 18.0077
R27735 6MSB_0.OUTP.n135 6MSB_0.OUTP.n136 16.1014
R27736 6MSB_0.OUTP.n136 6MSB_0.OUTP.t130 20.1114
R27737 6MSB_0.OUTP.n136 6MSB_0.OUTP.t131 18.0077
R27738 6MSB_0.OUTP.n133 6MSB_0.OUTP.n134 16.1014
R27739 6MSB_0.OUTP.n134 6MSB_0.OUTP.t132 20.1114
R27740 6MSB_0.OUTP.n134 6MSB_0.OUTP.t133 18.0077
R27741 6MSB_0.OUTP.n131 6MSB_0.OUTP.n132 16.1014
R27742 6MSB_0.OUTP.n132 6MSB_0.OUTP.t40 20.1114
R27743 6MSB_0.OUTP.n132 6MSB_0.OUTP.t41 18.0077
R27744 6MSB_0.OUTP.n129 6MSB_0.OUTP.n130 16.1014
R27745 6MSB_0.OUTP.n130 6MSB_0.OUTP.t4 20.1114
R27746 6MSB_0.OUTP.n130 6MSB_0.OUTP.t5 18.0077
R27747 6MSB_0.OUTP.n104 6MSB_0.OUTP.n105 0.0283452
R27748 6MSB_0.OUTP.n101 6MSB_0.OUTP.n100 0.0553571
R27749 6MSB_0.OUTP.n100 6MSB_0.OUTP.n99 0.0553571
R27750 6MSB_0.OUTP.n118 6MSB_0.OUTP.n120 21.2243
R27751 6MSB_0.OUTP.n116 6MSB_0.OUTP.n118 5.12336
R27752 6MSB_0.OUTP.n114 6MSB_0.OUTP.n116 5.12336
R27753 6MSB_0.OUTP.n112 6MSB_0.OUTP.n114 5.12336
R27754 6MSB_0.OUTP.n110 6MSB_0.OUTP.n112 5.12336
R27755 6MSB_0.OUTP.n108 6MSB_0.OUTP.n110 5.12336
R27756 6MSB_0.OUTP.n106 6MSB_0.OUTP.n108 5.12336
R27757 6MSB_0.OUTP.n105 6MSB_0.OUTP.n106 3.21386
R27758 6MSB_0.OUTP.n120 6MSB_0.OUTP.t18 20.1114
R27759 6MSB_0.OUTP.n120 6MSB_0.OUTP.t19 18.0077
R27760 6MSB_0.OUTP.n118 6MSB_0.OUTP.n119 16.1014
R27761 6MSB_0.OUTP.n119 6MSB_0.OUTP.t66 20.1114
R27762 6MSB_0.OUTP.n119 6MSB_0.OUTP.t67 18.0077
R27763 6MSB_0.OUTP.n116 6MSB_0.OUTP.n117 16.1014
R27764 6MSB_0.OUTP.n117 6MSB_0.OUTP.t12 20.1114
R27765 6MSB_0.OUTP.n117 6MSB_0.OUTP.t13 18.0077
R27766 6MSB_0.OUTP.n114 6MSB_0.OUTP.n115 16.1014
R27767 6MSB_0.OUTP.n115 6MSB_0.OUTP.t128 20.1114
R27768 6MSB_0.OUTP.n115 6MSB_0.OUTP.t129 18.0077
R27769 6MSB_0.OUTP.n112 6MSB_0.OUTP.n113 16.1014
R27770 6MSB_0.OUTP.n113 6MSB_0.OUTP.t10 20.1114
R27771 6MSB_0.OUTP.n113 6MSB_0.OUTP.t11 18.0077
R27772 6MSB_0.OUTP.n110 6MSB_0.OUTP.n111 16.1014
R27773 6MSB_0.OUTP.n111 6MSB_0.OUTP.t84 20.1114
R27774 6MSB_0.OUTP.n111 6MSB_0.OUTP.t85 18.0077
R27775 6MSB_0.OUTP.n108 6MSB_0.OUTP.n109 16.1014
R27776 6MSB_0.OUTP.n109 6MSB_0.OUTP.t80 20.1114
R27777 6MSB_0.OUTP.n109 6MSB_0.OUTP.t81 18.0077
R27778 6MSB_0.OUTP.n106 6MSB_0.OUTP.n107 16.1014
R27779 6MSB_0.OUTP.n107 6MSB_0.OUTP.t74 20.1114
R27780 6MSB_0.OUTP.n107 6MSB_0.OUTP.t75 18.0077
R27781 6MSB_0.OUTP.n81 6MSB_0.OUTP.n82 0.0283452
R27782 6MSB_0.OUTP.n78 6MSB_0.OUTP.n77 0.0553571
R27783 6MSB_0.OUTP.n77 6MSB_0.OUTP.n76 0.0553571
R27784 6MSB_0.OUTP.n95 6MSB_0.OUTP.n97 21.2243
R27785 6MSB_0.OUTP.n93 6MSB_0.OUTP.n95 5.12336
R27786 6MSB_0.OUTP.n91 6MSB_0.OUTP.n93 5.12336
R27787 6MSB_0.OUTP.n89 6MSB_0.OUTP.n91 5.12336
R27788 6MSB_0.OUTP.n87 6MSB_0.OUTP.n89 5.12336
R27789 6MSB_0.OUTP.n85 6MSB_0.OUTP.n87 5.12336
R27790 6MSB_0.OUTP.n83 6MSB_0.OUTP.n85 5.12336
R27791 6MSB_0.OUTP.n82 6MSB_0.OUTP.n83 3.21511
R27792 6MSB_0.OUTP.n97 6MSB_0.OUTP.t90 20.1114
R27793 6MSB_0.OUTP.n97 6MSB_0.OUTP.t91 18.0077
R27794 6MSB_0.OUTP.n95 6MSB_0.OUTP.n96 16.1014
R27795 6MSB_0.OUTP.n96 6MSB_0.OUTP.t82 20.1114
R27796 6MSB_0.OUTP.n96 6MSB_0.OUTP.t83 18.0077
R27797 6MSB_0.OUTP.n93 6MSB_0.OUTP.n94 16.1014
R27798 6MSB_0.OUTP.n94 6MSB_0.OUTP.t86 20.1114
R27799 6MSB_0.OUTP.n94 6MSB_0.OUTP.t87 18.0077
R27800 6MSB_0.OUTP.n91 6MSB_0.OUTP.n92 16.1014
R27801 6MSB_0.OUTP.n92 6MSB_0.OUTP.t96 20.1114
R27802 6MSB_0.OUTP.n92 6MSB_0.OUTP.t97 18.0077
R27803 6MSB_0.OUTP.n89 6MSB_0.OUTP.n90 16.1014
R27804 6MSB_0.OUTP.n90 6MSB_0.OUTP.t78 20.1114
R27805 6MSB_0.OUTP.n90 6MSB_0.OUTP.t79 18.0077
R27806 6MSB_0.OUTP.n87 6MSB_0.OUTP.n88 16.1014
R27807 6MSB_0.OUTP.n88 6MSB_0.OUTP.t92 20.1114
R27808 6MSB_0.OUTP.n88 6MSB_0.OUTP.t93 18.0077
R27809 6MSB_0.OUTP.n85 6MSB_0.OUTP.n86 16.1014
R27810 6MSB_0.OUTP.n86 6MSB_0.OUTP.t88 20.1114
R27811 6MSB_0.OUTP.n86 6MSB_0.OUTP.t89 18.0077
R27812 6MSB_0.OUTP.n83 6MSB_0.OUTP.n84 16.1014
R27813 6MSB_0.OUTP.n84 6MSB_0.OUTP.t98 20.1114
R27814 6MSB_0.OUTP.n84 6MSB_0.OUTP.t99 18.0077
R27815 6MSB_0.OUTP.n58 6MSB_0.OUTP.n59 0.0283452
R27816 6MSB_0.OUTP.n55 6MSB_0.OUTP.n54 0.0553571
R27817 6MSB_0.OUTP.n54 6MSB_0.OUTP.n53 0.0553571
R27818 6MSB_0.OUTP.n72 6MSB_0.OUTP.n74 21.2243
R27819 6MSB_0.OUTP.n70 6MSB_0.OUTP.n72 5.12336
R27820 6MSB_0.OUTP.n68 6MSB_0.OUTP.n70 5.12336
R27821 6MSB_0.OUTP.n66 6MSB_0.OUTP.n68 5.12336
R27822 6MSB_0.OUTP.n64 6MSB_0.OUTP.n66 5.12336
R27823 6MSB_0.OUTP.n62 6MSB_0.OUTP.n64 5.12336
R27824 6MSB_0.OUTP.n60 6MSB_0.OUTP.n62 5.12336
R27825 6MSB_0.OUTP.n59 6MSB_0.OUTP.n60 3.21323
R27826 6MSB_0.OUTP.n74 6MSB_0.OUTP.t48 20.1114
R27827 6MSB_0.OUTP.n74 6MSB_0.OUTP.t49 18.0077
R27828 6MSB_0.OUTP.n72 6MSB_0.OUTP.n73 16.1014
R27829 6MSB_0.OUTP.n73 6MSB_0.OUTP.t102 20.1114
R27830 6MSB_0.OUTP.n73 6MSB_0.OUTP.t103 18.0077
R27831 6MSB_0.OUTP.n70 6MSB_0.OUTP.n71 16.1014
R27832 6MSB_0.OUTP.n71 6MSB_0.OUTP.t36 20.1114
R27833 6MSB_0.OUTP.n71 6MSB_0.OUTP.t37 18.0077
R27834 6MSB_0.OUTP.n68 6MSB_0.OUTP.n69 16.1014
R27835 6MSB_0.OUTP.n69 6MSB_0.OUTP.t14 20.1114
R27836 6MSB_0.OUTP.n69 6MSB_0.OUTP.t15 18.0077
R27837 6MSB_0.OUTP.n66 6MSB_0.OUTP.n67 16.1014
R27838 6MSB_0.OUTP.n67 6MSB_0.OUTP.t28 20.1114
R27839 6MSB_0.OUTP.n67 6MSB_0.OUTP.t29 18.0077
R27840 6MSB_0.OUTP.n64 6MSB_0.OUTP.n65 16.1014
R27841 6MSB_0.OUTP.n65 6MSB_0.OUTP.t64 20.1114
R27842 6MSB_0.OUTP.n65 6MSB_0.OUTP.t65 18.0077
R27843 6MSB_0.OUTP.n62 6MSB_0.OUTP.n63 16.1014
R27844 6MSB_0.OUTP.n63 6MSB_0.OUTP.t62 20.1114
R27845 6MSB_0.OUTP.n63 6MSB_0.OUTP.t63 18.0077
R27846 6MSB_0.OUTP.n60 6MSB_0.OUTP.n61 16.1014
R27847 6MSB_0.OUTP.n61 6MSB_0.OUTP.t50 20.1114
R27848 6MSB_0.OUTP.n61 6MSB_0.OUTP.t51 18.0077
R27849 6MSB_0.OUTP.n35 6MSB_0.OUTP.n36 0.0283452
R27850 6MSB_0.OUTP.n32 6MSB_0.OUTP.n31 0.0553571
R27851 6MSB_0.OUTP.n31 6MSB_0.OUTP.n30 0.0553571
R27852 6MSB_0.OUTP.n49 6MSB_0.OUTP.n51 21.2243
R27853 6MSB_0.OUTP.n47 6MSB_0.OUTP.n49 5.12336
R27854 6MSB_0.OUTP.n45 6MSB_0.OUTP.n47 5.12336
R27855 6MSB_0.OUTP.n43 6MSB_0.OUTP.n45 5.12336
R27856 6MSB_0.OUTP.n41 6MSB_0.OUTP.n43 5.12336
R27857 6MSB_0.OUTP.n39 6MSB_0.OUTP.n41 5.12336
R27858 6MSB_0.OUTP.n37 6MSB_0.OUTP.n39 5.12336
R27859 6MSB_0.OUTP.n36 6MSB_0.OUTP.n37 3.21449
R27860 6MSB_0.OUTP.n51 6MSB_0.OUTP.t16 20.1114
R27861 6MSB_0.OUTP.n51 6MSB_0.OUTP.t17 18.0077
R27862 6MSB_0.OUTP.n49 6MSB_0.OUTP.n50 16.1014
R27863 6MSB_0.OUTP.n50 6MSB_0.OUTP.t30 20.1114
R27864 6MSB_0.OUTP.n50 6MSB_0.OUTP.t31 18.0077
R27865 6MSB_0.OUTP.n47 6MSB_0.OUTP.n48 16.1014
R27866 6MSB_0.OUTP.n48 6MSB_0.OUTP.t42 20.1114
R27867 6MSB_0.OUTP.n48 6MSB_0.OUTP.t43 18.0077
R27868 6MSB_0.OUTP.n45 6MSB_0.OUTP.n46 16.1014
R27869 6MSB_0.OUTP.n46 6MSB_0.OUTP.t8 20.1114
R27870 6MSB_0.OUTP.n46 6MSB_0.OUTP.t9 18.0077
R27871 6MSB_0.OUTP.n43 6MSB_0.OUTP.n44 16.1014
R27872 6MSB_0.OUTP.n44 6MSB_0.OUTP.t54 20.1114
R27873 6MSB_0.OUTP.n44 6MSB_0.OUTP.t55 18.0077
R27874 6MSB_0.OUTP.n41 6MSB_0.OUTP.n42 16.1014
R27875 6MSB_0.OUTP.n42 6MSB_0.OUTP.t34 20.1114
R27876 6MSB_0.OUTP.n42 6MSB_0.OUTP.t35 18.0077
R27877 6MSB_0.OUTP.n39 6MSB_0.OUTP.n40 16.1014
R27878 6MSB_0.OUTP.n40 6MSB_0.OUTP.t46 20.1114
R27879 6MSB_0.OUTP.n40 6MSB_0.OUTP.t47 18.0077
R27880 6MSB_0.OUTP.n37 6MSB_0.OUTP.n38 16.1014
R27881 6MSB_0.OUTP.n38 6MSB_0.OUTP.t6 20.1114
R27882 6MSB_0.OUTP.n38 6MSB_0.OUTP.t7 18.0077
R27883 6MSB_0.OUTP.n12 6MSB_0.OUTP.n13 0.0283452
R27884 6MSB_0.OUTP.n9 6MSB_0.OUTP.n8 0.0553571
R27885 6MSB_0.OUTP.n8 6MSB_0.OUTP.n7 0.0553571
R27886 6MSB_0.OUTP.n26 6MSB_0.OUTP.n28 21.2243
R27887 6MSB_0.OUTP.n24 6MSB_0.OUTP.n26 5.12336
R27888 6MSB_0.OUTP.n22 6MSB_0.OUTP.n24 5.12336
R27889 6MSB_0.OUTP.n20 6MSB_0.OUTP.n22 5.12336
R27890 6MSB_0.OUTP.n18 6MSB_0.OUTP.n20 5.12336
R27891 6MSB_0.OUTP.n16 6MSB_0.OUTP.n18 5.12336
R27892 6MSB_0.OUTP.n14 6MSB_0.OUTP.n16 5.12336
R27893 6MSB_0.OUTP.n13 6MSB_0.OUTP.n14 3.217
R27894 6MSB_0.OUTP.n28 6MSB_0.OUTP.t114 20.1114
R27895 6MSB_0.OUTP.n28 6MSB_0.OUTP.t115 18.0077
R27896 6MSB_0.OUTP.n26 6MSB_0.OUTP.n27 16.1014
R27897 6MSB_0.OUTP.n27 6MSB_0.OUTP.t110 20.1114
R27898 6MSB_0.OUTP.n27 6MSB_0.OUTP.t111 18.0077
R27899 6MSB_0.OUTP.n24 6MSB_0.OUTP.n25 16.1014
R27900 6MSB_0.OUTP.n25 6MSB_0.OUTP.t104 20.1114
R27901 6MSB_0.OUTP.n25 6MSB_0.OUTP.t105 18.0077
R27902 6MSB_0.OUTP.n22 6MSB_0.OUTP.n23 16.1014
R27903 6MSB_0.OUTP.n23 6MSB_0.OUTP.t112 20.1114
R27904 6MSB_0.OUTP.n23 6MSB_0.OUTP.t113 18.0077
R27905 6MSB_0.OUTP.n20 6MSB_0.OUTP.n21 16.1014
R27906 6MSB_0.OUTP.n21 6MSB_0.OUTP.t108 20.1114
R27907 6MSB_0.OUTP.n21 6MSB_0.OUTP.t109 18.0077
R27908 6MSB_0.OUTP.n18 6MSB_0.OUTP.n19 16.1014
R27909 6MSB_0.OUTP.n19 6MSB_0.OUTP.t106 20.1114
R27910 6MSB_0.OUTP.n19 6MSB_0.OUTP.t107 18.0077
R27911 6MSB_0.OUTP.n16 6MSB_0.OUTP.n17 16.1014
R27912 6MSB_0.OUTP.n17 6MSB_0.OUTP.t118 20.1114
R27913 6MSB_0.OUTP.n17 6MSB_0.OUTP.t119 18.0077
R27914 6MSB_0.OUTP.n14 6MSB_0.OUTP.n15 16.1014
R27915 6MSB_0.OUTP.n15 6MSB_0.OUTP.t116 20.1114
R27916 6MSB_0.OUTP.n15 6MSB_0.OUTP.t117 18.0077
R27917 6MSB_0.OUTN.t1 6MSB_0.OUTN.n187 17.8461
R27918 6MSB_0.OUTN.n187 6MSB_0.OUTN.t0 18.5474
R27919 6MSB_0.OUTN 6MSB_0.OUTN.n187 1.02891
R27920 6MSB_0.OUTN 6MSB_0.OUTN.n186 14.5823
R27921 6MSB_0.OUTN 6MSB_0.OUTN.n183 19.7052
R27922 6MSB_0.OUTN.n181 6MSB_0.OUTN.n183 5.12336
R27923 6MSB_0.OUTN.n179 6MSB_0.OUTN.n181 5.12336
R27924 6MSB_0.OUTN.n177 6MSB_0.OUTN.n179 5.12336
R27925 6MSB_0.OUTN.n175 6MSB_0.OUTN.n177 5.12336
R27926 6MSB_0.OUTN.n173 6MSB_0.OUTN.n175 5.12336
R27927 6MSB_0.OUTN.n186 6MSB_0.OUTN.n173 5.12336
R27928 6MSB_0.OUTN.n186 6MSB_0.OUTN.n3 3.73604
R27929 6MSB_0.OUTN.n185 6MSB_0.OUTN 1.02891
R27930 6MSB_0.OUTN.t41 6MSB_0.OUTN.n185 17.8461
R27931 6MSB_0.OUTN.t40 6MSB_0.OUTN.n185 18.5474
R27932 6MSB_0.OUTN 6MSB_0.OUTN.n183 14.5823
R27933 6MSB_0.OUTN.n184 6MSB_0.OUTN 1.02891
R27934 6MSB_0.OUTN.t81 6MSB_0.OUTN.n184 17.8461
R27935 6MSB_0.OUTN.t80 6MSB_0.OUTN.n184 18.5474
R27936 6MSB_0.OUTN 6MSB_0.OUTN.n181 14.5823
R27937 6MSB_0.OUTN.n182 6MSB_0.OUTN 1.02891
R27938 6MSB_0.OUTN.t39 6MSB_0.OUTN.n182 17.8461
R27939 6MSB_0.OUTN.t38 6MSB_0.OUTN.n182 18.5474
R27940 6MSB_0.OUTN 6MSB_0.OUTN.n179 14.5823
R27941 6MSB_0.OUTN.n180 6MSB_0.OUTN 1.02891
R27942 6MSB_0.OUTN.t123 6MSB_0.OUTN.n180 17.8461
R27943 6MSB_0.OUTN.t122 6MSB_0.OUTN.n180 18.5474
R27944 6MSB_0.OUTN 6MSB_0.OUTN.n177 14.5823
R27945 6MSB_0.OUTN.n178 6MSB_0.OUTN 1.02891
R27946 6MSB_0.OUTN.t37 6MSB_0.OUTN.n178 17.8461
R27947 6MSB_0.OUTN.t36 6MSB_0.OUTN.n178 18.5474
R27948 6MSB_0.OUTN 6MSB_0.OUTN.n175 14.5823
R27949 6MSB_0.OUTN.n176 6MSB_0.OUTN 1.02891
R27950 6MSB_0.OUTN.t11 6MSB_0.OUTN.n176 17.8461
R27951 6MSB_0.OUTN.t10 6MSB_0.OUTN.n176 18.5474
R27952 6MSB_0.OUTN 6MSB_0.OUTN.n173 14.5823
R27953 6MSB_0.OUTN.n174 6MSB_0.OUTN 1.02891
R27954 6MSB_0.OUTN.t13 6MSB_0.OUTN.n174 17.8461
R27955 6MSB_0.OUTN.t12 6MSB_0.OUTN.n174 18.5474
R27956 6MSB_0.OUTN.n0 6MSB_0.OUTN.n1 4.501
R27957 6MSB_0.OUTN.n2 6MSB_0.OUTN.n4 4.49441
R27958 6MSB_0.OUTN.n0 6MSB_0.OUTN.n3 9.0005
R27959 6MSB_0.OUTN.n2 6MSB_0.OUTN.n1 0.0697368
R27960 6MSB_0.OUTN.n4 6MSB_0.OUTN.n5 0.0141807
R27961 6MSB_0.OUTN.n5 6MSB_0.OUTN.n3 9.0005
R27962 6MSB_0.OUTN.n3 6MSB_0.OUTN.n2 0.0553571
R27963 6MSB_0.OUTN.n5 6MSB_0.OUTN.n1 4.50175
R27964 6MSB_0.OUTN.n6 6MSB_0.OUTN.n7 9.0005
R27965 6MSB_0.OUTN.n10 6MSB_0.OUTN.n8 4.49441
R27966 6MSB_0.OUTN.n12 6MSB_0.OUTN.n9 0.0283452
R27967 6MSB_0.OUTN.n6 6MSB_0.OUTN.n12 4.48733
R27968 6MSB_0.OUTN.n11 6MSB_0.OUTN.n7 9.0005
R27969 6MSB_0.OUTN.n11 6MSB_0.OUTN.n10 0.0141807
R27970 6MSB_0.OUTN.n11 6MSB_0.OUTN.n9 9.0005
R27971 6MSB_0.OUTN.n11 6MSB_0.OUTN.n13 9.0005
R27972 6MSB_0.OUTN.n29 6MSB_0.OUTN.n30 9.0005
R27973 6MSB_0.OUTN.n33 6MSB_0.OUTN.n31 4.49441
R27974 6MSB_0.OUTN.n35 6MSB_0.OUTN.n32 0.0283452
R27975 6MSB_0.OUTN.n29 6MSB_0.OUTN.n35 4.48733
R27976 6MSB_0.OUTN.n34 6MSB_0.OUTN.n30 9.0005
R27977 6MSB_0.OUTN.n34 6MSB_0.OUTN.n33 0.0141807
R27978 6MSB_0.OUTN.n34 6MSB_0.OUTN.n32 9.0005
R27979 6MSB_0.OUTN.n34 6MSB_0.OUTN.n36 9.0005
R27980 6MSB_0.OUTN.n52 6MSB_0.OUTN.n53 9.0005
R27981 6MSB_0.OUTN.n56 6MSB_0.OUTN.n54 4.49441
R27982 6MSB_0.OUTN.n58 6MSB_0.OUTN.n55 0.0283452
R27983 6MSB_0.OUTN.n52 6MSB_0.OUTN.n58 4.48733
R27984 6MSB_0.OUTN.n57 6MSB_0.OUTN.n53 9.0005
R27985 6MSB_0.OUTN.n56 6MSB_0.OUTN.n57 0.0141807
R27986 6MSB_0.OUTN.n57 6MSB_0.OUTN.n55 9.0005
R27987 6MSB_0.OUTN.n57 6MSB_0.OUTN.n59 9.0005
R27988 6MSB_0.OUTN.n75 6MSB_0.OUTN.n76 9.0005
R27989 6MSB_0.OUTN.n79 6MSB_0.OUTN.n77 4.49441
R27990 6MSB_0.OUTN.n81 6MSB_0.OUTN.n78 0.0283452
R27991 6MSB_0.OUTN.n75 6MSB_0.OUTN.n81 4.48733
R27992 6MSB_0.OUTN.n80 6MSB_0.OUTN.n76 9.0005
R27993 6MSB_0.OUTN.n79 6MSB_0.OUTN.n80 0.0141807
R27994 6MSB_0.OUTN.n80 6MSB_0.OUTN.n78 9.0005
R27995 6MSB_0.OUTN.n80 6MSB_0.OUTN.n82 9.0005
R27996 6MSB_0.OUTN.n98 6MSB_0.OUTN.n99 9.0005
R27997 6MSB_0.OUTN.n102 6MSB_0.OUTN.n100 4.49441
R27998 6MSB_0.OUTN.n104 6MSB_0.OUTN.n101 0.0283452
R27999 6MSB_0.OUTN.n98 6MSB_0.OUTN.n104 4.48733
R28000 6MSB_0.OUTN.n103 6MSB_0.OUTN.n99 9.0005
R28001 6MSB_0.OUTN.n102 6MSB_0.OUTN.n103 0.0141807
R28002 6MSB_0.OUTN.n103 6MSB_0.OUTN.n101 9.0005
R28003 6MSB_0.OUTN.n103 6MSB_0.OUTN.n105 9.0005
R28004 6MSB_0.OUTN.n121 6MSB_0.OUTN.n122 9.0005
R28005 6MSB_0.OUTN.n125 6MSB_0.OUTN.n123 4.49441
R28006 6MSB_0.OUTN.n127 6MSB_0.OUTN.n124 0.0283452
R28007 6MSB_0.OUTN.n121 6MSB_0.OUTN.n127 4.48733
R28008 6MSB_0.OUTN.n126 6MSB_0.OUTN.n122 9.0005
R28009 6MSB_0.OUTN.n125 6MSB_0.OUTN.n126 0.0141807
R28010 6MSB_0.OUTN.n126 6MSB_0.OUTN.n124 9.0005
R28011 6MSB_0.OUTN.n126 6MSB_0.OUTN.n128 9.0005
R28012 6MSB_0.OUTN.n144 6MSB_0.OUTN.n145 9.0005
R28013 6MSB_0.OUTN.n148 6MSB_0.OUTN.n146 4.49441
R28014 6MSB_0.OUTN.n150 6MSB_0.OUTN.n147 0.0283452
R28015 6MSB_0.OUTN.n144 6MSB_0.OUTN.n150 4.48733
R28016 6MSB_0.OUTN.n149 6MSB_0.OUTN.n145 9.0005
R28017 6MSB_0.OUTN.n148 6MSB_0.OUTN.n149 0.0141807
R28018 6MSB_0.OUTN.n149 6MSB_0.OUTN.n147 9.0005
R28019 6MSB_0.OUTN.n149 6MSB_0.OUTN.n151 9.0005
R28020 6MSB_0.OUTN.n165 6MSB_0.OUTN.n166 14.283
R28021 6MSB_0.OUTN.n167 6MSB_0.OUTN.n168 14.2981
R28022 6MSB_0.OUTN.n169 6MSB_0.OUTN.n170 14.3012
R28023 6MSB_0.OUTN.n171 6MSB_0.OUTN.n172 14.2875
R28024 6MSB_0.OUTN.n10 6MSB_0.OUTN.n6 0.0141807
R28025 6MSB_0.OUTN.n29 6MSB_0.OUTN.n11 0.7441
R28026 6MSB_0.OUTN.n33 6MSB_0.OUTN.n29 0.0141807
R28027 6MSB_0.OUTN.n0 6MSB_0.OUTN.n34 0.7441
R28028 6MSB_0.OUTN.n4 6MSB_0.OUTN.n0 0.0141807
R28029 6MSB_0.OUTN.n5 6MSB_0.OUTN.n52 0.7441
R28030 6MSB_0.OUTN.n52 6MSB_0.OUTN.n56 0.0141807
R28031 6MSB_0.OUTN.n57 6MSB_0.OUTN.n75 0.7441
R28032 6MSB_0.OUTN.n75 6MSB_0.OUTN.n79 0.0141807
R28033 6MSB_0.OUTN.n80 6MSB_0.OUTN.n98 0.7441
R28034 6MSB_0.OUTN.n98 6MSB_0.OUTN.n102 0.0141807
R28035 6MSB_0.OUTN.n103 6MSB_0.OUTN.n121 0.7441
R28036 6MSB_0.OUTN.n121 6MSB_0.OUTN.n125 0.0141807
R28037 6MSB_0.OUTN.n126 6MSB_0.OUTN.n144 0.7441
R28038 6MSB_0.OUTN.n144 6MSB_0.OUTN.n148 0.0141807
R28039 6MSB_0.OUTN.n149 6MSB_0.OUTN.n165 0.456725
R28040 6MSB_0.OUTN.n165 6MSB_0.OUTN.n167 0.38495
R28041 6MSB_0.OUTN.n167 6MSB_0.OUTN.n169 0.369825
R28042 6MSB_0.OUTN.n169 6MSB_0.OUTN.n171 0.29695
R28043 6MSB_0.OUTN.n171 6MSB_0.OUTN 0.1842
R28044 6MSB_0.OUTN.n172 6MSB_0.OUTN.t89 19.998
R28045 6MSB_0.OUTN.n172 6MSB_0.OUTN.t88 17.8942
R28046 6MSB_0.OUTN.n170 6MSB_0.OUTN.t87 17.8942
R28047 6MSB_0.OUTN.n170 6MSB_0.OUTN.t86 19.998
R28048 6MSB_0.OUTN.n168 6MSB_0.OUTN.t2 20.1114
R28049 6MSB_0.OUTN.n168 6MSB_0.OUTN.t3 18.0077
R28050 6MSB_0.OUTN.n166 6MSB_0.OUTN.t5 18.0077
R28051 6MSB_0.OUTN.n166 6MSB_0.OUTN.t4 20.1114
R28052 6MSB_0.OUTN.n150 6MSB_0.OUTN.n151 0.0283452
R28053 6MSB_0.OUTN.n147 6MSB_0.OUTN.n146 0.0553571
R28054 6MSB_0.OUTN.n146 6MSB_0.OUTN.n145 0.0553571
R28055 6MSB_0.OUTN 6MSB_0.OUTN.n162 19.7052
R28056 6MSB_0.OUTN.n160 6MSB_0.OUTN.n162 5.12336
R28057 6MSB_0.OUTN.n158 6MSB_0.OUTN.n160 5.12336
R28058 6MSB_0.OUTN.n156 6MSB_0.OUTN.n158 5.12336
R28059 6MSB_0.OUTN.n154 6MSB_0.OUTN.n156 5.12336
R28060 6MSB_0.OUTN.n152 6MSB_0.OUTN.n154 5.12336
R28061 6MSB_0.OUTN.n151 6MSB_0.OUTN.n152 8.86267
R28062 6MSB_0.OUTN.n164 6MSB_0.OUTN 1.02891
R28063 6MSB_0.OUTN.t19 6MSB_0.OUTN.n164 17.8461
R28064 6MSB_0.OUTN.t18 6MSB_0.OUTN.n164 18.5474
R28065 6MSB_0.OUTN 6MSB_0.OUTN.n162 14.5823
R28066 6MSB_0.OUTN.n163 6MSB_0.OUTN 1.02891
R28067 6MSB_0.OUTN.t121 6MSB_0.OUTN.n163 17.8461
R28068 6MSB_0.OUTN.t120 6MSB_0.OUTN.n163 18.5474
R28069 6MSB_0.OUTN 6MSB_0.OUTN.n160 14.5823
R28070 6MSB_0.OUTN.n161 6MSB_0.OUTN 1.02891
R28071 6MSB_0.OUTN.t119 6MSB_0.OUTN.n161 17.8461
R28072 6MSB_0.OUTN.t118 6MSB_0.OUTN.n161 18.5474
R28073 6MSB_0.OUTN 6MSB_0.OUTN.n158 14.5823
R28074 6MSB_0.OUTN.n159 6MSB_0.OUTN 1.02891
R28075 6MSB_0.OUTN.t25 6MSB_0.OUTN.n159 17.8461
R28076 6MSB_0.OUTN.t24 6MSB_0.OUTN.n159 18.5474
R28077 6MSB_0.OUTN 6MSB_0.OUTN.n156 14.5823
R28078 6MSB_0.OUTN.n157 6MSB_0.OUTN 1.02891
R28079 6MSB_0.OUTN.t103 6MSB_0.OUTN.n157 17.8461
R28080 6MSB_0.OUTN.t102 6MSB_0.OUTN.n157 18.5474
R28081 6MSB_0.OUTN 6MSB_0.OUTN.n154 14.5823
R28082 6MSB_0.OUTN.n155 6MSB_0.OUTN 1.02891
R28083 6MSB_0.OUTN.t9 6MSB_0.OUTN.n155 17.8461
R28084 6MSB_0.OUTN.t8 6MSB_0.OUTN.n155 18.5474
R28085 6MSB_0.OUTN 6MSB_0.OUTN.n152 14.5823
R28086 6MSB_0.OUTN.n153 6MSB_0.OUTN 1.02891
R28087 6MSB_0.OUTN.t133 6MSB_0.OUTN.n153 17.8461
R28088 6MSB_0.OUTN.t132 6MSB_0.OUTN.n153 18.5474
R28089 6MSB_0.OUTN.n127 6MSB_0.OUTN.n128 0.0283452
R28090 6MSB_0.OUTN.n124 6MSB_0.OUTN.n123 0.0553571
R28091 6MSB_0.OUTN.n123 6MSB_0.OUTN.n122 0.0553571
R28092 6MSB_0.OUTN 6MSB_0.OUTN.n141 19.7052
R28093 6MSB_0.OUTN.n139 6MSB_0.OUTN.n141 5.12336
R28094 6MSB_0.OUTN.n137 6MSB_0.OUTN.n139 5.12336
R28095 6MSB_0.OUTN.n135 6MSB_0.OUTN.n137 5.12336
R28096 6MSB_0.OUTN.n133 6MSB_0.OUTN.n135 5.12336
R28097 6MSB_0.OUTN.n131 6MSB_0.OUTN.n133 5.12336
R28098 6MSB_0.OUTN.n129 6MSB_0.OUTN.n131 5.12336
R28099 6MSB_0.OUTN.n128 6MSB_0.OUTN.n129 3.73667
R28100 6MSB_0.OUTN.n143 6MSB_0.OUTN 1.02891
R28101 6MSB_0.OUTN.t131 6MSB_0.OUTN.n143 17.8461
R28102 6MSB_0.OUTN.t130 6MSB_0.OUTN.n143 18.5474
R28103 6MSB_0.OUTN 6MSB_0.OUTN.n141 14.5823
R28104 6MSB_0.OUTN.n142 6MSB_0.OUTN 1.02891
R28105 6MSB_0.OUTN.t27 6MSB_0.OUTN.n142 17.8461
R28106 6MSB_0.OUTN.t26 6MSB_0.OUTN.n142 18.5474
R28107 6MSB_0.OUTN 6MSB_0.OUTN.n139 14.5823
R28108 6MSB_0.OUTN.n140 6MSB_0.OUTN 1.02891
R28109 6MSB_0.OUTN.t21 6MSB_0.OUTN.n140 17.8461
R28110 6MSB_0.OUTN.t20 6MSB_0.OUTN.n140 18.5474
R28111 6MSB_0.OUTN 6MSB_0.OUTN.n137 14.5823
R28112 6MSB_0.OUTN.n138 6MSB_0.OUTN 1.02891
R28113 6MSB_0.OUTN.t125 6MSB_0.OUTN.n138 17.8461
R28114 6MSB_0.OUTN.t124 6MSB_0.OUTN.n138 18.5474
R28115 6MSB_0.OUTN 6MSB_0.OUTN.n135 14.5823
R28116 6MSB_0.OUTN.n136 6MSB_0.OUTN 1.02891
R28117 6MSB_0.OUTN.t49 6MSB_0.OUTN.n136 17.8461
R28118 6MSB_0.OUTN.t48 6MSB_0.OUTN.n136 18.5474
R28119 6MSB_0.OUTN 6MSB_0.OUTN.n133 14.5823
R28120 6MSB_0.OUTN.n134 6MSB_0.OUTN 1.02891
R28121 6MSB_0.OUTN.t47 6MSB_0.OUTN.n134 17.8461
R28122 6MSB_0.OUTN.t46 6MSB_0.OUTN.n134 18.5474
R28123 6MSB_0.OUTN 6MSB_0.OUTN.n131 14.5823
R28124 6MSB_0.OUTN.n132 6MSB_0.OUTN 1.02891
R28125 6MSB_0.OUTN.t23 6MSB_0.OUTN.n132 17.8461
R28126 6MSB_0.OUTN.t22 6MSB_0.OUTN.n132 18.5474
R28127 6MSB_0.OUTN 6MSB_0.OUTN.n129 14.5823
R28128 6MSB_0.OUTN.n130 6MSB_0.OUTN 1.02891
R28129 6MSB_0.OUTN.t55 6MSB_0.OUTN.n130 17.8461
R28130 6MSB_0.OUTN.t54 6MSB_0.OUTN.n130 18.5474
R28131 6MSB_0.OUTN.n104 6MSB_0.OUTN.n105 0.0283452
R28132 6MSB_0.OUTN.n101 6MSB_0.OUTN.n100 0.0553571
R28133 6MSB_0.OUTN.n100 6MSB_0.OUTN.n99 0.0553571
R28134 6MSB_0.OUTN 6MSB_0.OUTN.n118 19.7052
R28135 6MSB_0.OUTN.n116 6MSB_0.OUTN.n118 5.12336
R28136 6MSB_0.OUTN.n114 6MSB_0.OUTN.n116 5.12336
R28137 6MSB_0.OUTN.n112 6MSB_0.OUTN.n114 5.12336
R28138 6MSB_0.OUTN.n110 6MSB_0.OUTN.n112 5.12336
R28139 6MSB_0.OUTN.n108 6MSB_0.OUTN.n110 5.12336
R28140 6MSB_0.OUTN.n106 6MSB_0.OUTN.n108 5.12336
R28141 6MSB_0.OUTN.n105 6MSB_0.OUTN.n106 3.73667
R28142 6MSB_0.OUTN.n120 6MSB_0.OUTN 1.02891
R28143 6MSB_0.OUTN.t59 6MSB_0.OUTN.n120 17.8461
R28144 6MSB_0.OUTN.t58 6MSB_0.OUTN.n120 18.5474
R28145 6MSB_0.OUTN 6MSB_0.OUTN.n118 14.5823
R28146 6MSB_0.OUTN.n119 6MSB_0.OUTN 1.02891
R28147 6MSB_0.OUTN.t53 6MSB_0.OUTN.n119 17.8461
R28148 6MSB_0.OUTN.t52 6MSB_0.OUTN.n119 18.5474
R28149 6MSB_0.OUTN 6MSB_0.OUTN.n116 14.5823
R28150 6MSB_0.OUTN.n117 6MSB_0.OUTN 1.02891
R28151 6MSB_0.OUTN.t35 6MSB_0.OUTN.n117 17.8461
R28152 6MSB_0.OUTN.t34 6MSB_0.OUTN.n117 18.5474
R28153 6MSB_0.OUTN 6MSB_0.OUTN.n114 14.5823
R28154 6MSB_0.OUTN.n115 6MSB_0.OUTN 1.02891
R28155 6MSB_0.OUTN.t71 6MSB_0.OUTN.n115 17.8461
R28156 6MSB_0.OUTN.t70 6MSB_0.OUTN.n115 18.5474
R28157 6MSB_0.OUTN 6MSB_0.OUTN.n112 14.5823
R28158 6MSB_0.OUTN.n113 6MSB_0.OUTN 1.02891
R28159 6MSB_0.OUTN.t67 6MSB_0.OUTN.n113 17.8461
R28160 6MSB_0.OUTN.t66 6MSB_0.OUTN.n113 18.5474
R28161 6MSB_0.OUTN 6MSB_0.OUTN.n110 14.5823
R28162 6MSB_0.OUTN.n111 6MSB_0.OUTN 1.02891
R28163 6MSB_0.OUTN.t57 6MSB_0.OUTN.n111 17.8461
R28164 6MSB_0.OUTN.t56 6MSB_0.OUTN.n111 18.5474
R28165 6MSB_0.OUTN 6MSB_0.OUTN.n108 14.5823
R28166 6MSB_0.OUTN.n109 6MSB_0.OUTN 1.02891
R28167 6MSB_0.OUTN.t75 6MSB_0.OUTN.n109 17.8461
R28168 6MSB_0.OUTN.t74 6MSB_0.OUTN.n109 18.5474
R28169 6MSB_0.OUTN 6MSB_0.OUTN.n106 14.5823
R28170 6MSB_0.OUTN.n107 6MSB_0.OUTN 1.02891
R28171 6MSB_0.OUTN.t73 6MSB_0.OUTN.n107 17.8461
R28172 6MSB_0.OUTN.t72 6MSB_0.OUTN.n107 18.5474
R28173 6MSB_0.OUTN.n81 6MSB_0.OUTN.n82 0.0283452
R28174 6MSB_0.OUTN.n78 6MSB_0.OUTN.n77 0.0553571
R28175 6MSB_0.OUTN.n77 6MSB_0.OUTN.n76 0.0553571
R28176 6MSB_0.OUTN 6MSB_0.OUTN.n95 19.7052
R28177 6MSB_0.OUTN.n93 6MSB_0.OUTN.n95 5.12336
R28178 6MSB_0.OUTN.n91 6MSB_0.OUTN.n93 5.12336
R28179 6MSB_0.OUTN.n89 6MSB_0.OUTN.n91 5.12336
R28180 6MSB_0.OUTN.n87 6MSB_0.OUTN.n89 5.12336
R28181 6MSB_0.OUTN.n85 6MSB_0.OUTN.n87 5.12336
R28182 6MSB_0.OUTN.n83 6MSB_0.OUTN.n85 5.12336
R28183 6MSB_0.OUTN.n82 6MSB_0.OUTN.n83 3.73604
R28184 6MSB_0.OUTN.n97 6MSB_0.OUTN 1.02891
R28185 6MSB_0.OUTN.t79 6MSB_0.OUTN.n97 17.8461
R28186 6MSB_0.OUTN.t78 6MSB_0.OUTN.n97 18.5474
R28187 6MSB_0.OUTN 6MSB_0.OUTN.n95 14.5823
R28188 6MSB_0.OUTN.n96 6MSB_0.OUTN 1.02891
R28189 6MSB_0.OUTN.t63 6MSB_0.OUTN.n96 17.8461
R28190 6MSB_0.OUTN.t62 6MSB_0.OUTN.n96 18.5474
R28191 6MSB_0.OUTN 6MSB_0.OUTN.n93 14.5823
R28192 6MSB_0.OUTN.n94 6MSB_0.OUTN 1.02891
R28193 6MSB_0.OUTN.t83 6MSB_0.OUTN.n94 17.8461
R28194 6MSB_0.OUTN.t82 6MSB_0.OUTN.n94 18.5474
R28195 6MSB_0.OUTN 6MSB_0.OUTN.n91 14.5823
R28196 6MSB_0.OUTN.n92 6MSB_0.OUTN 1.02891
R28197 6MSB_0.OUTN.t77 6MSB_0.OUTN.n92 17.8461
R28198 6MSB_0.OUTN.t76 6MSB_0.OUTN.n92 18.5474
R28199 6MSB_0.OUTN 6MSB_0.OUTN.n89 14.5823
R28200 6MSB_0.OUTN.n90 6MSB_0.OUTN 1.02891
R28201 6MSB_0.OUTN.t69 6MSB_0.OUTN.n90 17.8461
R28202 6MSB_0.OUTN.t68 6MSB_0.OUTN.n90 18.5474
R28203 6MSB_0.OUTN 6MSB_0.OUTN.n87 14.5823
R28204 6MSB_0.OUTN.n88 6MSB_0.OUTN 1.02891
R28205 6MSB_0.OUTN.t65 6MSB_0.OUTN.n88 17.8461
R28206 6MSB_0.OUTN.t64 6MSB_0.OUTN.n88 18.5474
R28207 6MSB_0.OUTN 6MSB_0.OUTN.n85 14.5823
R28208 6MSB_0.OUTN.n86 6MSB_0.OUTN 1.02891
R28209 6MSB_0.OUTN.t61 6MSB_0.OUTN.n86 17.8461
R28210 6MSB_0.OUTN.t60 6MSB_0.OUTN.n86 18.5474
R28211 6MSB_0.OUTN 6MSB_0.OUTN.n83 14.5823
R28212 6MSB_0.OUTN.n84 6MSB_0.OUTN 1.02891
R28213 6MSB_0.OUTN.t85 6MSB_0.OUTN.n84 17.8461
R28214 6MSB_0.OUTN.t84 6MSB_0.OUTN.n84 18.5474
R28215 6MSB_0.OUTN.n58 6MSB_0.OUTN.n59 0.0283452
R28216 6MSB_0.OUTN.n55 6MSB_0.OUTN.n54 0.0553571
R28217 6MSB_0.OUTN.n54 6MSB_0.OUTN.n53 0.0553571
R28218 6MSB_0.OUTN 6MSB_0.OUTN.n72 19.7052
R28219 6MSB_0.OUTN.n70 6MSB_0.OUTN.n72 5.12336
R28220 6MSB_0.OUTN.n68 6MSB_0.OUTN.n70 5.12336
R28221 6MSB_0.OUTN.n66 6MSB_0.OUTN.n68 5.12336
R28222 6MSB_0.OUTN.n64 6MSB_0.OUTN.n66 5.12336
R28223 6MSB_0.OUTN.n62 6MSB_0.OUTN.n64 5.12336
R28224 6MSB_0.OUTN.n60 6MSB_0.OUTN.n62 5.12336
R28225 6MSB_0.OUTN.n59 6MSB_0.OUTN.n60 3.73604
R28226 6MSB_0.OUTN.n74 6MSB_0.OUTN 1.02891
R28227 6MSB_0.OUTN.t93 6MSB_0.OUTN.n74 17.8461
R28228 6MSB_0.OUTN.t92 6MSB_0.OUTN.n74 18.5474
R28229 6MSB_0.OUTN 6MSB_0.OUTN.n72 14.5823
R28230 6MSB_0.OUTN.n73 6MSB_0.OUTN 1.02891
R28231 6MSB_0.OUTN.t51 6MSB_0.OUTN.n73 17.8461
R28232 6MSB_0.OUTN.t50 6MSB_0.OUTN.n73 18.5474
R28233 6MSB_0.OUTN 6MSB_0.OUTN.n70 14.5823
R28234 6MSB_0.OUTN.n71 6MSB_0.OUTN 1.02891
R28235 6MSB_0.OUTN.t91 6MSB_0.OUTN.n71 17.8461
R28236 6MSB_0.OUTN.t90 6MSB_0.OUTN.n71 18.5474
R28237 6MSB_0.OUTN 6MSB_0.OUTN.n68 14.5823
R28238 6MSB_0.OUTN.n69 6MSB_0.OUTN 1.02891
R28239 6MSB_0.OUTN.t33 6MSB_0.OUTN.n69 17.8461
R28240 6MSB_0.OUTN.t32 6MSB_0.OUTN.n69 18.5474
R28241 6MSB_0.OUTN 6MSB_0.OUTN.n66 14.5823
R28242 6MSB_0.OUTN.n67 6MSB_0.OUTN 1.02891
R28243 6MSB_0.OUTN.t31 6MSB_0.OUTN.n67 17.8461
R28244 6MSB_0.OUTN.t30 6MSB_0.OUTN.n67 18.5474
R28245 6MSB_0.OUTN 6MSB_0.OUTN.n64 14.5823
R28246 6MSB_0.OUTN.n65 6MSB_0.OUTN 1.02891
R28247 6MSB_0.OUTN.t45 6MSB_0.OUTN.n65 17.8461
R28248 6MSB_0.OUTN.t44 6MSB_0.OUTN.n65 18.5474
R28249 6MSB_0.OUTN 6MSB_0.OUTN.n62 14.5823
R28250 6MSB_0.OUTN.n63 6MSB_0.OUTN 1.02891
R28251 6MSB_0.OUTN.t129 6MSB_0.OUTN.n63 17.8461
R28252 6MSB_0.OUTN.t128 6MSB_0.OUTN.n63 18.5474
R28253 6MSB_0.OUTN 6MSB_0.OUTN.n60 14.5823
R28254 6MSB_0.OUTN.n61 6MSB_0.OUTN 1.02891
R28255 6MSB_0.OUTN.t95 6MSB_0.OUTN.n61 17.8461
R28256 6MSB_0.OUTN.t94 6MSB_0.OUTN.n61 18.5474
R28257 6MSB_0.OUTN.n35 6MSB_0.OUTN.n36 0.0283452
R28258 6MSB_0.OUTN.n32 6MSB_0.OUTN.n31 0.0553571
R28259 6MSB_0.OUTN.n31 6MSB_0.OUTN.n30 0.0553571
R28260 6MSB_0.OUTN 6MSB_0.OUTN.n49 19.7052
R28261 6MSB_0.OUTN.n47 6MSB_0.OUTN.n49 5.12336
R28262 6MSB_0.OUTN.n45 6MSB_0.OUTN.n47 5.12336
R28263 6MSB_0.OUTN.n43 6MSB_0.OUTN.n45 5.12336
R28264 6MSB_0.OUTN.n41 6MSB_0.OUTN.n43 5.12336
R28265 6MSB_0.OUTN.n39 6MSB_0.OUTN.n41 5.12336
R28266 6MSB_0.OUTN.n37 6MSB_0.OUTN.n39 5.12336
R28267 6MSB_0.OUTN.n36 6MSB_0.OUTN.n37 3.73604
R28268 6MSB_0.OUTN.n51 6MSB_0.OUTN 1.02891
R28269 6MSB_0.OUTN.t15 6MSB_0.OUTN.n51 17.8461
R28270 6MSB_0.OUTN.t14 6MSB_0.OUTN.n51 18.5474
R28271 6MSB_0.OUTN 6MSB_0.OUTN.n49 14.5823
R28272 6MSB_0.OUTN.n50 6MSB_0.OUTN 1.02891
R28273 6MSB_0.OUTN.t7 6MSB_0.OUTN.n50 17.8461
R28274 6MSB_0.OUTN.t6 6MSB_0.OUTN.n50 18.5474
R28275 6MSB_0.OUTN 6MSB_0.OUTN.n47 14.5823
R28276 6MSB_0.OUTN.n48 6MSB_0.OUTN 1.02891
R28277 6MSB_0.OUTN.t127 6MSB_0.OUTN.n48 17.8461
R28278 6MSB_0.OUTN.t126 6MSB_0.OUTN.n48 18.5474
R28279 6MSB_0.OUTN 6MSB_0.OUTN.n45 14.5823
R28280 6MSB_0.OUTN.n46 6MSB_0.OUTN 1.02891
R28281 6MSB_0.OUTN.t29 6MSB_0.OUTN.n46 17.8461
R28282 6MSB_0.OUTN.t28 6MSB_0.OUTN.n46 18.5474
R28283 6MSB_0.OUTN 6MSB_0.OUTN.n43 14.5823
R28284 6MSB_0.OUTN.n44 6MSB_0.OUTN 1.02891
R28285 6MSB_0.OUTN.t43 6MSB_0.OUTN.n44 17.8461
R28286 6MSB_0.OUTN.t42 6MSB_0.OUTN.n44 18.5474
R28287 6MSB_0.OUTN 6MSB_0.OUTN.n41 14.5823
R28288 6MSB_0.OUTN.n42 6MSB_0.OUTN 1.02891
R28289 6MSB_0.OUTN.t117 6MSB_0.OUTN.n42 17.8461
R28290 6MSB_0.OUTN.t116 6MSB_0.OUTN.n42 18.5474
R28291 6MSB_0.OUTN 6MSB_0.OUTN.n39 14.5823
R28292 6MSB_0.OUTN.n40 6MSB_0.OUTN 1.02891
R28293 6MSB_0.OUTN.t17 6MSB_0.OUTN.n40 17.8461
R28294 6MSB_0.OUTN.t16 6MSB_0.OUTN.n40 18.5474
R28295 6MSB_0.OUTN 6MSB_0.OUTN.n37 14.5823
R28296 6MSB_0.OUTN.n38 6MSB_0.OUTN 1.02891
R28297 6MSB_0.OUTN.t115 6MSB_0.OUTN.n38 17.8461
R28298 6MSB_0.OUTN.t114 6MSB_0.OUTN.n38 18.5474
R28299 6MSB_0.OUTN.n12 6MSB_0.OUTN.n13 0.0283452
R28300 6MSB_0.OUTN.n9 6MSB_0.OUTN.n8 0.0553571
R28301 6MSB_0.OUTN.n8 6MSB_0.OUTN.n7 0.0553571
R28302 6MSB_0.OUTN 6MSB_0.OUTN.n26 19.7052
R28303 6MSB_0.OUTN.n24 6MSB_0.OUTN.n26 5.12336
R28304 6MSB_0.OUTN.n22 6MSB_0.OUTN.n24 5.12336
R28305 6MSB_0.OUTN.n20 6MSB_0.OUTN.n22 5.12336
R28306 6MSB_0.OUTN.n18 6MSB_0.OUTN.n20 5.12336
R28307 6MSB_0.OUTN.n16 6MSB_0.OUTN.n18 5.12336
R28308 6MSB_0.OUTN.n14 6MSB_0.OUTN.n16 5.12336
R28309 6MSB_0.OUTN.n13 6MSB_0.OUTN.n14 3.73793
R28310 6MSB_0.OUTN.n28 6MSB_0.OUTN 1.02891
R28311 6MSB_0.OUTN.t101 6MSB_0.OUTN.n28 17.8461
R28312 6MSB_0.OUTN.t100 6MSB_0.OUTN.n28 18.5474
R28313 6MSB_0.OUTN 6MSB_0.OUTN.n26 14.5823
R28314 6MSB_0.OUTN.n27 6MSB_0.OUTN 1.02891
R28315 6MSB_0.OUTN.t109 6MSB_0.OUTN.n27 17.8461
R28316 6MSB_0.OUTN.t108 6MSB_0.OUTN.n27 18.5474
R28317 6MSB_0.OUTN 6MSB_0.OUTN.n24 14.5823
R28318 6MSB_0.OUTN.n25 6MSB_0.OUTN 1.02891
R28319 6MSB_0.OUTN.t107 6MSB_0.OUTN.n25 17.8461
R28320 6MSB_0.OUTN.t106 6MSB_0.OUTN.n25 18.5474
R28321 6MSB_0.OUTN 6MSB_0.OUTN.n22 14.5823
R28322 6MSB_0.OUTN.n23 6MSB_0.OUTN 1.02891
R28323 6MSB_0.OUTN.t99 6MSB_0.OUTN.n23 17.8461
R28324 6MSB_0.OUTN.t98 6MSB_0.OUTN.n23 18.5474
R28325 6MSB_0.OUTN 6MSB_0.OUTN.n20 14.5823
R28326 6MSB_0.OUTN.n21 6MSB_0.OUTN 1.02891
R28327 6MSB_0.OUTN.t97 6MSB_0.OUTN.n21 17.8461
R28328 6MSB_0.OUTN.t96 6MSB_0.OUTN.n21 18.5474
R28329 6MSB_0.OUTN 6MSB_0.OUTN.n18 14.5823
R28330 6MSB_0.OUTN.n19 6MSB_0.OUTN 1.02891
R28331 6MSB_0.OUTN.t111 6MSB_0.OUTN.n19 17.8461
R28332 6MSB_0.OUTN.t110 6MSB_0.OUTN.n19 18.5474
R28333 6MSB_0.OUTN 6MSB_0.OUTN.n16 14.5823
R28334 6MSB_0.OUTN.n17 6MSB_0.OUTN 1.02891
R28335 6MSB_0.OUTN.t105 6MSB_0.OUTN.n17 17.8461
R28336 6MSB_0.OUTN.t104 6MSB_0.OUTN.n17 18.5474
R28337 6MSB_0.OUTN 6MSB_0.OUTN.n14 14.5823
R28338 6MSB_0.OUTN.n15 6MSB_0.OUTN 1.02891
R28339 6MSB_0.OUTN.t113 6MSB_0.OUTN.n15 17.8461
R28340 6MSB_0.OUTN.t112 6MSB_0.OUTN.n15 18.5474
R28341 a_51442_27857.t5 a_51442_27857.n2 17.0005
R28342 a_51442_27857.n2 a_51442_27857.n0 1.26894
R28343 a_51442_27857.n1 a_51442_27857.t3 17.0005
R28344 a_51442_27857.n0 a_51442_27857.n1 1.26894
R28345 a_51442_27857.n1 a_51442_27857.t0 18.9255
R28346 a_51442_27857.n0 a_51442_27857.t2 35.3608
R28347 a_51442_27857.n0 a_51442_27857.t4 17.5677
R28348 a_51442_27857.n2 a_51442_27857.t1 18.9255
R28349 a_50817_27517.t0 a_50817_27517.n0 8.53521
R28350 a_50817_27517.n0 a_50817_27517.t2 15.9571
R28351 a_50817_27517.n0 a_50817_27517.t1 6.13626
R28352 a_50396_27497.t0 a_50396_27497.n0 8.53379
R28353 a_50396_27497.n0 a_50396_27497.t1 6.23476
R28354 a_50396_27497.n0 a_50396_27497.t2 35.06
C123 X10 VSS 4.64686f
C124 X9 VSS 3.27655f
C125 X8 VSS 4.14285f
C126 X4 VSS 5.60974f
C127 X3 VSS 6.10708f
C128 X6 VSS 6.53119f
C129 X5 VSS 7.13836f
C130 X7 VSS 6.95893f
C131 X2 VSS 3.7073f
C132 CLK VSS 0.21374p
C133 X1 VSS 2.0674f
C134 VDD VSS 0.68238p
C135 a_50719_594# VSS 2.13725f $ **FLOATING
C136 a_44199_594# VSS 2.15315f $ **FLOATING
C137 a_37679_594# VSS 2.13709f $ **FLOATING
C138 a_31159_594# VSS 2.13709f $ **FLOATING
C139 a_24639_594# VSS 2.13709f $ **FLOATING
C140 a_18119_594# VSS 2.13709f $ **FLOATING
C141 a_11599_594# VSS 2.13965f $ **FLOATING
C142 a_5079_594# VSS 2.13965f $ **FLOATING
C143 a_50719_3394# VSS 2.11901f $ **FLOATING
C144 a_44199_3394# VSS 2.13513f $ **FLOATING
C145 a_37679_3394# VSS 2.11885f $ **FLOATING
C146 a_31159_3394# VSS 2.11885f $ **FLOATING
C147 a_24639_3394# VSS 2.11885f $ **FLOATING
C148 a_18119_3394# VSS 2.11885f $ **FLOATING
C149 a_11599_3394# VSS 2.12183f $ **FLOATING
C150 a_5079_3394# VSS 2.12183f $ **FLOATING
C151 a_50719_6194# VSS 2.13636f $ **FLOATING
C152 a_44199_6194# VSS 2.15222f $ **FLOATING
C153 a_37679_6194# VSS 2.1362f $ **FLOATING
C154 a_31159_6194# VSS 2.1362f $ **FLOATING
C155 a_24639_6194# VSS 2.1362f $ **FLOATING
C156 a_18119_6194# VSS 2.1362f $ **FLOATING
C157 a_11599_6194# VSS 2.13867f $ **FLOATING
C158 a_5079_6194# VSS 2.13867f $ **FLOATING
C159 a_50719_8994# VSS 2.1207f $ **FLOATING
C160 a_44199_8994# VSS 2.13679f $ **FLOATING
C161 a_37679_8994# VSS 2.12053f $ **FLOATING
C162 a_31159_8994# VSS 2.12053f $ **FLOATING
C163 a_24639_8994# VSS 2.12053f $ **FLOATING
C164 a_18119_8994# VSS 2.12053f $ **FLOATING
C165 a_11599_8994# VSS 2.12347f $ **FLOATING
C166 a_5079_8994# VSS 2.12347f $ **FLOATING
C167 a_50719_11794# VSS 2.13764f $ **FLOATING
C168 a_44199_11794# VSS 2.15348f $ **FLOATING
C169 a_37679_11794# VSS 2.13748f $ **FLOATING
C170 a_31159_11794# VSS 2.13748f $ **FLOATING
C171 a_24639_11794# VSS 2.13748f $ **FLOATING
C172 a_18119_11794# VSS 2.13748f $ **FLOATING
C173 a_11599_11794# VSS 2.13992f $ **FLOATING
C174 a_5079_11794# VSS 2.13992f $ **FLOATING
C175 a_50719_14594# VSS 2.11901f $ **FLOATING
C176 a_44199_14594# VSS 2.13513f $ **FLOATING
C177 a_37679_14594# VSS 2.11885f $ **FLOATING
C178 a_31159_14594# VSS 2.11885f $ **FLOATING
C179 a_24639_14594# VSS 2.11885f $ **FLOATING
C180 a_18119_14594# VSS 2.11885f $ **FLOATING
C181 a_11599_14594# VSS 2.12183f $ **FLOATING
C182 a_5079_14594# VSS 2.12183f $ **FLOATING
C183 a_50719_17394# VSS 2.13764f $ **FLOATING
C184 a_44199_17394# VSS 2.15348f $ **FLOATING
C185 a_37679_17394# VSS 2.13748f $ **FLOATING
C186 a_31159_17394# VSS 2.13748f $ **FLOATING
C187 a_24639_17394# VSS 2.13748f $ **FLOATING
C188 a_18119_17394# VSS 2.13748f $ **FLOATING
C189 a_11599_17394# VSS 2.13992f $ **FLOATING
C190 a_5079_17394# VSS 2.13992f $ **FLOATING
C191 a_44199_20194# VSS 2.13524f $ **FLOATING
C192 a_37679_20194# VSS 2.11885f $ **FLOATING
C193 a_31159_20194# VSS 2.11885f $ **FLOATING
C194 a_24639_20194# VSS 2.11885f $ **FLOATING
C195 a_18119_20194# VSS 2.11885f $ **FLOATING
C196 a_11599_20194# VSS 2.12183f $ **FLOATING
C197 a_5079_20194# VSS 2.12183f $ **FLOATING
C198 4LSB_weighted_0.VBIAS VSS 0.3556p $ **FLOATING
C199 6MSB_0.OUTP VSS 0.21377p $ **FLOATING
C200 6MSB_0.OUTN VSS 0.18582p $ **FLOATING
C201 a_50396_27497.t0 VSS 0.07257f $ **FLOATING
C202 a_50396_27497.n0 VSS 0.64858f $ **FLOATING
C203 a_50396_27497.t2 VSS 0.48696f $ **FLOATING
C204 a_50396_27497.t1 VSS 0.11853f $ **FLOATING
C205 a_50817_27517.t0 VSS 0.07268f $ **FLOATING
C206 a_50817_27517.t1 VSS 0.11842f $ **FLOATING
C207 a_50817_27517.n0 VSS 0.51246f $ **FLOATING
C208 a_50817_27517.t2 VSS 0.30209f $ **FLOATING
C209 a_51442_27857.t5 VSS 0.09489f $ **FLOATING
C210 a_51442_27857.t1 VSS 0.10896f $ **FLOATING
C211 a_51442_27857.t4 VSS 0.0966f $ **FLOATING
C212 a_51442_27857.n0 VSS 0.48257f $ **FLOATING
C213 a_51442_27857.t2 VSS 0.14851f $ **FLOATING
C214 a_51442_27857.t3 VSS 0.09489f $ **FLOATING
C215 a_51442_27857.n1 VSS 0.3198f $ **FLOATING
C216 a_51442_27857.t0 VSS 0.10896f $ **FLOATING
C217 a_51442_27857.n2 VSS 0.3198f $ **FLOATING
C218 6MSB_0.OUTN.t1 VSS 0.05915f $ **FLOATING
C219 6MSB_0.OUTN.n0 VSS 4.21351f $ **FLOATING
C220 6MSB_0.OUTN.n1 VSS 0.14853f $ **FLOATING
C221 6MSB_0.OUTN.n2 VSS 0.13433f $ **FLOATING
C222 6MSB_0.OUTN.n3 VSS 1.63942f $ **FLOATING
C223 6MSB_0.OUTN.n5 VSS 4.21351f $ **FLOATING
C224 6MSB_0.OUTN.n6 VSS 7.4335f $ **FLOATING
C225 6MSB_0.OUTN.n7 VSS 0.06394f $ **FLOATING
C226 6MSB_0.OUTN.n8 VSS 0.11123f $ **FLOATING
C227 6MSB_0.OUTN.n9 VSS 0.11123f $ **FLOATING
C228 6MSB_0.OUTN.n11 VSS 4.21332f $ **FLOATING
C229 6MSB_0.OUTN.n13 VSS 1.64179f $ **FLOATING
C230 6MSB_0.OUTN.n14 VSS 4.56482f $ **FLOATING
C231 6MSB_0.OUTN.t112 VSS 0.06285f $ **FLOATING
C232 6MSB_0.OUTN.t113 VSS 0.05915f $ **FLOATING
C233 6MSB_0.OUTN.n15 VSS 0.22392f $ **FLOATING
C234 6MSB_0.OUTN.n16 VSS 7.09488f $ **FLOATING
C235 6MSB_0.OUTN.t104 VSS 0.06285f $ **FLOATING
C236 6MSB_0.OUTN.t105 VSS 0.05915f $ **FLOATING
C237 6MSB_0.OUTN.n17 VSS 0.22392f $ **FLOATING
C238 6MSB_0.OUTN.n18 VSS 7.09488f $ **FLOATING
C239 6MSB_0.OUTN.t110 VSS 0.06285f $ **FLOATING
C240 6MSB_0.OUTN.t111 VSS 0.05915f $ **FLOATING
C241 6MSB_0.OUTN.n19 VSS 0.22392f $ **FLOATING
C242 6MSB_0.OUTN.n20 VSS 7.09488f $ **FLOATING
C243 6MSB_0.OUTN.t96 VSS 0.06285f $ **FLOATING
C244 6MSB_0.OUTN.t97 VSS 0.05915f $ **FLOATING
C245 6MSB_0.OUTN.n21 VSS 0.22392f $ **FLOATING
C246 6MSB_0.OUTN.n22 VSS 7.09488f $ **FLOATING
C247 6MSB_0.OUTN.t98 VSS 0.06285f $ **FLOATING
C248 6MSB_0.OUTN.t99 VSS 0.05915f $ **FLOATING
C249 6MSB_0.OUTN.n23 VSS 0.22392f $ **FLOATING
C250 6MSB_0.OUTN.n24 VSS 7.09488f $ **FLOATING
C251 6MSB_0.OUTN.t106 VSS 0.06285f $ **FLOATING
C252 6MSB_0.OUTN.t107 VSS 0.05915f $ **FLOATING
C253 6MSB_0.OUTN.n25 VSS 0.22392f $ **FLOATING
C254 6MSB_0.OUTN.n26 VSS 14.3703f $ **FLOATING
C255 6MSB_0.OUTN.t108 VSS 0.06285f $ **FLOATING
C256 6MSB_0.OUTN.t109 VSS 0.05915f $ **FLOATING
C257 6MSB_0.OUTN.n27 VSS 0.22392f $ **FLOATING
C258 6MSB_0.OUTN.t100 VSS 0.06285f $ **FLOATING
C259 6MSB_0.OUTN.t101 VSS 0.05915f $ **FLOATING
C260 6MSB_0.OUTN.n28 VSS 0.22392f $ **FLOATING
C261 6MSB_0.OUTN.n29 VSS 4.21332f $ **FLOATING
C262 6MSB_0.OUTN.n30 VSS 0.06078f $ **FLOATING
C263 6MSB_0.OUTN.n31 VSS 0.11123f $ **FLOATING
C264 6MSB_0.OUTN.n32 VSS 0.11123f $ **FLOATING
C265 6MSB_0.OUTN.n34 VSS 4.21332f $ **FLOATING
C266 6MSB_0.OUTN.n36 VSS 1.63942f $ **FLOATING
C267 6MSB_0.OUTN.n37 VSS 4.56402f $ **FLOATING
C268 6MSB_0.OUTN.t114 VSS 0.06285f $ **FLOATING
C269 6MSB_0.OUTN.t115 VSS 0.05915f $ **FLOATING
C270 6MSB_0.OUTN.n38 VSS 0.22392f $ **FLOATING
C271 6MSB_0.OUTN.n39 VSS 7.09488f $ **FLOATING
C272 6MSB_0.OUTN.t16 VSS 0.06285f $ **FLOATING
C273 6MSB_0.OUTN.t17 VSS 0.05915f $ **FLOATING
C274 6MSB_0.OUTN.n40 VSS 0.22392f $ **FLOATING
C275 6MSB_0.OUTN.n41 VSS 7.09488f $ **FLOATING
C276 6MSB_0.OUTN.t116 VSS 0.06285f $ **FLOATING
C277 6MSB_0.OUTN.t117 VSS 0.05915f $ **FLOATING
C278 6MSB_0.OUTN.n42 VSS 0.22392f $ **FLOATING
C279 6MSB_0.OUTN.n43 VSS 7.09488f $ **FLOATING
C280 6MSB_0.OUTN.t42 VSS 0.06285f $ **FLOATING
C281 6MSB_0.OUTN.t43 VSS 0.05915f $ **FLOATING
C282 6MSB_0.OUTN.n44 VSS 0.22392f $ **FLOATING
C283 6MSB_0.OUTN.n45 VSS 7.09488f $ **FLOATING
C284 6MSB_0.OUTN.t28 VSS 0.06285f $ **FLOATING
C285 6MSB_0.OUTN.t29 VSS 0.05915f $ **FLOATING
C286 6MSB_0.OUTN.n46 VSS 0.22392f $ **FLOATING
C287 6MSB_0.OUTN.n47 VSS 7.09488f $ **FLOATING
C288 6MSB_0.OUTN.t126 VSS 0.06285f $ **FLOATING
C289 6MSB_0.OUTN.t127 VSS 0.05915f $ **FLOATING
C290 6MSB_0.OUTN.n48 VSS 0.22392f $ **FLOATING
C291 6MSB_0.OUTN.n49 VSS 14.3703f $ **FLOATING
C292 6MSB_0.OUTN.t6 VSS 0.06285f $ **FLOATING
C293 6MSB_0.OUTN.t7 VSS 0.05915f $ **FLOATING
C294 6MSB_0.OUTN.n50 VSS 0.22392f $ **FLOATING
C295 6MSB_0.OUTN.t14 VSS 0.06285f $ **FLOATING
C296 6MSB_0.OUTN.t15 VSS 0.05915f $ **FLOATING
C297 6MSB_0.OUTN.n51 VSS 0.22392f $ **FLOATING
C298 6MSB_0.OUTN.n52 VSS 4.21332f $ **FLOATING
C299 6MSB_0.OUTN.n53 VSS 0.06078f $ **FLOATING
C300 6MSB_0.OUTN.n54 VSS 0.11123f $ **FLOATING
C301 6MSB_0.OUTN.n55 VSS 0.11123f $ **FLOATING
C302 6MSB_0.OUTN.n57 VSS 4.21332f $ **FLOATING
C303 6MSB_0.OUTN.n59 VSS 1.63942f $ **FLOATING
C304 6MSB_0.OUTN.n60 VSS 4.56402f $ **FLOATING
C305 6MSB_0.OUTN.t94 VSS 0.06285f $ **FLOATING
C306 6MSB_0.OUTN.t95 VSS 0.05915f $ **FLOATING
C307 6MSB_0.OUTN.n61 VSS 0.22392f $ **FLOATING
C308 6MSB_0.OUTN.n62 VSS 7.09488f $ **FLOATING
C309 6MSB_0.OUTN.t128 VSS 0.06285f $ **FLOATING
C310 6MSB_0.OUTN.t129 VSS 0.05915f $ **FLOATING
C311 6MSB_0.OUTN.n63 VSS 0.22392f $ **FLOATING
C312 6MSB_0.OUTN.n64 VSS 7.09488f $ **FLOATING
C313 6MSB_0.OUTN.t44 VSS 0.06285f $ **FLOATING
C314 6MSB_0.OUTN.t45 VSS 0.05915f $ **FLOATING
C315 6MSB_0.OUTN.n65 VSS 0.22392f $ **FLOATING
C316 6MSB_0.OUTN.n66 VSS 7.09488f $ **FLOATING
C317 6MSB_0.OUTN.t30 VSS 0.06285f $ **FLOATING
C318 6MSB_0.OUTN.t31 VSS 0.05915f $ **FLOATING
C319 6MSB_0.OUTN.n67 VSS 0.22392f $ **FLOATING
C320 6MSB_0.OUTN.n68 VSS 7.09488f $ **FLOATING
C321 6MSB_0.OUTN.t32 VSS 0.06285f $ **FLOATING
C322 6MSB_0.OUTN.t33 VSS 0.05915f $ **FLOATING
C323 6MSB_0.OUTN.n69 VSS 0.22392f $ **FLOATING
C324 6MSB_0.OUTN.n70 VSS 7.09488f $ **FLOATING
C325 6MSB_0.OUTN.t90 VSS 0.06285f $ **FLOATING
C326 6MSB_0.OUTN.t91 VSS 0.05915f $ **FLOATING
C327 6MSB_0.OUTN.n71 VSS 0.22392f $ **FLOATING
C328 6MSB_0.OUTN.n72 VSS 14.3703f $ **FLOATING
C329 6MSB_0.OUTN.t50 VSS 0.06285f $ **FLOATING
C330 6MSB_0.OUTN.t51 VSS 0.05915f $ **FLOATING
C331 6MSB_0.OUTN.n73 VSS 0.22392f $ **FLOATING
C332 6MSB_0.OUTN.t92 VSS 0.06285f $ **FLOATING
C333 6MSB_0.OUTN.t93 VSS 0.05915f $ **FLOATING
C334 6MSB_0.OUTN.n74 VSS 0.22392f $ **FLOATING
C335 6MSB_0.OUTN.n75 VSS 4.21332f $ **FLOATING
C336 6MSB_0.OUTN.n76 VSS 0.06078f $ **FLOATING
C337 6MSB_0.OUTN.n77 VSS 0.11123f $ **FLOATING
C338 6MSB_0.OUTN.n78 VSS 0.11123f $ **FLOATING
C339 6MSB_0.OUTN.n80 VSS 4.21332f $ **FLOATING
C340 6MSB_0.OUTN.n82 VSS 1.63942f $ **FLOATING
C341 6MSB_0.OUTN.n83 VSS 4.56402f $ **FLOATING
C342 6MSB_0.OUTN.t84 VSS 0.06285f $ **FLOATING
C343 6MSB_0.OUTN.t85 VSS 0.05915f $ **FLOATING
C344 6MSB_0.OUTN.n84 VSS 0.22392f $ **FLOATING
C345 6MSB_0.OUTN.n85 VSS 7.09488f $ **FLOATING
C346 6MSB_0.OUTN.t60 VSS 0.06285f $ **FLOATING
C347 6MSB_0.OUTN.t61 VSS 0.05915f $ **FLOATING
C348 6MSB_0.OUTN.n86 VSS 0.22392f $ **FLOATING
C349 6MSB_0.OUTN.n87 VSS 7.09488f $ **FLOATING
C350 6MSB_0.OUTN.t64 VSS 0.06285f $ **FLOATING
C351 6MSB_0.OUTN.t65 VSS 0.05915f $ **FLOATING
C352 6MSB_0.OUTN.n88 VSS 0.22392f $ **FLOATING
C353 6MSB_0.OUTN.n89 VSS 7.09488f $ **FLOATING
C354 6MSB_0.OUTN.t68 VSS 0.06285f $ **FLOATING
C355 6MSB_0.OUTN.t69 VSS 0.05915f $ **FLOATING
C356 6MSB_0.OUTN.n90 VSS 0.22392f $ **FLOATING
C357 6MSB_0.OUTN.n91 VSS 7.09488f $ **FLOATING
C358 6MSB_0.OUTN.t76 VSS 0.06285f $ **FLOATING
C359 6MSB_0.OUTN.t77 VSS 0.05915f $ **FLOATING
C360 6MSB_0.OUTN.n92 VSS 0.22392f $ **FLOATING
C361 6MSB_0.OUTN.n93 VSS 7.09488f $ **FLOATING
C362 6MSB_0.OUTN.t82 VSS 0.06285f $ **FLOATING
C363 6MSB_0.OUTN.t83 VSS 0.05915f $ **FLOATING
C364 6MSB_0.OUTN.n94 VSS 0.22392f $ **FLOATING
C365 6MSB_0.OUTN.n95 VSS 14.3703f $ **FLOATING
C366 6MSB_0.OUTN.t62 VSS 0.06285f $ **FLOATING
C367 6MSB_0.OUTN.t63 VSS 0.05915f $ **FLOATING
C368 6MSB_0.OUTN.n96 VSS 0.22392f $ **FLOATING
C369 6MSB_0.OUTN.t78 VSS 0.06285f $ **FLOATING
C370 6MSB_0.OUTN.t79 VSS 0.05915f $ **FLOATING
C371 6MSB_0.OUTN.n97 VSS 0.22392f $ **FLOATING
C372 6MSB_0.OUTN.n98 VSS 4.21332f $ **FLOATING
C373 6MSB_0.OUTN.n99 VSS 0.06183f $ **FLOATING
C374 6MSB_0.OUTN.n100 VSS 0.11123f $ **FLOATING
C375 6MSB_0.OUTN.n101 VSS 0.11123f $ **FLOATING
C376 6MSB_0.OUTN.n103 VSS 4.21332f $ **FLOATING
C377 6MSB_0.OUTN.n105 VSS 1.64021f $ **FLOATING
C378 6MSB_0.OUTN.n106 VSS 4.56429f $ **FLOATING
C379 6MSB_0.OUTN.t72 VSS 0.06285f $ **FLOATING
C380 6MSB_0.OUTN.t73 VSS 0.05915f $ **FLOATING
C381 6MSB_0.OUTN.n107 VSS 0.22392f $ **FLOATING
C382 6MSB_0.OUTN.n108 VSS 7.09488f $ **FLOATING
C383 6MSB_0.OUTN.t74 VSS 0.06285f $ **FLOATING
C384 6MSB_0.OUTN.t75 VSS 0.05915f $ **FLOATING
C385 6MSB_0.OUTN.n109 VSS 0.22392f $ **FLOATING
C386 6MSB_0.OUTN.n110 VSS 7.09488f $ **FLOATING
C387 6MSB_0.OUTN.t56 VSS 0.06285f $ **FLOATING
C388 6MSB_0.OUTN.t57 VSS 0.05915f $ **FLOATING
C389 6MSB_0.OUTN.n111 VSS 0.22392f $ **FLOATING
C390 6MSB_0.OUTN.n112 VSS 7.09488f $ **FLOATING
C391 6MSB_0.OUTN.t66 VSS 0.06285f $ **FLOATING
C392 6MSB_0.OUTN.t67 VSS 0.05915f $ **FLOATING
C393 6MSB_0.OUTN.n113 VSS 0.22392f $ **FLOATING
C394 6MSB_0.OUTN.n114 VSS 7.09488f $ **FLOATING
C395 6MSB_0.OUTN.t70 VSS 0.06285f $ **FLOATING
C396 6MSB_0.OUTN.t71 VSS 0.05915f $ **FLOATING
C397 6MSB_0.OUTN.n115 VSS 0.22392f $ **FLOATING
C398 6MSB_0.OUTN.n116 VSS 7.09488f $ **FLOATING
C399 6MSB_0.OUTN.t34 VSS 0.06285f $ **FLOATING
C400 6MSB_0.OUTN.t35 VSS 0.05915f $ **FLOATING
C401 6MSB_0.OUTN.n117 VSS 0.22392f $ **FLOATING
C402 6MSB_0.OUTN.n118 VSS 14.3703f $ **FLOATING
C403 6MSB_0.OUTN.t52 VSS 0.06285f $ **FLOATING
C404 6MSB_0.OUTN.t53 VSS 0.05915f $ **FLOATING
C405 6MSB_0.OUTN.n119 VSS 0.22392f $ **FLOATING
C406 6MSB_0.OUTN.t58 VSS 0.06285f $ **FLOATING
C407 6MSB_0.OUTN.t59 VSS 0.05915f $ **FLOATING
C408 6MSB_0.OUTN.n120 VSS 0.22392f $ **FLOATING
C409 6MSB_0.OUTN.n121 VSS 4.21332f $ **FLOATING
C410 6MSB_0.OUTN.n122 VSS 0.06183f $ **FLOATING
C411 6MSB_0.OUTN.n123 VSS 0.11123f $ **FLOATING
C412 6MSB_0.OUTN.n124 VSS 0.11123f $ **FLOATING
C413 6MSB_0.OUTN.n126 VSS 4.21332f $ **FLOATING
C414 6MSB_0.OUTN.n128 VSS 1.64021f $ **FLOATING
C415 6MSB_0.OUTN.n129 VSS 4.56429f $ **FLOATING
C416 6MSB_0.OUTN.t54 VSS 0.06285f $ **FLOATING
C417 6MSB_0.OUTN.t55 VSS 0.05915f $ **FLOATING
C418 6MSB_0.OUTN.n130 VSS 0.22392f $ **FLOATING
C419 6MSB_0.OUTN.n131 VSS 7.09488f $ **FLOATING
C420 6MSB_0.OUTN.t22 VSS 0.06285f $ **FLOATING
C421 6MSB_0.OUTN.t23 VSS 0.05915f $ **FLOATING
C422 6MSB_0.OUTN.n132 VSS 0.22392f $ **FLOATING
C423 6MSB_0.OUTN.n133 VSS 7.09488f $ **FLOATING
C424 6MSB_0.OUTN.t46 VSS 0.06285f $ **FLOATING
C425 6MSB_0.OUTN.t47 VSS 0.05915f $ **FLOATING
C426 6MSB_0.OUTN.n134 VSS 0.22392f $ **FLOATING
C427 6MSB_0.OUTN.n135 VSS 7.09488f $ **FLOATING
C428 6MSB_0.OUTN.t48 VSS 0.06285f $ **FLOATING
C429 6MSB_0.OUTN.t49 VSS 0.05915f $ **FLOATING
C430 6MSB_0.OUTN.n136 VSS 0.22392f $ **FLOATING
C431 6MSB_0.OUTN.n137 VSS 7.09488f $ **FLOATING
C432 6MSB_0.OUTN.t124 VSS 0.06285f $ **FLOATING
C433 6MSB_0.OUTN.t125 VSS 0.05915f $ **FLOATING
C434 6MSB_0.OUTN.n138 VSS 0.22392f $ **FLOATING
C435 6MSB_0.OUTN.n139 VSS 7.09488f $ **FLOATING
C436 6MSB_0.OUTN.t20 VSS 0.06285f $ **FLOATING
C437 6MSB_0.OUTN.t21 VSS 0.05915f $ **FLOATING
C438 6MSB_0.OUTN.n140 VSS 0.22392f $ **FLOATING
C439 6MSB_0.OUTN.n141 VSS 14.3703f $ **FLOATING
C440 6MSB_0.OUTN.t26 VSS 0.06285f $ **FLOATING
C441 6MSB_0.OUTN.t27 VSS 0.05915f $ **FLOATING
C442 6MSB_0.OUTN.n142 VSS 0.22392f $ **FLOATING
C443 6MSB_0.OUTN.t130 VSS 0.06285f $ **FLOATING
C444 6MSB_0.OUTN.t131 VSS 0.05915f $ **FLOATING
C445 6MSB_0.OUTN.n143 VSS 0.22392f $ **FLOATING
C446 6MSB_0.OUTN.n144 VSS 4.21332f $ **FLOATING
C447 6MSB_0.OUTN.n145 VSS 0.0671f $ **FLOATING
C448 6MSB_0.OUTN.n146 VSS 0.11123f $ **FLOATING
C449 6MSB_0.OUTN.n147 VSS 0.11123f $ **FLOATING
C450 6MSB_0.OUTN.n149 VSS 2.64085f $ **FLOATING
C451 6MSB_0.OUTN.n151 VSS 4.15203f $ **FLOATING
C452 6MSB_0.OUTN.n152 VSS 8.92545f $ **FLOATING
C453 6MSB_0.OUTN.t132 VSS 0.06285f $ **FLOATING
C454 6MSB_0.OUTN.t133 VSS 0.05915f $ **FLOATING
C455 6MSB_0.OUTN.n153 VSS 0.22392f $ **FLOATING
C456 6MSB_0.OUTN.n154 VSS 7.09488f $ **FLOATING
C457 6MSB_0.OUTN.t8 VSS 0.06285f $ **FLOATING
C458 6MSB_0.OUTN.t9 VSS 0.05915f $ **FLOATING
C459 6MSB_0.OUTN.n155 VSS 0.22392f $ **FLOATING
C460 6MSB_0.OUTN.n156 VSS 7.09488f $ **FLOATING
C461 6MSB_0.OUTN.t102 VSS 0.06285f $ **FLOATING
C462 6MSB_0.OUTN.t103 VSS 0.05915f $ **FLOATING
C463 6MSB_0.OUTN.n157 VSS 0.22392f $ **FLOATING
C464 6MSB_0.OUTN.n158 VSS 7.09488f $ **FLOATING
C465 6MSB_0.OUTN.t24 VSS 0.06285f $ **FLOATING
C466 6MSB_0.OUTN.t25 VSS 0.05915f $ **FLOATING
C467 6MSB_0.OUTN.n159 VSS 0.22392f $ **FLOATING
C468 6MSB_0.OUTN.n160 VSS 7.09488f $ **FLOATING
C469 6MSB_0.OUTN.t118 VSS 0.06285f $ **FLOATING
C470 6MSB_0.OUTN.t119 VSS 0.05915f $ **FLOATING
C471 6MSB_0.OUTN.n161 VSS 0.22392f $ **FLOATING
C472 6MSB_0.OUTN.n162 VSS 14.3703f $ **FLOATING
C473 6MSB_0.OUTN.t120 VSS 0.06285f $ **FLOATING
C474 6MSB_0.OUTN.t121 VSS 0.05915f $ **FLOATING
C475 6MSB_0.OUTN.n163 VSS 0.22392f $ **FLOATING
C476 6MSB_0.OUTN.t18 VSS 0.06285f $ **FLOATING
C477 6MSB_0.OUTN.t19 VSS 0.05915f $ **FLOATING
C478 6MSB_0.OUTN.n164 VSS 0.22392f $ **FLOATING
C479 6MSB_0.OUTN.n165 VSS 5.27332f $ **FLOATING
C480 6MSB_0.OUTN.t4 VSS 0.0763f $ **FLOATING
C481 6MSB_0.OUTN.t5 VSS 0.05983f $ **FLOATING
C482 6MSB_0.OUTN.n166 VSS 0.55398f $ **FLOATING
C483 6MSB_0.OUTN.n167 VSS 4.802f $ **FLOATING
C484 6MSB_0.OUTN.t3 VSS 0.05983f $ **FLOATING
C485 6MSB_0.OUTN.n168 VSS 0.55546f $ **FLOATING
C486 6MSB_0.OUTN.t2 VSS 0.0763f $ **FLOATING
C487 6MSB_0.OUTN.n169 VSS 4.32036f $ **FLOATING
C488 6MSB_0.OUTN.t86 VSS 0.07513f $ **FLOATING
C489 6MSB_0.OUTN.t87 VSS 0.05935f $ **FLOATING
C490 6MSB_0.OUTN.n170 VSS 0.54135f $ **FLOATING
C491 6MSB_0.OUTN.n171 VSS 3.63155f $ **FLOATING
C492 6MSB_0.OUTN.t88 VSS 0.05935f $ **FLOATING
C493 6MSB_0.OUTN.n172 VSS 0.54066f $ **FLOATING
C494 6MSB_0.OUTN.t89 VSS 0.07513f $ **FLOATING
C495 6MSB_0.OUTN.n173 VSS 7.09488f $ **FLOATING
C496 6MSB_0.OUTN.t12 VSS 0.06285f $ **FLOATING
C497 6MSB_0.OUTN.t13 VSS 0.05915f $ **FLOATING
C498 6MSB_0.OUTN.n174 VSS 0.22392f $ **FLOATING
C499 6MSB_0.OUTN.n175 VSS 7.09488f $ **FLOATING
C500 6MSB_0.OUTN.t10 VSS 0.06285f $ **FLOATING
C501 6MSB_0.OUTN.t11 VSS 0.05915f $ **FLOATING
C502 6MSB_0.OUTN.n176 VSS 0.22392f $ **FLOATING
C503 6MSB_0.OUTN.n177 VSS 7.09488f $ **FLOATING
C504 6MSB_0.OUTN.t36 VSS 0.06285f $ **FLOATING
C505 6MSB_0.OUTN.t37 VSS 0.05915f $ **FLOATING
C506 6MSB_0.OUTN.n178 VSS 0.22392f $ **FLOATING
C507 6MSB_0.OUTN.n179 VSS 7.09488f $ **FLOATING
C508 6MSB_0.OUTN.t122 VSS 0.06285f $ **FLOATING
C509 6MSB_0.OUTN.t123 VSS 0.05915f $ **FLOATING
C510 6MSB_0.OUTN.n180 VSS 0.22392f $ **FLOATING
C511 6MSB_0.OUTN.n181 VSS 7.09488f $ **FLOATING
C512 6MSB_0.OUTN.t38 VSS 0.06285f $ **FLOATING
C513 6MSB_0.OUTN.t39 VSS 0.05915f $ **FLOATING
C514 6MSB_0.OUTN.n182 VSS 0.22392f $ **FLOATING
C515 6MSB_0.OUTN.n183 VSS 14.3703f $ **FLOATING
C516 6MSB_0.OUTN.t80 VSS 0.06285f $ **FLOATING
C517 6MSB_0.OUTN.t81 VSS 0.05915f $ **FLOATING
C518 6MSB_0.OUTN.n184 VSS 0.22392f $ **FLOATING
C519 6MSB_0.OUTN.t40 VSS 0.06285f $ **FLOATING
C520 6MSB_0.OUTN.t41 VSS 0.05915f $ **FLOATING
C521 6MSB_0.OUTN.n185 VSS 0.22392f $ **FLOATING
C522 6MSB_0.OUTN.n186 VSS 4.56402f $ **FLOATING
C523 6MSB_0.OUTN.t0 VSS 0.06285f $ **FLOATING
C524 6MSB_0.OUTN.n187 VSS 0.22392f $ **FLOATING
C525 6MSB_0.OUTP.t1 VSS 0.04333f $ **FLOATING
C526 6MSB_0.OUTP.n0 VSS 3.05151f $ **FLOATING
C527 6MSB_0.OUTP.n1 VSS 0.10681f $ **FLOATING
C528 6MSB_0.OUTP.n2 VSS 0.09729f $ **FLOATING
C529 6MSB_0.OUTP.n3 VSS 0.81008f $ **FLOATING
C530 6MSB_0.OUTP.n5 VSS 3.05151f $ **FLOATING
C531 6MSB_0.OUTP.n6 VSS 4.94758f $ **FLOATING
C532 6MSB_0.OUTP.n7 VSS 0.0463f $ **FLOATING
C533 6MSB_0.OUTP.n8 VSS 0.08056f $ **FLOATING
C534 6MSB_0.OUTP.n9 VSS 0.08056f $ **FLOATING
C535 6MSB_0.OUTP.n11 VSS 3.05137f $ **FLOATING
C536 6MSB_0.OUTP.n13 VSS 0.81253f $ **FLOATING
C537 6MSB_0.OUTP.n14 VSS 3.17011f $ **FLOATING
C538 6MSB_0.OUTP.t117 VSS 0.04333f $ **FLOATING
C539 6MSB_0.OUTP.n15 VSS 0.39696f $ **FLOATING
C540 6MSB_0.OUTP.t116 VSS 0.05526f $ **FLOATING
C541 6MSB_0.OUTP.n16 VSS 5.22326f $ **FLOATING
C542 6MSB_0.OUTP.t119 VSS 0.04333f $ **FLOATING
C543 6MSB_0.OUTP.n17 VSS 0.39696f $ **FLOATING
C544 6MSB_0.OUTP.t118 VSS 0.05526f $ **FLOATING
C545 6MSB_0.OUTP.n18 VSS 5.22326f $ **FLOATING
C546 6MSB_0.OUTP.t107 VSS 0.04333f $ **FLOATING
C547 6MSB_0.OUTP.n19 VSS 0.39696f $ **FLOATING
C548 6MSB_0.OUTP.t106 VSS 0.05526f $ **FLOATING
C549 6MSB_0.OUTP.n20 VSS 5.22326f $ **FLOATING
C550 6MSB_0.OUTP.t109 VSS 0.04333f $ **FLOATING
C551 6MSB_0.OUTP.n21 VSS 0.39696f $ **FLOATING
C552 6MSB_0.OUTP.t108 VSS 0.05526f $ **FLOATING
C553 6MSB_0.OUTP.n22 VSS 5.22326f $ **FLOATING
C554 6MSB_0.OUTP.t113 VSS 0.04333f $ **FLOATING
C555 6MSB_0.OUTP.n23 VSS 0.39696f $ **FLOATING
C556 6MSB_0.OUTP.t112 VSS 0.05526f $ **FLOATING
C557 6MSB_0.OUTP.n24 VSS 5.22326f $ **FLOATING
C558 6MSB_0.OUTP.t105 VSS 0.04333f $ **FLOATING
C559 6MSB_0.OUTP.n25 VSS 0.39696f $ **FLOATING
C560 6MSB_0.OUTP.t104 VSS 0.05526f $ **FLOATING
C561 6MSB_0.OUTP.n26 VSS 10.7952f $ **FLOATING
C562 6MSB_0.OUTP.t111 VSS 0.04333f $ **FLOATING
C563 6MSB_0.OUTP.n27 VSS 0.39696f $ **FLOATING
C564 6MSB_0.OUTP.t110 VSS 0.05526f $ **FLOATING
C565 6MSB_0.OUTP.t115 VSS 0.04333f $ **FLOATING
C566 6MSB_0.OUTP.n28 VSS 2.16979f $ **FLOATING
C567 6MSB_0.OUTP.t114 VSS 0.05526f $ **FLOATING
C568 6MSB_0.OUTP.n29 VSS 3.05137f $ **FLOATING
C569 6MSB_0.OUTP.n30 VSS 0.04325f $ **FLOATING
C570 6MSB_0.OUTP.n31 VSS 0.08056f $ **FLOATING
C571 6MSB_0.OUTP.n32 VSS 0.08056f $ **FLOATING
C572 6MSB_0.OUTP.n34 VSS 3.05137f $ **FLOATING
C573 6MSB_0.OUTP.n36 VSS 0.81008f $ **FLOATING
C574 6MSB_0.OUTP.n37 VSS 3.16951f $ **FLOATING
C575 6MSB_0.OUTP.t7 VSS 0.04333f $ **FLOATING
C576 6MSB_0.OUTP.n38 VSS 0.39696f $ **FLOATING
C577 6MSB_0.OUTP.t6 VSS 0.05526f $ **FLOATING
C578 6MSB_0.OUTP.n39 VSS 5.22326f $ **FLOATING
C579 6MSB_0.OUTP.t47 VSS 0.04333f $ **FLOATING
C580 6MSB_0.OUTP.n40 VSS 0.39696f $ **FLOATING
C581 6MSB_0.OUTP.t46 VSS 0.05526f $ **FLOATING
C582 6MSB_0.OUTP.n41 VSS 5.22326f $ **FLOATING
C583 6MSB_0.OUTP.t35 VSS 0.04333f $ **FLOATING
C584 6MSB_0.OUTP.n42 VSS 0.39696f $ **FLOATING
C585 6MSB_0.OUTP.t34 VSS 0.05526f $ **FLOATING
C586 6MSB_0.OUTP.n43 VSS 5.22326f $ **FLOATING
C587 6MSB_0.OUTP.t55 VSS 0.04333f $ **FLOATING
C588 6MSB_0.OUTP.n44 VSS 0.39696f $ **FLOATING
C589 6MSB_0.OUTP.t54 VSS 0.05526f $ **FLOATING
C590 6MSB_0.OUTP.n45 VSS 5.22326f $ **FLOATING
C591 6MSB_0.OUTP.t9 VSS 0.04333f $ **FLOATING
C592 6MSB_0.OUTP.n46 VSS 0.39696f $ **FLOATING
C593 6MSB_0.OUTP.t8 VSS 0.05526f $ **FLOATING
C594 6MSB_0.OUTP.n47 VSS 5.22326f $ **FLOATING
C595 6MSB_0.OUTP.t43 VSS 0.04333f $ **FLOATING
C596 6MSB_0.OUTP.n48 VSS 0.39696f $ **FLOATING
C597 6MSB_0.OUTP.t42 VSS 0.05526f $ **FLOATING
C598 6MSB_0.OUTP.n49 VSS 10.7952f $ **FLOATING
C599 6MSB_0.OUTP.t31 VSS 0.04333f $ **FLOATING
C600 6MSB_0.OUTP.n50 VSS 0.39696f $ **FLOATING
C601 6MSB_0.OUTP.t30 VSS 0.05526f $ **FLOATING
C602 6MSB_0.OUTP.t17 VSS 0.04333f $ **FLOATING
C603 6MSB_0.OUTP.n51 VSS 2.16979f $ **FLOATING
C604 6MSB_0.OUTP.t16 VSS 0.05526f $ **FLOATING
C605 6MSB_0.OUTP.n52 VSS 3.05137f $ **FLOATING
C606 6MSB_0.OUTP.n53 VSS 0.04173f $ **FLOATING
C607 6MSB_0.OUTP.n54 VSS 0.08056f $ **FLOATING
C608 6MSB_0.OUTP.n55 VSS 0.08056f $ **FLOATING
C609 6MSB_0.OUTP.n57 VSS 3.05137f $ **FLOATING
C610 6MSB_0.OUTP.n59 VSS 0.80886f $ **FLOATING
C611 6MSB_0.OUTP.n60 VSS 3.16921f $ **FLOATING
C612 6MSB_0.OUTP.t51 VSS 0.04333f $ **FLOATING
C613 6MSB_0.OUTP.n61 VSS 0.39696f $ **FLOATING
C614 6MSB_0.OUTP.t50 VSS 0.05526f $ **FLOATING
C615 6MSB_0.OUTP.n62 VSS 5.22326f $ **FLOATING
C616 6MSB_0.OUTP.t63 VSS 0.04333f $ **FLOATING
C617 6MSB_0.OUTP.n63 VSS 0.39696f $ **FLOATING
C618 6MSB_0.OUTP.t62 VSS 0.05526f $ **FLOATING
C619 6MSB_0.OUTP.n64 VSS 5.22326f $ **FLOATING
C620 6MSB_0.OUTP.t65 VSS 0.04333f $ **FLOATING
C621 6MSB_0.OUTP.n65 VSS 0.39696f $ **FLOATING
C622 6MSB_0.OUTP.t64 VSS 0.05526f $ **FLOATING
C623 6MSB_0.OUTP.n66 VSS 5.22326f $ **FLOATING
C624 6MSB_0.OUTP.t29 VSS 0.04333f $ **FLOATING
C625 6MSB_0.OUTP.n67 VSS 0.39696f $ **FLOATING
C626 6MSB_0.OUTP.t28 VSS 0.05526f $ **FLOATING
C627 6MSB_0.OUTP.n68 VSS 5.22326f $ **FLOATING
C628 6MSB_0.OUTP.t15 VSS 0.04333f $ **FLOATING
C629 6MSB_0.OUTP.n69 VSS 0.39696f $ **FLOATING
C630 6MSB_0.OUTP.t14 VSS 0.05526f $ **FLOATING
C631 6MSB_0.OUTP.n70 VSS 5.22326f $ **FLOATING
C632 6MSB_0.OUTP.t37 VSS 0.04333f $ **FLOATING
C633 6MSB_0.OUTP.n71 VSS 0.39696f $ **FLOATING
C634 6MSB_0.OUTP.t36 VSS 0.05526f $ **FLOATING
C635 6MSB_0.OUTP.n72 VSS 10.7952f $ **FLOATING
C636 6MSB_0.OUTP.t103 VSS 0.04333f $ **FLOATING
C637 6MSB_0.OUTP.n73 VSS 0.39696f $ **FLOATING
C638 6MSB_0.OUTP.t102 VSS 0.05526f $ **FLOATING
C639 6MSB_0.OUTP.t49 VSS 0.04333f $ **FLOATING
C640 6MSB_0.OUTP.n74 VSS 2.16979f $ **FLOATING
C641 6MSB_0.OUTP.t48 VSS 0.05526f $ **FLOATING
C642 6MSB_0.OUTP.n75 VSS 3.05137f $ **FLOATING
C643 6MSB_0.OUTP.n76 VSS 0.04402f $ **FLOATING
C644 6MSB_0.OUTP.n77 VSS 0.08056f $ **FLOATING
C645 6MSB_0.OUTP.n78 VSS 0.08056f $ **FLOATING
C646 6MSB_0.OUTP.n80 VSS 3.05137f $ **FLOATING
C647 6MSB_0.OUTP.n82 VSS 0.8107f $ **FLOATING
C648 6MSB_0.OUTP.n83 VSS 3.16966f $ **FLOATING
C649 6MSB_0.OUTP.t99 VSS 0.04333f $ **FLOATING
C650 6MSB_0.OUTP.n84 VSS 0.39696f $ **FLOATING
C651 6MSB_0.OUTP.t98 VSS 0.05526f $ **FLOATING
C652 6MSB_0.OUTP.n85 VSS 5.22326f $ **FLOATING
C653 6MSB_0.OUTP.t89 VSS 0.04333f $ **FLOATING
C654 6MSB_0.OUTP.n86 VSS 0.39696f $ **FLOATING
C655 6MSB_0.OUTP.t88 VSS 0.05526f $ **FLOATING
C656 6MSB_0.OUTP.n87 VSS 5.22326f $ **FLOATING
C657 6MSB_0.OUTP.t93 VSS 0.04333f $ **FLOATING
C658 6MSB_0.OUTP.n88 VSS 0.39696f $ **FLOATING
C659 6MSB_0.OUTP.t92 VSS 0.05526f $ **FLOATING
C660 6MSB_0.OUTP.n89 VSS 5.22326f $ **FLOATING
C661 6MSB_0.OUTP.t79 VSS 0.04333f $ **FLOATING
C662 6MSB_0.OUTP.n90 VSS 0.39696f $ **FLOATING
C663 6MSB_0.OUTP.t78 VSS 0.05526f $ **FLOATING
C664 6MSB_0.OUTP.n91 VSS 5.22326f $ **FLOATING
C665 6MSB_0.OUTP.t97 VSS 0.04333f $ **FLOATING
C666 6MSB_0.OUTP.n92 VSS 0.39696f $ **FLOATING
C667 6MSB_0.OUTP.t96 VSS 0.05526f $ **FLOATING
C668 6MSB_0.OUTP.n93 VSS 5.22326f $ **FLOATING
C669 6MSB_0.OUTP.t87 VSS 0.04333f $ **FLOATING
C670 6MSB_0.OUTP.n94 VSS 0.39696f $ **FLOATING
C671 6MSB_0.OUTP.t86 VSS 0.05526f $ **FLOATING
C672 6MSB_0.OUTP.n95 VSS 10.7952f $ **FLOATING
C673 6MSB_0.OUTP.t83 VSS 0.04333f $ **FLOATING
C674 6MSB_0.OUTP.n96 VSS 0.39696f $ **FLOATING
C675 6MSB_0.OUTP.t82 VSS 0.05526f $ **FLOATING
C676 6MSB_0.OUTP.t91 VSS 0.04333f $ **FLOATING
C677 6MSB_0.OUTP.n97 VSS 2.16979f $ **FLOATING
C678 6MSB_0.OUTP.t90 VSS 0.05526f $ **FLOATING
C679 6MSB_0.OUTP.n98 VSS 3.05137f $ **FLOATING
C680 6MSB_0.OUTP.n99 VSS 0.04249f $ **FLOATING
C681 6MSB_0.OUTP.n100 VSS 0.08056f $ **FLOATING
C682 6MSB_0.OUTP.n101 VSS 0.08056f $ **FLOATING
C683 6MSB_0.OUTP.n103 VSS 3.05137f $ **FLOATING
C684 6MSB_0.OUTP.n105 VSS 0.80947f $ **FLOATING
C685 6MSB_0.OUTP.n106 VSS 3.16936f $ **FLOATING
C686 6MSB_0.OUTP.t75 VSS 0.04333f $ **FLOATING
C687 6MSB_0.OUTP.n107 VSS 0.39696f $ **FLOATING
C688 6MSB_0.OUTP.t74 VSS 0.05526f $ **FLOATING
C689 6MSB_0.OUTP.n108 VSS 5.22326f $ **FLOATING
C690 6MSB_0.OUTP.t81 VSS 0.04333f $ **FLOATING
C691 6MSB_0.OUTP.n109 VSS 0.39696f $ **FLOATING
C692 6MSB_0.OUTP.t80 VSS 0.05526f $ **FLOATING
C693 6MSB_0.OUTP.n110 VSS 5.22326f $ **FLOATING
C694 6MSB_0.OUTP.t85 VSS 0.04333f $ **FLOATING
C695 6MSB_0.OUTP.n111 VSS 0.39696f $ **FLOATING
C696 6MSB_0.OUTP.t84 VSS 0.05526f $ **FLOATING
C697 6MSB_0.OUTP.n112 VSS 5.22326f $ **FLOATING
C698 6MSB_0.OUTP.t11 VSS 0.04333f $ **FLOATING
C699 6MSB_0.OUTP.n113 VSS 0.39696f $ **FLOATING
C700 6MSB_0.OUTP.t10 VSS 0.05526f $ **FLOATING
C701 6MSB_0.OUTP.n114 VSS 5.22326f $ **FLOATING
C702 6MSB_0.OUTP.t129 VSS 0.04333f $ **FLOATING
C703 6MSB_0.OUTP.n115 VSS 0.39696f $ **FLOATING
C704 6MSB_0.OUTP.t128 VSS 0.05526f $ **FLOATING
C705 6MSB_0.OUTP.n116 VSS 5.22326f $ **FLOATING
C706 6MSB_0.OUTP.t13 VSS 0.04333f $ **FLOATING
C707 6MSB_0.OUTP.n117 VSS 0.39696f $ **FLOATING
C708 6MSB_0.OUTP.t12 VSS 0.05526f $ **FLOATING
C709 6MSB_0.OUTP.n118 VSS 10.7952f $ **FLOATING
C710 6MSB_0.OUTP.t67 VSS 0.04333f $ **FLOATING
C711 6MSB_0.OUTP.n119 VSS 0.39696f $ **FLOATING
C712 6MSB_0.OUTP.t66 VSS 0.05526f $ **FLOATING
C713 6MSB_0.OUTP.t19 VSS 0.04333f $ **FLOATING
C714 6MSB_0.OUTP.n120 VSS 2.16979f $ **FLOATING
C715 6MSB_0.OUTP.t18 VSS 0.05526f $ **FLOATING
C716 6MSB_0.OUTP.n121 VSS 3.05137f $ **FLOATING
C717 6MSB_0.OUTP.n122 VSS 0.04402f $ **FLOATING
C718 6MSB_0.OUTP.n123 VSS 0.08056f $ **FLOATING
C719 6MSB_0.OUTP.n124 VSS 0.08056f $ **FLOATING
C720 6MSB_0.OUTP.n126 VSS 3.05137f $ **FLOATING
C721 6MSB_0.OUTP.n128 VSS 0.8107f $ **FLOATING
C722 6MSB_0.OUTP.n129 VSS 3.16966f $ **FLOATING
C723 6MSB_0.OUTP.t5 VSS 0.04333f $ **FLOATING
C724 6MSB_0.OUTP.n130 VSS 0.39696f $ **FLOATING
C725 6MSB_0.OUTP.t4 VSS 0.05526f $ **FLOATING
C726 6MSB_0.OUTP.n131 VSS 5.22326f $ **FLOATING
C727 6MSB_0.OUTP.t41 VSS 0.04333f $ **FLOATING
C728 6MSB_0.OUTP.n132 VSS 0.39696f $ **FLOATING
C729 6MSB_0.OUTP.t40 VSS 0.05526f $ **FLOATING
C730 6MSB_0.OUTP.n133 VSS 5.22326f $ **FLOATING
C731 6MSB_0.OUTP.t133 VSS 0.04333f $ **FLOATING
C732 6MSB_0.OUTP.n134 VSS 0.39696f $ **FLOATING
C733 6MSB_0.OUTP.t132 VSS 0.05526f $ **FLOATING
C734 6MSB_0.OUTP.n135 VSS 5.22326f $ **FLOATING
C735 6MSB_0.OUTP.t131 VSS 0.04333f $ **FLOATING
C736 6MSB_0.OUTP.n136 VSS 0.39696f $ **FLOATING
C737 6MSB_0.OUTP.t130 VSS 0.05526f $ **FLOATING
C738 6MSB_0.OUTP.n137 VSS 5.22326f $ **FLOATING
C739 6MSB_0.OUTP.t125 VSS 0.04333f $ **FLOATING
C740 6MSB_0.OUTP.n138 VSS 0.39696f $ **FLOATING
C741 6MSB_0.OUTP.t124 VSS 0.05526f $ **FLOATING
C742 6MSB_0.OUTP.n139 VSS 5.22326f $ **FLOATING
C743 6MSB_0.OUTP.t127 VSS 0.04333f $ **FLOATING
C744 6MSB_0.OUTP.n140 VSS 0.39696f $ **FLOATING
C745 6MSB_0.OUTP.t126 VSS 0.05526f $ **FLOATING
C746 6MSB_0.OUTP.n141 VSS 10.7952f $ **FLOATING
C747 6MSB_0.OUTP.t53 VSS 0.04333f $ **FLOATING
C748 6MSB_0.OUTP.n142 VSS 0.39696f $ **FLOATING
C749 6MSB_0.OUTP.t52 VSS 0.05526f $ **FLOATING
C750 6MSB_0.OUTP.t95 VSS 0.04333f $ **FLOATING
C751 6MSB_0.OUTP.n143 VSS 2.16979f $ **FLOATING
C752 6MSB_0.OUTP.t94 VSS 0.05526f $ **FLOATING
C753 6MSB_0.OUTP.n144 VSS 3.05137f $ **FLOATING
C754 6MSB_0.OUTP.n145 VSS 0.0402f $ **FLOATING
C755 6MSB_0.OUTP.n146 VSS 0.08056f $ **FLOATING
C756 6MSB_0.OUTP.n147 VSS 0.08056f $ **FLOATING
C757 6MSB_0.OUTP.n149 VSS 1.47992f $ **FLOATING
C758 6MSB_0.OUTP.n151 VSS 2.60209f $ **FLOATING
C759 6MSB_0.OUTP.n152 VSS 6.34819f $ **FLOATING
C760 6MSB_0.OUTP.t101 VSS 0.04333f $ **FLOATING
C761 6MSB_0.OUTP.n153 VSS 0.39696f $ **FLOATING
C762 6MSB_0.OUTP.t100 VSS 0.05526f $ **FLOATING
C763 6MSB_0.OUTP.n154 VSS 5.22326f $ **FLOATING
C764 6MSB_0.OUTP.t27 VSS 0.04333f $ **FLOATING
C765 6MSB_0.OUTP.n155 VSS 0.39696f $ **FLOATING
C766 6MSB_0.OUTP.t26 VSS 0.05526f $ **FLOATING
C767 6MSB_0.OUTP.n156 VSS 5.22326f $ **FLOATING
C768 6MSB_0.OUTP.t123 VSS 0.04333f $ **FLOATING
C769 6MSB_0.OUTP.n157 VSS 0.39696f $ **FLOATING
C770 6MSB_0.OUTP.t122 VSS 0.05526f $ **FLOATING
C771 6MSB_0.OUTP.n158 VSS 5.22326f $ **FLOATING
C772 6MSB_0.OUTP.t23 VSS 0.04333f $ **FLOATING
C773 6MSB_0.OUTP.n159 VSS 0.39696f $ **FLOATING
C774 6MSB_0.OUTP.t22 VSS 0.05526f $ **FLOATING
C775 6MSB_0.OUTP.n160 VSS 5.22326f $ **FLOATING
C776 6MSB_0.OUTP.t25 VSS 0.04333f $ **FLOATING
C777 6MSB_0.OUTP.n161 VSS 0.39696f $ **FLOATING
C778 6MSB_0.OUTP.t24 VSS 0.05526f $ **FLOATING
C779 6MSB_0.OUTP.n162 VSS 10.7952f $ **FLOATING
C780 6MSB_0.OUTP.t61 VSS 0.04333f $ **FLOATING
C781 6MSB_0.OUTP.n163 VSS 0.39696f $ **FLOATING
C782 6MSB_0.OUTP.t60 VSS 0.05526f $ **FLOATING
C783 6MSB_0.OUTP.t77 VSS 0.04333f $ **FLOATING
C784 6MSB_0.OUTP.n164 VSS 2.16979f $ **FLOATING
C785 6MSB_0.OUTP.t76 VSS 0.05526f $ **FLOATING
C786 6MSB_0.OUTP.n165 VSS 4.53292f $ **FLOATING
C787 6MSB_0.OUTP.t39 VSS 0.04284f $ **FLOATING
C788 6MSB_0.OUTP.n166 VSS 0.29818f $ **FLOATING
C789 6MSB_0.OUTP.t38 VSS 0.04552f $ **FLOATING
C790 6MSB_0.OUTP.n167 VSS 3.41562f $ **FLOATING
C791 6MSB_0.OUTP.t32 VSS 0.04552f $ **FLOATING
C792 6MSB_0.OUTP.t33 VSS 0.04284f $ **FLOATING
C793 6MSB_0.OUTP.n168 VSS 0.2993f $ **FLOATING
C794 6MSB_0.OUTP.n169 VSS 2.96667f $ **FLOATING
C795 6MSB_0.OUTP.t21 VSS 0.04284f $ **FLOATING
C796 6MSB_0.OUTP.n170 VSS 0.29926f $ **FLOATING
C797 6MSB_0.OUTP.t20 VSS 0.04552f $ **FLOATING
C798 6MSB_0.OUTP.n171 VSS 4.33008f $ **FLOATING
C799 6MSB_0.OUTP.t68 VSS 0.04552f $ **FLOATING
C800 6MSB_0.OUTP.t69 VSS 0.04284f $ **FLOATING
C801 6MSB_0.OUTP.n172 VSS 0.29894f $ **FLOATING
C802 6MSB_0.OUTP.n173 VSS 3.16951f $ **FLOATING
C803 6MSB_0.OUTP.t3 VSS 0.04333f $ **FLOATING
C804 6MSB_0.OUTP.n174 VSS 0.39696f $ **FLOATING
C805 6MSB_0.OUTP.t2 VSS 0.05526f $ **FLOATING
C806 6MSB_0.OUTP.n175 VSS 5.22326f $ **FLOATING
C807 6MSB_0.OUTP.t71 VSS 0.04333f $ **FLOATING
C808 6MSB_0.OUTP.n176 VSS 0.39696f $ **FLOATING
C809 6MSB_0.OUTP.t70 VSS 0.05526f $ **FLOATING
C810 6MSB_0.OUTP.n177 VSS 5.22326f $ **FLOATING
C811 6MSB_0.OUTP.t73 VSS 0.04333f $ **FLOATING
C812 6MSB_0.OUTP.n178 VSS 0.39696f $ **FLOATING
C813 6MSB_0.OUTP.t72 VSS 0.05526f $ **FLOATING
C814 6MSB_0.OUTP.n179 VSS 5.22326f $ **FLOATING
C815 6MSB_0.OUTP.t121 VSS 0.04333f $ **FLOATING
C816 6MSB_0.OUTP.n180 VSS 0.39696f $ **FLOATING
C817 6MSB_0.OUTP.t120 VSS 0.05526f $ **FLOATING
C818 6MSB_0.OUTP.n181 VSS 5.22326f $ **FLOATING
C819 6MSB_0.OUTP.t45 VSS 0.04333f $ **FLOATING
C820 6MSB_0.OUTP.n182 VSS 0.39696f $ **FLOATING
C821 6MSB_0.OUTP.t44 VSS 0.05526f $ **FLOATING
C822 6MSB_0.OUTP.n183 VSS 10.7952f $ **FLOATING
C823 6MSB_0.OUTP.t57 VSS 0.04333f $ **FLOATING
C824 6MSB_0.OUTP.n184 VSS 0.39696f $ **FLOATING
C825 6MSB_0.OUTP.t56 VSS 0.05526f $ **FLOATING
C826 6MSB_0.OUTP.t59 VSS 0.04333f $ **FLOATING
C827 6MSB_0.OUTP.n185 VSS 2.16979f $ **FLOATING
C828 6MSB_0.OUTP.t58 VSS 0.05526f $ **FLOATING
C829 6MSB_0.OUTP.n186 VSS 5.22326f $ **FLOATING
C830 6MSB_0.OUTP.t0 VSS 0.05526f $ **FLOATING
C831 6MSB_0.OUTP.n187 VSS 0.39696f $ **FLOATING
C832 a_48514_27442.t0 VSS 0.14125f $ **FLOATING
C833 a_48514_27442.t3 VSS 0.32221f $ **FLOATING
C834 a_48514_27442.t2 VSS 0.15289f $ **FLOATING
C835 a_48514_27442.t1 VSS 0.15132f $ **FLOATING
C836 a_48514_27442.n0 VSS 0.35399f $ **FLOATING
C837 a_48514_27442.n1 VSS 0.45198f $ **FLOATING
C838 a_48254_27219.t0 VSS 0.1855f $ **FLOATING
C839 a_48254_27219.t1 VSS 0.18652f $ **FLOATING
C840 a_48254_27219.n0 VSS 1.00284f $ **FLOATING
C841 a_48254_27219.t2 VSS 0.16689f $ **FLOATING
C842 a_48254_27219.n1 VSS 1.08716f $ **FLOATING
C843 a_48254_27219.t3 VSS 0.17284f $ **FLOATING
C844 a_48540_27537.t0 VSS 0.20291f $ **FLOATING
C845 a_48540_27537.t4 VSS 0.26194f $ **FLOATING
C846 a_48540_27537.n0 VSS 0.53803f $ **FLOATING
C847 a_48540_27537.t2 VSS 0.28557f $ **FLOATING
C848 a_48540_27537.t3 VSS 0.28796f $ **FLOATING
C849 a_48540_27537.n1 VSS 0.8668f $ **FLOATING
C850 a_48540_27537.t1 VSS 0.29225f $ **FLOATING
C851 a_48540_27537.n2 VSS 0.52581f $ **FLOATING
C852 a_48949_27476.t0 VSS 0.16415f $ **FLOATING
C853 a_48949_27476.t3 VSS 0.63694f $ **FLOATING
C854 a_48949_27476.n0 VSS 0.33731f $ **FLOATING
C855 a_48949_27476.t1 VSS 0.24022f $ **FLOATING
C856 a_48949_27476.n1 VSS 0.19105f $ **FLOATING
C857 a_48949_27476.t2 VSS 0.26566f $ **FLOATING
C858 a_49051_27563.t0 VSS 0.20661f $ **FLOATING
C859 a_49051_27563.t3 VSS 0.29103f $ **FLOATING
C860 a_49051_27563.n0 VSS 0.65337f $ **FLOATING
C861 a_49051_27563.t1 VSS 0.314f $ **FLOATING
C862 a_49051_27563.t2 VSS 0.28076f $ **FLOATING
C863 a_49051_27563.n1 VSS 0.35157f $ **FLOATING
C864 a_49799_27296.t0 VSS 0.24053f $ **FLOATING
C865 a_49799_27296.t1 VSS 0.15859f $ **FLOATING
C866 a_49799_27296.t2 VSS 0.80042f $ **FLOATING
C867 a_49799_27296.n0 VSS 0.44996f $ **FLOATING
C868 a_50027_27436.t0 VSS 0.11255f $ **FLOATING
C869 a_50027_27436.t2 VSS 0.22435f $ **FLOATING
C870 a_50027_27436.t1 VSS 0.11174f $ **FLOATING
C871 a_50027_27436.n0 VSS 0.48958f $ **FLOATING
C872 a_50600_27497.t0 VSS 0.08889f $ **FLOATING
C873 a_50600_27497.t2 VSS 0.29458f $ **FLOATING
C874 a_50600_27497.t1 VSS 0.14182f $ **FLOATING
C875 a_50600_27497.n0 VSS 0.33333f $ **FLOATING
C876 a_48829_27232.t0 VSS 0.39847f $ **FLOATING
C877 a_48829_27232.t1 VSS 0.45852f $ **FLOATING
C878 a_49705_27296.t0 VSS 0.37995f $ **FLOATING
C879 a_49705_27296.t1 VSS 0.38132f $ **FLOATING
C880 a_51768_27313.t1 VSS 0.02782f $ **FLOATING
C881 a_51768_27313.t0 VSS 0.02782f $ **FLOATING
C882 a_48254_26907.t0 VSS 0.16421f $ **FLOATING
C883 a_48254_26907.t3 VSS 0.18352f $ **FLOATING
C884 a_48254_26907.n0 VSS 0.98674f $ **FLOATING
C885 a_48254_26907.t2 VSS 0.18252f $ **FLOATING
C886 a_48254_26907.t1 VSS 0.17006f $ **FLOATING
C887 a_48254_26907.n1 VSS 1.06972f $ **FLOATING
C888 a_48514_26437.t0 VSS 0.14982f $ **FLOATING
C889 a_48514_26437.t1 VSS 0.15138f $ **FLOATING
C890 a_48514_26437.t2 VSS 0.13986f $ **FLOATING
C891 a_48514_26437.t3 VSS 0.31903f $ **FLOATING
C892 a_48514_26437.n0 VSS 0.44751f $ **FLOATING
C893 a_48514_26437.n1 VSS 0.3505f $ **FLOATING
C894 a_48540_26473.t0 VSS 0.28155f $ **FLOATING
C895 a_48540_26473.t4 VSS 0.25825f $ **FLOATING
C896 a_48540_26473.t3 VSS 0.28813f $ **FLOATING
C897 a_48540_26473.n0 VSS 0.51841f $ **FLOATING
C898 a_48540_26473.t2 VSS 0.20005f $ **FLOATING
C899 a_48540_26473.n1 VSS 0.53069f $ **FLOATING
C900 a_48540_26473.t1 VSS 0.2839f $ **FLOATING
C901 a_48540_26473.n2 VSS 0.85435f $ **FLOATING
C902 a_48949_26480.t0 VSS 0.16258f $ **FLOATING
C903 a_48949_26480.t3 VSS 0.63085f $ **FLOATING
C904 a_48949_26480.n0 VSS 0.33409f $ **FLOATING
C905 a_48949_26480.t1 VSS 0.23792f $ **FLOATING
C906 a_48949_26480.n1 VSS 0.18922f $ **FLOATING
C907 a_48949_26480.t2 VSS 0.26312f $ **FLOATING
C908 a_48829_26894.t0 VSS 0.45173f $ **FLOATING
C909 a_48829_26894.t1 VSS 0.39256f $ **FLOATING
C910 a_49051_26480.t0 VSS 0.20371f $ **FLOATING
C911 a_49051_26480.t3 VSS 0.28695f $ **FLOATING
C912 a_49051_26480.n0 VSS 0.64421f $ **FLOATING
C913 a_49051_26480.t1 VSS 0.30959f $ **FLOATING
C914 a_49051_26480.t2 VSS 0.27683f $ **FLOATING
C915 a_49051_26480.n1 VSS 0.34664f $ **FLOATING
C916 a_50027_26708.t0 VSS 0.10902f $ **FLOATING
C917 a_50027_26708.t1 VSS 0.10981f $ **FLOATING
C918 a_50027_26708.n0 VSS 0.47769f $ **FLOATING
C919 a_50027_26708.t2 VSS 0.2189f $ **FLOATING
C920 a_49799_26830.t0 VSS 0.1567f $ **FLOATING
C921 a_49799_26830.t2 VSS 0.79084f $ **FLOATING
C922 a_49799_26830.n0 VSS 0.44458f $ **FLOATING
C923 a_49799_26830.t1 VSS 0.23765f $ **FLOATING
C924 a_50600_26513.t0 VSS 0.08793f $ **FLOATING
C925 a_50600_26513.t2 VSS 0.29141f $ **FLOATING
C926 a_50600_26513.t1 VSS 0.14029f $ **FLOATING
C927 a_50600_26513.n0 VSS 0.32974f $ **FLOATING
C928 a_49705_26830.t0 VSS 0.37565f $ **FLOATING
C929 a_49705_26830.t1 VSS 0.377f $ **FLOATING
C930 a_50396_26489.t0 VSS 0.07414f $ **FLOATING
C931 a_50396_26489.n0 VSS 0.65832f $ **FLOATING
C932 a_50396_26489.t2 VSS 0.49442f $ **FLOATING
C933 a_50396_26489.t1 VSS 0.12109f $ **FLOATING
C934 a_50817_26469.t0 VSS 0.06995f $ **FLOATING
C935 a_50817_26469.t1 VSS 0.11398f $ **FLOATING
C936 a_50817_26469.n0 VSS 0.49325f $ **FLOATING
C937 a_50817_26469.t2 VSS 0.2898f $ **FLOATING
C938 a_51683_26669.t3 VSS 0.02858f $ **FLOATING
C939 a_51683_26669.t1 VSS 0.02859f $ **FLOATING
C940 a_51683_26669.n0 VSS 0.07882f $ **FLOATING
C941 a_51683_26669.t2 VSS 0.02858f $ **FLOATING
C942 a_51683_26669.t0 VSS 0.02859f $ **FLOATING
C943 a_51683_26669.n1 VSS 0.07882f $ **FLOATING
C944 a_51440_26253.t1 VSS 0.11272f $ **FLOATING
C945 a_51440_26253.t3 VSS 0.09817f $ **FLOATING
C946 a_51440_26253.n0 VSS 0.33085f $ **FLOATING
C947 a_51440_26253.t4 VSS 0.09994f $ **FLOATING
C948 a_51440_26253.n1 VSS 0.44842f $ **FLOATING
C949 a_51440_26253.t5 VSS 0.13564f $ **FLOATING
C950 a_51440_26253.t2 VSS 0.09817f $ **FLOATING
C951 a_51440_26253.n2 VSS 0.33085f $ **FLOATING
C952 a_51440_26253.t0 VSS 0.11272f $ **FLOATING
C953 a_485_25427.t0 VSS 0.13707f $ **FLOATING
C954 a_485_25427.t2 VSS 0.4856f $ **FLOATING
C955 a_485_25427.t1 VSS 0.18858f $ **FLOATING
C956 a_485_25427.n0 VSS 0.60941f $ **FLOATING
C957 a_1261_25305.t0 VSS 0.12205f $ **FLOATING
C958 a_1261_25305.t2 VSS 0.4084f $ **FLOATING
C959 a_1261_25305.n0 VSS 0.46239f $ **FLOATING
C960 a_1261_25305.t1 VSS 0.17761f $ **FLOATING
C961 a_1963_25289.t0 VSS 0.09612f $ **FLOATING
C962 a_1963_25289.t2 VSS 0.36397f $ **FLOATING
C963 a_1963_25289.t1 VSS 0.15072f $ **FLOATING
C964 a_1963_25289.n0 VSS 0.40119f $ **FLOATING
C965 a_521_25453.t0 VSS 0.07152f $ **FLOATING
C966 a_521_25453.n0 VSS 6.05946f $ **FLOATING
C967 a_521_25453.t9 VSS 0.09077f $ **FLOATING
C968 a_521_25453.n1 VSS 15.8737f $ **FLOATING
C969 a_521_25453.t8 VSS 0.09077f $ **FLOATING
C970 a_521_25453.n2 VSS 2.55935f $ **FLOATING
C971 a_521_25453.t7 VSS 0.09077f $ **FLOATING
C972 a_521_25453.n3 VSS 2.55935f $ **FLOATING
C973 a_521_25453.t6 VSS 0.09077f $ **FLOATING
C974 a_521_25453.n4 VSS 2.55935f $ **FLOATING
C975 a_521_25453.t5 VSS 0.09077f $ **FLOATING
C976 a_521_25453.n5 VSS 2.55935f $ **FLOATING
C977 a_521_25453.t4 VSS 0.09077f $ **FLOATING
C978 a_521_25453.n6 VSS 2.55935f $ **FLOATING
C979 a_521_25453.t3 VSS 0.09077f $ **FLOATING
C980 a_521_25453.n7 VSS 4.54664f $ **FLOATING
C981 a_521_25453.t2 VSS 0.23366f $ **FLOATING
C982 a_521_25453.t1 VSS 0.10655f $ **FLOATING
C983 a_1317_25535.t0 VSS 0.02071f $ **FLOATING
C984 a_2009_25540.t0 VSS 0.03674f $ **FLOATING
C985 a_2713_25289.t0 VSS 0.09666f $ **FLOATING
C986 a_2713_25289.t2 VSS 0.366f $ **FLOATING
C987 a_2713_25289.t1 VSS 0.15156f $ **FLOATING
C988 a_2713_25289.n0 VSS 0.40342f $ **FLOATING
C989 a_3509_25305.t1 VSS 0.1202f $ **FLOATING
C990 a_3509_25305.t2 VSS 0.4022f $ **FLOATING
C991 a_3509_25305.n0 VSS 0.45538f $ **FLOATING
C992 a_3509_25305.t0 VSS 0.17491f $ **FLOATING
C993 a_1201_24910.t0 VSS 0.14637f $ **FLOATING
C994 a_1201_24910.t1 VSS 0.22538f $ **FLOATING
C995 a_1201_24910.n0 VSS 0.62182f $ **FLOATING
C996 a_1201_24910.t2 VSS 0.27114f $ **FLOATING
C997 a_3161_25540.t0 VSS 0.03813f $ **FLOATING
C998 a_1997_24905.t0 VSS 0.16107f $ **FLOATING
C999 a_1997_24905.n0 VSS 0.54655f $ **FLOATING
C1000 a_1997_24905.t2 VSS 0.28163f $ **FLOATING
C1001 a_1997_24905.t1 VSS 0.24719f $ **FLOATING
C1002 a_3893_25535.t0 VSS 0.02242f $ **FLOATING
C1003 a_4285_25305.t0 VSS 0.12077f $ **FLOATING
C1004 a_4285_25305.t2 VSS 0.40409f $ **FLOATING
C1005 a_4285_25305.n0 VSS 0.45752f $ **FLOATING
C1006 a_4285_25305.t1 VSS 0.17573f $ **FLOATING
C1007 a_50205_25015.t0 VSS 0.06759f $ **FLOATING
C1008 a_50205_25015.n0 VSS 0.67322f $ **FLOATING
C1009 a_50205_25015.t2 VSS 0.483f $ **FLOATING
C1010 a_50205_25015.t1 VSS 0.1104f $ **FLOATING
C1011 a_4341_25535.t0 VSS 0.02281f $ **FLOATING
C1012 a_2713_24910.t0 VSS 0.06311f $ **FLOATING
C1013 a_2713_24910.n0 VSS 0.11301f $ **FLOATING
C1014 a_2713_24910.t10 VSS 0.06842f $ **FLOATING
C1015 a_2713_24910.n1 VSS 1.45138f $ **FLOATING
C1016 a_2713_24910.t9 VSS 0.06676f $ **FLOATING
C1017 a_2713_24910.n2 VSS 4.61968f $ **FLOATING
C1018 a_2713_24910.t8 VSS 0.06676f $ **FLOATING
C1019 a_2713_24910.n3 VSS 1.88236f $ **FLOATING
C1020 a_2713_24910.t7 VSS 0.06676f $ **FLOATING
C1021 a_2713_24910.n4 VSS 1.88236f $ **FLOATING
C1022 a_2713_24910.t6 VSS 0.06676f $ **FLOATING
C1023 a_2713_24910.n5 VSS 1.88236f $ **FLOATING
C1024 a_2713_24910.t5 VSS 0.06676f $ **FLOATING
C1025 a_2713_24910.n6 VSS 1.88236f $ **FLOATING
C1026 a_2713_24910.t4 VSS 0.06676f $ **FLOATING
C1027 a_2713_24910.n7 VSS 1.88236f $ **FLOATING
C1028 a_2713_24910.t3 VSS 0.06676f $ **FLOATING
C1029 a_2713_24910.n8 VSS 3.34398f $ **FLOATING
C1030 a_2713_24910.t2 VSS 0.17185f $ **FLOATING
C1031 a_2713_24910.t1 VSS 0.09658f $ **FLOATING
C1032 a_50626_25035.t0 VSS 0.05876f $ **FLOATING
C1033 a_50626_25035.t1 VSS 0.09574f $ **FLOATING
C1034 a_50626_25035.n0 VSS 0.5889f $ **FLOATING
C1035 a_50626_25035.t2 VSS 0.24978f $ **FLOATING
C1036 a_3545_25331.t0 VSS 0.08344f $ **FLOATING
C1037 a_3545_25331.t1 VSS 0.12927f $ **FLOATING
C1038 a_3545_25331.n0 VSS 14.9967f $ **FLOATING
C1039 a_3545_25331.t9 VSS 0.10592f $ **FLOATING
C1040 a_3545_25331.n1 VSS 23.3191f $ **FLOATING
C1041 a_3545_25331.t8 VSS 0.10592f $ **FLOATING
C1042 a_3545_25331.n2 VSS 2.98645f $ **FLOATING
C1043 a_3545_25331.t7 VSS 0.10592f $ **FLOATING
C1044 a_3545_25331.n3 VSS 2.98645f $ **FLOATING
C1045 a_3545_25331.t6 VSS 0.10592f $ **FLOATING
C1046 a_3545_25331.n4 VSS 2.98645f $ **FLOATING
C1047 a_3545_25331.t5 VSS 0.10592f $ **FLOATING
C1048 a_3545_25331.n5 VSS 2.98645f $ **FLOATING
C1049 a_3545_25331.t4 VSS 0.10592f $ **FLOATING
C1050 a_3545_25331.n6 VSS 2.98645f $ **FLOATING
C1051 a_3545_25331.t3 VSS 0.10592f $ **FLOATING
C1052 a_3545_25331.n7 VSS 5.30538f $ **FLOATING
C1053 a_3545_25331.t2 VSS 0.27265f $ **FLOATING
C1054 a_51440_25469.t6 VSS 0.06511f $ **FLOATING
C1055 a_51440_25469.n0 VSS 0.36166f $ **FLOATING
C1056 a_51440_25469.t3 VSS 0.10572f $ **FLOATING
C1057 a_51440_25469.n1 VSS 0.4078f $ **FLOATING
C1058 a_51440_25469.t2 VSS 0.10329f $ **FLOATING
C1059 a_51440_25469.n2 VSS 0.35432f $ **FLOATING
C1060 a_51440_25469.t0 VSS 0.1186f $ **FLOATING
C1061 a_51440_25469.t4 VSS 0.10329f $ **FLOATING
C1062 a_51440_25469.n3 VSS 0.35432f $ **FLOATING
C1063 a_51440_25469.t1 VSS 0.1186f $ **FLOATING
C1064 a_51440_25469.t5 VSS 0.06511f $ **FLOATING
C1065 a_1201_24685.t0 VSS 0.09084f $ **FLOATING
C1066 a_1201_24685.t2 VSS 0.34397f $ **FLOATING
C1067 a_1201_24685.t1 VSS 0.14244f $ **FLOATING
C1068 a_1201_24685.n0 VSS 0.37914f $ **FLOATING
C1069 a_1997_24701.t0 VSS 0.11615f $ **FLOATING
C1070 a_1997_24701.t2 VSS 0.38865f $ **FLOATING
C1071 a_1997_24701.n0 VSS 0.44003f $ **FLOATING
C1072 a_1997_24701.t1 VSS 0.16902f $ **FLOATING
C1073 a_1649_24936.t0 VSS 0.03042f $ **FLOATING
C1074 a_2381_24931.t0 VSS 0.02012f $ **FLOATING
C1075 a_4305_24905.t0 VSS 0.13625f $ **FLOATING
C1076 a_4305_24905.n0 VSS 0.57874f $ **FLOATING
C1077 a_4305_24905.t2 VSS 0.28243f $ **FLOATING
C1078 a_4305_24905.t1 VSS 0.21065f $ **FLOATING
C1079 a_2713_24685.t0 VSS 0.09913f $ **FLOATING
C1080 a_2713_24685.t2 VSS 0.37535f $ **FLOATING
C1081 a_2713_24685.t1 VSS 0.15543f $ **FLOATING
C1082 a_2713_24685.n0 VSS 0.41373f $ **FLOATING
C1083 a_1253_24711.t0 VSS 0.07249f $ **FLOATING
C1084 a_1253_24711.t1 VSS 0.11291f $ **FLOATING
C1085 a_1253_24711.n0 VSS 4.04919f $ **FLOATING
C1086 a_1253_24711.t9 VSS 0.07765f $ **FLOATING
C1087 a_1253_24711.n1 VSS 9.49143f $ **FLOATING
C1088 a_1253_24711.t8 VSS 0.07765f $ **FLOATING
C1089 a_1253_24711.n2 VSS 2.18947f $ **FLOATING
C1090 a_1253_24711.t7 VSS 0.07765f $ **FLOATING
C1091 a_1253_24711.n3 VSS 2.18947f $ **FLOATING
C1092 a_1253_24711.t6 VSS 0.07765f $ **FLOATING
C1093 a_1253_24711.n4 VSS 2.18947f $ **FLOATING
C1094 a_1253_24711.t5 VSS 0.07765f $ **FLOATING
C1095 a_1253_24711.n5 VSS 2.18947f $ **FLOATING
C1096 a_1253_24711.t4 VSS 0.07765f $ **FLOATING
C1097 a_1253_24711.n6 VSS 2.18947f $ **FLOATING
C1098 a_1253_24711.t3 VSS 0.07765f $ **FLOATING
C1099 a_1253_24711.n7 VSS 3.88956f $ **FLOATING
C1100 a_1253_24711.t2 VSS 0.19989f $ **FLOATING
C1101 a_3161_24936.t0 VSS 0.02692f $ **FLOATING
C1102 a_2033_24727.t0 VSS 0.07875f $ **FLOATING
C1103 a_2033_24727.t1 VSS 0.12176f $ **FLOATING
C1104 a_2033_24727.n0 VSS 10.9049f $ **FLOATING
C1105 a_2033_24727.t9 VSS 0.09988f $ **FLOATING
C1106 a_2033_24727.n1 VSS 18.603f $ **FLOATING
C1107 a_2033_24727.t8 VSS 0.09988f $ **FLOATING
C1108 a_2033_24727.n2 VSS 2.81625f $ **FLOATING
C1109 a_2033_24727.t7 VSS 0.09988f $ **FLOATING
C1110 a_2033_24727.n3 VSS 2.81625f $ **FLOATING
C1111 a_2033_24727.t6 VSS 0.09988f $ **FLOATING
C1112 a_2033_24727.n4 VSS 2.81625f $ **FLOATING
C1113 a_2033_24727.t5 VSS 0.09988f $ **FLOATING
C1114 a_2033_24727.n5 VSS 2.81625f $ **FLOATING
C1115 a_2033_24727.t4 VSS 0.09988f $ **FLOATING
C1116 a_2033_24727.n6 VSS 2.81625f $ **FLOATING
C1117 a_2033_24727.t3 VSS 0.09988f $ **FLOATING
C1118 a_2033_24727.n7 VSS 5.00302f $ **FLOATING
C1119 a_2033_24727.t2 VSS 0.25711f $ **FLOATING
C1120 a_653_546.t0 VSS 0.07075f $ **FLOATING
C1121 a_653_546.t1 VSS 0.10848f $ **FLOATING
C1122 a_653_546.n0 VSS 1.75265f $ **FLOATING
C1123 a_653_546.t9 VSS 0.07528f $ **FLOATING
C1124 a_653_546.n1 VSS 3.7977f $ **FLOATING
C1125 a_653_546.t8 VSS 0.07528f $ **FLOATING
C1126 a_653_546.n2 VSS 2.12249f $ **FLOATING
C1127 a_653_546.t7 VSS 0.07528f $ **FLOATING
C1128 a_653_546.n3 VSS 2.12249f $ **FLOATING
C1129 a_653_546.t6 VSS 0.07528f $ **FLOATING
C1130 a_653_546.n4 VSS 2.12249f $ **FLOATING
C1131 a_653_546.t5 VSS 0.07528f $ **FLOATING
C1132 a_653_546.n5 VSS 2.12249f $ **FLOATING
C1133 a_653_546.t4 VSS 0.07528f $ **FLOATING
C1134 a_653_546.n6 VSS 2.12249f $ **FLOATING
C1135 a_653_546.t3 VSS 0.07528f $ **FLOATING
C1136 a_653_546.n7 VSS 3.77057f $ **FLOATING
C1137 a_653_546.t2 VSS 0.19378f $ **FLOATING
C1138 a_48323_24960.t0 VSS 0.1507f $ **FLOATING
C1139 a_48323_24960.t2 VSS 0.13922f $ **FLOATING
C1140 a_48323_24960.t3 VSS 0.31758f $ **FLOATING
C1141 a_48323_24960.n0 VSS 0.44548f $ **FLOATING
C1142 a_48323_24960.n1 VSS 0.34891f $ **FLOATING
C1143 a_48323_24960.t1 VSS 0.14914f $ **FLOATING
C1144 a_4285_24701.t0 VSS 0.11409f $ **FLOATING
C1145 a_4285_24701.t2 VSS 0.38177f $ **FLOATING
C1146 a_4285_24701.n0 VSS 0.43224f $ **FLOATING
C1147 a_4285_24701.t1 VSS 0.16603f $ **FLOATING
C1148 a_48063_24737.t0 VSS 0.16499f $ **FLOATING
C1149 a_48063_24737.t3 VSS 0.18441f $ **FLOATING
C1150 a_48063_24737.n0 VSS 0.99148f $ **FLOATING
C1151 a_48063_24737.t2 VSS 0.1834f $ **FLOATING
C1152 a_48063_24737.t1 VSS 0.17088f $ **FLOATING
C1153 a_48063_24737.n1 VSS 1.07485f $ **FLOATING
C1154 a_48349_25055.t0 VSS 0.2841f $ **FLOATING
C1155 a_48349_25055.t4 VSS 0.26058f $ **FLOATING
C1156 a_48349_25055.t3 VSS 0.29074f $ **FLOATING
C1157 a_48349_25055.n0 VSS 0.52309f $ **FLOATING
C1158 a_48349_25055.t2 VSS 0.20186f $ **FLOATING
C1159 a_48349_25055.n1 VSS 0.53525f $ **FLOATING
C1160 a_48349_25055.t1 VSS 0.28647f $ **FLOATING
C1161 a_48349_25055.n2 VSS 0.86232f $ **FLOATING
C1162 a_48758_24994.t0 VSS 0.15912f $ **FLOATING
C1163 a_48758_24994.t3 VSS 0.61742f $ **FLOATING
C1164 a_48758_24994.n0 VSS 0.32698f $ **FLOATING
C1165 a_48758_24994.t1 VSS 0.23286f $ **FLOATING
C1166 a_48758_24994.n1 VSS 0.18519f $ **FLOATING
C1167 a_48758_24994.t2 VSS 0.25752f $ **FLOATING
C1168 a_48860_25081.t0 VSS 0.20317f $ **FLOATING
C1169 a_48860_25081.t3 VSS 0.28619f $ **FLOATING
C1170 a_48860_25081.n0 VSS 0.64249f $ **FLOATING
C1171 a_48860_25081.t1 VSS 0.30877f $ **FLOATING
C1172 a_48860_25081.t2 VSS 0.27609f $ **FLOATING
C1173 a_48860_25081.n1 VSS 0.34572f $ **FLOATING
C1174 a_4321_24727.t0 VSS 0.05188f $ **FLOATING
C1175 a_4321_24727.t1 VSS 0.07901f $ **FLOATING
C1176 a_4321_24727.n0 VSS 11.7907f $ **FLOATING
C1177 a_4321_24727.t9 VSS 0.06538f $ **FLOATING
C1178 a_4321_24727.n1 VSS 15.8817f $ **FLOATING
C1179 a_4321_24727.t8 VSS 0.06538f $ **FLOATING
C1180 a_4321_24727.n2 VSS 1.84343f $ **FLOATING
C1181 a_4321_24727.t7 VSS 0.06538f $ **FLOATING
C1182 a_4321_24727.n3 VSS 1.84343f $ **FLOATING
C1183 a_4321_24727.t6 VSS 0.06538f $ **FLOATING
C1184 a_4321_24727.n4 VSS 1.84343f $ **FLOATING
C1185 a_4321_24727.t5 VSS 0.06538f $ **FLOATING
C1186 a_4321_24727.n5 VSS 1.84343f $ **FLOATING
C1187 a_4321_24727.t4 VSS 0.06538f $ **FLOATING
C1188 a_4321_24727.n6 VSS 1.84343f $ **FLOATING
C1189 a_4321_24727.t3 VSS 0.06538f $ **FLOATING
C1190 a_4321_24727.n7 VSS 3.27481f $ **FLOATING
C1191 a_4321_24727.t2 VSS 0.1683f $ **FLOATING
C1192 a_49608_24814.t0 VSS 0.15664f $ **FLOATING
C1193 a_49608_24814.t2 VSS 0.79053f $ **FLOATING
C1194 a_49608_24814.n0 VSS 0.4444f $ **FLOATING
C1195 a_49608_24814.t1 VSS 0.23756f $ **FLOATING
C1196 a_49836_24954.t0 VSS 0.10965f $ **FLOATING
C1197 a_49836_24954.t2 VSS 0.21857f $ **FLOATING
C1198 a_49836_24954.t1 VSS 0.10886f $ **FLOATING
C1199 a_49836_24954.n0 VSS 0.47697f $ **FLOATING
C1200 a_50409_25015.t0 VSS 0.08708f $ **FLOATING
C1201 a_50409_25015.t2 VSS 0.28856f $ **FLOATING
C1202 a_50409_25015.t1 VSS 0.13892f $ **FLOATING
C1203 a_50409_25015.n0 VSS 0.32652f $ **FLOATING
C1204 a_48638_24750.t0 VSS 0.4602f $ **FLOATING
C1205 a_48638_24750.t1 VSS 0.39993f $ **FLOATING
C1206 a_49514_24814.t0 VSS 0.38543f $ **FLOATING
C1207 a_49514_24814.t1 VSS 0.38682f $ **FLOATING
C1208 a_51516_24785.t3 VSS 0.03341f $ **FLOATING
C1209 a_51516_24785.t1 VSS 0.0334f $ **FLOATING
C1210 a_51516_24785.n0 VSS 0.09782f $ **FLOATING
C1211 a_51516_24785.t4 VSS 0.03341f $ **FLOATING
C1212 a_51516_24785.t5 VSS 0.0334f $ **FLOATING
C1213 a_51516_24785.n1 VSS 0.13265f $ **FLOATING
C1214 a_51516_24785.t2 VSS 0.03341f $ **FLOATING
C1215 a_51516_24785.t0 VSS 0.0334f $ **FLOATING
C1216 a_51516_24785.n2 VSS 0.09782f $ **FLOATING
C1217 a_48063_24365.t0 VSS 0.16471f $ **FLOATING
C1218 a_48063_24365.t2 VSS 0.18409f $ **FLOATING
C1219 a_48063_24365.n0 VSS 0.9898f $ **FLOATING
C1220 a_48063_24365.t3 VSS 0.18309f $ **FLOATING
C1221 a_48063_24365.t1 VSS 0.17059f $ **FLOATING
C1222 a_48063_24365.n1 VSS 1.07303f $ **FLOATING
C1223 a_48323_23895.t0 VSS 0.14907f $ **FLOATING
C1224 a_48323_23895.t1 VSS 0.15062f $ **FLOATING
C1225 a_48323_23895.t2 VSS 0.13915f $ **FLOATING
C1226 a_48323_23895.t3 VSS 0.31742f $ **FLOATING
C1227 a_48323_23895.n0 VSS 0.44526f $ **FLOATING
C1228 a_48323_23895.n1 VSS 0.34873f $ **FLOATING
C1229 a_48349_23931.t0 VSS 0.28407f $ **FLOATING
C1230 a_48349_23931.t4 VSS 0.26056f $ **FLOATING
C1231 a_48349_23931.t3 VSS 0.29071f $ **FLOATING
C1232 a_48349_23931.n0 VSS 0.52304f $ **FLOATING
C1233 a_48349_23931.t2 VSS 0.20184f $ **FLOATING
C1234 a_48349_23931.n1 VSS 0.53544f $ **FLOATING
C1235 a_48349_23931.t1 VSS 0.28644f $ **FLOATING
C1236 a_48349_23931.n2 VSS 0.862f $ **FLOATING
C1237 a_48758_23938.t0 VSS 0.15886f $ **FLOATING
C1238 a_48758_23938.t3 VSS 0.61641f $ **FLOATING
C1239 a_48758_23938.n0 VSS 0.32644f $ **FLOATING
C1240 a_48758_23938.t1 VSS 0.23247f $ **FLOATING
C1241 a_48758_23938.n1 VSS 0.18489f $ **FLOATING
C1242 a_48758_23938.t2 VSS 0.2571f $ **FLOATING
C1243 a_48638_24352.t0 VSS 0.46019f $ **FLOATING
C1244 a_48638_24352.t1 VSS 0.39992f $ **FLOATING
C1245 a_48860_23938.t0 VSS 0.20316f $ **FLOATING
C1246 a_48860_23938.t3 VSS 0.28618f $ **FLOATING
C1247 a_48860_23938.n0 VSS 0.64248f $ **FLOATING
C1248 a_48860_23938.t1 VSS 0.30876f $ **FLOATING
C1249 a_48860_23938.t2 VSS 0.27609f $ **FLOATING
C1250 a_48860_23938.n1 VSS 0.34572f $ **FLOATING
C1251 a_49836_24166.t0 VSS 0.10929f $ **FLOATING
C1252 a_49836_24166.t2 VSS 0.21786f $ **FLOATING
C1253 a_49836_24166.t1 VSS 0.10851f $ **FLOATING
C1254 a_49836_24166.n0 VSS 0.47542f $ **FLOATING
C1255 a_49608_24288.t0 VSS 0.23706f $ **FLOATING
C1256 a_49608_24288.t1 VSS 0.15631f $ **FLOATING
C1257 a_49608_24288.t2 VSS 0.78886f $ **FLOATING
C1258 a_49608_24288.n0 VSS 0.44347f $ **FLOATING
C1259 a_50409_23971.t0 VSS 0.08666f $ **FLOATING
C1260 a_50409_23971.t2 VSS 0.28719f $ **FLOATING
C1261 a_50409_23971.t1 VSS 0.13825f $ **FLOATING
C1262 a_50409_23971.n0 VSS 0.32496f $ **FLOATING
C1263 a_49514_24288.t0 VSS 0.38543f $ **FLOATING
C1264 a_49514_24288.t1 VSS 0.38682f $ **FLOATING
C1265 a_50205_23947.t0 VSS 0.05861f $ **FLOATING
C1266 a_50205_23947.n0 VSS 0.6202f $ **FLOATING
C1267 a_50205_23947.t2 VSS 0.43556f $ **FLOATING
C1268 a_50205_23947.t1 VSS 0.09573f $ **FLOATING
C1269 a_50626_23927.t0 VSS 0.05672f $ **FLOATING
C1270 a_50626_23927.t1 VSS 0.09243f $ **FLOATING
C1271 a_50626_23927.n0 VSS 0.55686f $ **FLOATING
C1272 a_50626_23927.t2 VSS 0.24706f $ **FLOATING
C1273 a_51517_23976.t3 VSS 0.05168f $ **FLOATING
C1274 a_51517_23976.t1 VSS 0.05169f $ **FLOATING
C1275 a_51517_23976.n0 VSS 0.09771f $ **FLOATING
C1276 a_51517_23976.t5 VSS 0.05168f $ **FLOATING
C1277 a_51517_23976.t4 VSS 0.05169f $ **FLOATING
C1278 a_51517_23976.n1 VSS 0.12572f $ **FLOATING
C1279 a_51517_23976.t2 VSS 0.05168f $ **FLOATING
C1280 a_51517_23976.t0 VSS 0.05169f $ **FLOATING
C1281 a_51517_23976.n2 VSS 0.09771f $ **FLOATING
C1282 a_51453_23453.t1 VSS 0.11166f $ **FLOATING
C1283 a_51453_23453.t4 VSS 0.09725f $ **FLOATING
C1284 a_51453_23453.n0 VSS 0.3336f $ **FLOATING
C1285 a_51453_23453.t3 VSS 0.09954f $ **FLOATING
C1286 a_51453_23453.n1 VSS 0.38331f $ **FLOATING
C1287 a_51453_23453.t5 VSS 0.12131f $ **FLOATING
C1288 a_51453_23453.t6 VSS 0.12131f $ **FLOATING
C1289 a_51453_23453.n2 VSS 0.39799f $ **FLOATING
C1290 a_51453_23453.t2 VSS 0.09725f $ **FLOATING
C1291 a_51453_23453.n3 VSS 0.3336f $ **FLOATING
C1292 a_51453_23453.t0 VSS 0.11166f $ **FLOATING
C1293 a_3877_20494.t0 VSS 0.0698f $ **FLOATING
C1294 a_3877_20494.n0 VSS 0.73499f $ **FLOATING
C1295 a_3877_20494.t2 VSS 0.50603f $ **FLOATING
C1296 a_3877_20494.t1 VSS 0.11401f $ **FLOATING
C1297 a_10397_20494.t0 VSS 0.06981f $ **FLOATING
C1298 a_10397_20494.n0 VSS 0.735f $ **FLOATING
C1299 a_10397_20494.t2 VSS 0.50604f $ **FLOATING
C1300 a_10397_20494.t1 VSS 0.11401f $ **FLOATING
C1301 a_4298_20514.t0 VSS 0.06221f $ **FLOATING
C1302 a_4298_20514.t1 VSS 0.10138f $ **FLOATING
C1303 a_4298_20514.n0 VSS 0.63901f $ **FLOATING
C1304 a_4298_20514.t2 VSS 0.27148f $ **FLOATING
C1305 a_16917_20494.t0 VSS 0.0697f $ **FLOATING
C1306 a_16917_20494.n0 VSS 0.73393f $ **FLOATING
C1307 a_16917_20494.t2 VSS 0.5053f $ **FLOATING
C1308 a_16917_20494.t1 VSS 0.11385f $ **FLOATING
C1309 a_10818_20514.t0 VSS 0.06221f $ **FLOATING
C1310 a_10818_20514.t1 VSS 0.10138f $ **FLOATING
C1311 a_10818_20514.n0 VSS 0.63901f $ **FLOATING
C1312 a_10818_20514.t2 VSS 0.27148f $ **FLOATING
C1313 a_23437_20494.t0 VSS 0.06971f $ **FLOATING
C1314 a_23437_20494.n0 VSS 0.73395f $ **FLOATING
C1315 a_23437_20494.t2 VSS 0.50532f $ **FLOATING
C1316 a_23437_20494.t1 VSS 0.11385f $ **FLOATING
C1317 a_17338_20514.t0 VSS 0.06219f $ **FLOATING
C1318 a_17338_20514.t1 VSS 0.10133f $ **FLOATING
C1319 a_17338_20514.n0 VSS 0.63874f $ **FLOATING
C1320 a_17338_20514.t2 VSS 0.27137f $ **FLOATING
C1321 a_29957_20494.t0 VSS 0.0697f $ **FLOATING
C1322 a_29957_20494.n0 VSS 0.73386f $ **FLOATING
C1323 a_29957_20494.t2 VSS 0.50525f $ **FLOATING
C1324 a_29957_20494.t1 VSS 0.11383f $ **FLOATING
C1325 a_23858_20514.t0 VSS 0.06219f $ **FLOATING
C1326 a_23858_20514.t1 VSS 0.10133f $ **FLOATING
C1327 a_23858_20514.n0 VSS 0.63874f $ **FLOATING
C1328 a_23858_20514.t2 VSS 0.27137f $ **FLOATING
C1329 a_36477_20494.t0 VSS 0.0697f $ **FLOATING
C1330 a_36477_20494.n0 VSS 0.73388f $ **FLOATING
C1331 a_36477_20494.t2 VSS 0.50526f $ **FLOATING
C1332 a_36477_20494.t1 VSS 0.11384f $ **FLOATING
C1333 a_30378_20514.t0 VSS 0.06219f $ **FLOATING
C1334 a_30378_20514.t1 VSS 0.10133f $ **FLOATING
C1335 a_30378_20514.n0 VSS 0.63874f $ **FLOATING
C1336 a_30378_20514.t2 VSS 0.27137f $ **FLOATING
C1337 a_42997_20494.t0 VSS 0.06974f $ **FLOATING
C1338 a_42997_20494.n0 VSS 0.73433f $ **FLOATING
C1339 a_42997_20494.t2 VSS 0.50558f $ **FLOATING
C1340 a_42997_20494.t1 VSS 0.11391f $ **FLOATING
C1341 a_36898_20514.t0 VSS 0.06219f $ **FLOATING
C1342 a_36898_20514.t1 VSS 0.10133f $ **FLOATING
C1343 a_36898_20514.n0 VSS 0.63874f $ **FLOATING
C1344 a_36898_20514.t2 VSS 0.27137f $ **FLOATING
C1345 a_43418_20514.t0 VSS 0.06219f $ **FLOATING
C1346 a_43418_20514.t1 VSS 0.10134f $ **FLOATING
C1347 a_43418_20514.n0 VSS 0.63881f $ **FLOATING
C1348 a_43418_20514.t2 VSS 0.2714f $ **FLOATING
C1349 a_5003_20550.t3 VSS 0.14892f $ **FLOATING
C1350 a_5003_20550.t5 VSS 0.13043f $ **FLOATING
C1351 a_5003_20550.n0 VSS 0.31976f $ **FLOATING
C1352 a_5003_20550.t9 VSS 0.10111f $ **FLOATING
C1353 a_5003_20550.n1 VSS 0.38933f $ **FLOATING
C1354 a_5003_20550.t7 VSS 0.09878f $ **FLOATING
C1355 a_5003_20550.n2 VSS 0.33885f $ **FLOATING
C1356 a_5003_20550.t0 VSS 0.11342f $ **FLOATING
C1357 a_5003_20550.t8 VSS 0.09878f $ **FLOATING
C1358 a_5003_20550.n3 VSS 0.33885f $ **FLOATING
C1359 a_5003_20550.t1 VSS 0.11342f $ **FLOATING
C1360 a_5003_20550.t2 VSS 0.14892f $ **FLOATING
C1361 a_5003_20550.t4 VSS 0.13119f $ **FLOATING
C1362 a_5003_20550.n4 VSS 0.35455f $ **FLOATING
C1363 a_5003_20550.t6 VSS 0.13119f $ **FLOATING
C1364 a_5003_20550.n5 VSS 0.35455f $ **FLOATING
C1365 a_11523_20550.t3 VSS 0.14892f $ **FLOATING
C1366 a_11523_20550.t8 VSS 0.13043f $ **FLOATING
C1367 a_11523_20550.n0 VSS 0.31976f $ **FLOATING
C1368 a_11523_20550.t5 VSS 0.10111f $ **FLOATING
C1369 a_11523_20550.n1 VSS 0.38933f $ **FLOATING
C1370 a_11523_20550.t4 VSS 0.09878f $ **FLOATING
C1371 a_11523_20550.n2 VSS 0.33885f $ **FLOATING
C1372 a_11523_20550.t0 VSS 0.11342f $ **FLOATING
C1373 a_11523_20550.t6 VSS 0.09878f $ **FLOATING
C1374 a_11523_20550.n3 VSS 0.33885f $ **FLOATING
C1375 a_11523_20550.t1 VSS 0.11342f $ **FLOATING
C1376 a_11523_20550.t2 VSS 0.14892f $ **FLOATING
C1377 a_11523_20550.t7 VSS 0.13119f $ **FLOATING
C1378 a_11523_20550.n4 VSS 0.35455f $ **FLOATING
C1379 a_11523_20550.t9 VSS 0.13119f $ **FLOATING
C1380 a_11523_20550.n5 VSS 0.35455f $ **FLOATING
C1381 a_18043_20550.t3 VSS 0.14893f $ **FLOATING
C1382 a_18043_20550.t5 VSS 0.13044f $ **FLOATING
C1383 a_18043_20550.n0 VSS 0.31978f $ **FLOATING
C1384 a_18043_20550.t9 VSS 0.10112f $ **FLOATING
C1385 a_18043_20550.n1 VSS 0.38937f $ **FLOATING
C1386 a_18043_20550.t7 VSS 0.09879f $ **FLOATING
C1387 a_18043_20550.n2 VSS 0.33888f $ **FLOATING
C1388 a_18043_20550.t0 VSS 0.11343f $ **FLOATING
C1389 a_18043_20550.t8 VSS 0.09879f $ **FLOATING
C1390 a_18043_20550.n3 VSS 0.33888f $ **FLOATING
C1391 a_18043_20550.t1 VSS 0.11343f $ **FLOATING
C1392 a_18043_20550.t2 VSS 0.14893f $ **FLOATING
C1393 a_18043_20550.t4 VSS 0.1312f $ **FLOATING
C1394 a_18043_20550.n4 VSS 0.35458f $ **FLOATING
C1395 a_18043_20550.t6 VSS 0.1312f $ **FLOATING
C1396 a_18043_20550.n5 VSS 0.35458f $ **FLOATING
C1397 a_24563_20550.t3 VSS 0.14894f $ **FLOATING
C1398 a_24563_20550.t7 VSS 0.13044f $ **FLOATING
C1399 a_24563_20550.n0 VSS 0.31979f $ **FLOATING
C1400 a_24563_20550.t9 VSS 0.10112f $ **FLOATING
C1401 a_24563_20550.n1 VSS 0.38938f $ **FLOATING
C1402 a_24563_20550.t4 VSS 0.09879f $ **FLOATING
C1403 a_24563_20550.n2 VSS 0.33889f $ **FLOATING
C1404 a_24563_20550.t0 VSS 0.11343f $ **FLOATING
C1405 a_24563_20550.t5 VSS 0.09879f $ **FLOATING
C1406 a_24563_20550.n3 VSS 0.33889f $ **FLOATING
C1407 a_24563_20550.t1 VSS 0.11343f $ **FLOATING
C1408 a_24563_20550.t2 VSS 0.14894f $ **FLOATING
C1409 a_24563_20550.t6 VSS 0.1312f $ **FLOATING
C1410 a_24563_20550.n4 VSS 0.35459f $ **FLOATING
C1411 a_24563_20550.t8 VSS 0.1312f $ **FLOATING
C1412 a_24563_20550.n5 VSS 0.35459f $ **FLOATING
C1413 a_31083_20550.t9 VSS 0.13119f $ **FLOATING
C1414 a_31083_20550.t8 VSS 0.13043f $ **FLOATING
C1415 a_31083_20550.n0 VSS 0.31977f $ **FLOATING
C1416 a_31083_20550.t5 VSS 0.10111f $ **FLOATING
C1417 a_31083_20550.n1 VSS 0.38936f $ **FLOATING
C1418 a_31083_20550.t4 VSS 0.09879f $ **FLOATING
C1419 a_31083_20550.n2 VSS 0.33886f $ **FLOATING
C1420 a_31083_20550.t0 VSS 0.11342f $ **FLOATING
C1421 a_31083_20550.t6 VSS 0.09879f $ **FLOATING
C1422 a_31083_20550.n3 VSS 0.33886f $ **FLOATING
C1423 a_31083_20550.t1 VSS 0.11342f $ **FLOATING
C1424 a_31083_20550.t2 VSS 0.14893f $ **FLOATING
C1425 a_31083_20550.t7 VSS 0.13119f $ **FLOATING
C1426 a_31083_20550.n4 VSS 0.35456f $ **FLOATING
C1427 a_31083_20550.t3 VSS 0.14893f $ **FLOATING
C1428 a_31083_20550.n5 VSS 0.35456f $ **FLOATING
C1429 a_37603_20550.t3 VSS 0.14893f $ **FLOATING
C1430 a_37603_20550.t5 VSS 0.13044f $ **FLOATING
C1431 a_37603_20550.n0 VSS 0.31978f $ **FLOATING
C1432 a_37603_20550.t9 VSS 0.10111f $ **FLOATING
C1433 a_37603_20550.n1 VSS 0.38936f $ **FLOATING
C1434 a_37603_20550.t7 VSS 0.09879f $ **FLOATING
C1435 a_37603_20550.n2 VSS 0.33887f $ **FLOATING
C1436 a_37603_20550.t0 VSS 0.11343f $ **FLOATING
C1437 a_37603_20550.t8 VSS 0.09879f $ **FLOATING
C1438 a_37603_20550.n3 VSS 0.33887f $ **FLOATING
C1439 a_37603_20550.t1 VSS 0.11343f $ **FLOATING
C1440 a_37603_20550.t2 VSS 0.14893f $ **FLOATING
C1441 a_37603_20550.t4 VSS 0.1312f $ **FLOATING
C1442 a_37603_20550.n4 VSS 0.35457f $ **FLOATING
C1443 a_37603_20550.t6 VSS 0.1312f $ **FLOATING
C1444 a_37603_20550.n5 VSS 0.35457f $ **FLOATING
C1445 a_44123_20550.t9 VSS 0.13068f $ **FLOATING
C1446 a_44123_20550.t8 VSS 0.12992f $ **FLOATING
C1447 a_44123_20550.n0 VSS 0.31851f $ **FLOATING
C1448 a_44123_20550.t5 VSS 0.10071f $ **FLOATING
C1449 a_44123_20550.n1 VSS 0.38782f $ **FLOATING
C1450 a_44123_20550.t4 VSS 0.0984f $ **FLOATING
C1451 a_44123_20550.n2 VSS 0.33753f $ **FLOATING
C1452 a_44123_20550.t0 VSS 0.11298f $ **FLOATING
C1453 a_44123_20550.t6 VSS 0.0984f $ **FLOATING
C1454 a_44123_20550.n3 VSS 0.33753f $ **FLOATING
C1455 a_44123_20550.t1 VSS 0.11298f $ **FLOATING
C1456 a_44123_20550.t2 VSS 0.14834f $ **FLOATING
C1457 a_44123_20550.t7 VSS 0.13068f $ **FLOATING
C1458 a_44123_20550.n4 VSS 0.35317f $ **FLOATING
C1459 a_44123_20550.t3 VSS 0.14834f $ **FLOATING
C1460 a_44123_20550.n5 VSS 0.35317f $ **FLOATING
C1461 a_585_20594.t0 VSS 0.06879f $ **FLOATING
C1462 a_585_20594.t2 VSS 0.23098f $ **FLOATING
C1463 a_585_20594.t1 VSS 0.10786f $ **FLOATING
C1464 a_585_20594.n0 VSS 0.28711f $ **FLOATING
C1465 a_679_20594.t0 VSS 0.03523f $ **FLOATING
C1466 a_890_20198.t0 VSS 0.12968f $ **FLOATING
C1467 a_890_20198.t1 VSS 0.19985f $ **FLOATING
C1468 a_890_20198.n0 VSS 0.56042f $ **FLOATING
C1469 a_890_20198.t2 VSS 0.27368f $ **FLOATING
C1470 a_n2044_4040.t0 VSS 0.09218f $ **FLOATING
C1471 a_n2044_4040.n0 VSS 7.48642f $ **FLOATING
C1472 a_n2044_4040.t2 VSS 1.67076f $ **FLOATING
C1473 a_n2044_4040.n1 VSS 13.3636f $ **FLOATING
C1474 a_n2044_4040.t10 VSS 0.29504f $ **FLOATING
C1475 a_n2044_4040.n2 VSS 4.47485f $ **FLOATING
C1476 a_n2044_4040.t3 VSS 0.31739f $ **FLOATING
C1477 a_n2044_4040.n3 VSS 3.97226f $ **FLOATING
C1478 a_n2044_4040.t11 VSS 0.29504f $ **FLOATING
C1479 a_n2044_4040.n4 VSS 4.47485f $ **FLOATING
C1480 a_n2044_4040.t4 VSS 0.31739f $ **FLOATING
C1481 a_n2044_4040.n5 VSS 3.97226f $ **FLOATING
C1482 a_n2044_4040.t12 VSS 0.29504f $ **FLOATING
C1483 a_n2044_4040.n6 VSS 4.47485f $ **FLOATING
C1484 a_n2044_4040.t5 VSS 0.31739f $ **FLOATING
C1485 a_n2044_4040.n7 VSS 3.97226f $ **FLOATING
C1486 a_n2044_4040.t13 VSS 0.29504f $ **FLOATING
C1487 a_n2044_4040.n8 VSS 4.47485f $ **FLOATING
C1488 a_n2044_4040.t6 VSS 0.31739f $ **FLOATING
C1489 a_n2044_4040.n9 VSS 3.97226f $ **FLOATING
C1490 a_n2044_4040.t14 VSS 0.29504f $ **FLOATING
C1491 a_n2044_4040.n10 VSS 4.47485f $ **FLOATING
C1492 a_n2044_4040.t7 VSS 0.31739f $ **FLOATING
C1493 a_n2044_4040.n11 VSS 3.97226f $ **FLOATING
C1494 a_n2044_4040.t15 VSS 0.29504f $ **FLOATING
C1495 a_n2044_4040.n12 VSS 4.47485f $ **FLOATING
C1496 a_n2044_4040.t8 VSS 0.31739f $ **FLOATING
C1497 a_n2044_4040.n13 VSS 3.97226f $ **FLOATING
C1498 a_n2044_4040.t16 VSS 0.29504f $ **FLOATING
C1499 a_n2044_4040.n14 VSS 18.5982f $ **FLOATING
C1500 a_n2044_4040.t9 VSS 0.31739f $ **FLOATING
C1501 a_n2044_4040.t1 VSS 0.141f $ **FLOATING
C1502 a_1279_20514.t1 VSS 0.16159f $ **FLOATING
C1503 a_1279_20514.t3 VSS 0.18513f $ **FLOATING
C1504 a_1279_20514.t2 VSS 0.25357f $ **FLOATING
C1505 a_1279_20514.t0 VSS 0.25273f $ **FLOATING
C1506 a_1279_20514.n0 VSS 0.39401f $ **FLOATING
C1507 a_1279_20514.n1 VSS 0.36186f $ **FLOATING
C1508 a_1995_20439.t0 VSS 0.14823f $ **FLOATING
C1509 a_1995_20439.t2 VSS 0.13694f $ **FLOATING
C1510 a_1995_20439.t3 VSS 0.31238f $ **FLOATING
C1511 a_1995_20439.n0 VSS 0.43819f $ **FLOATING
C1512 a_1995_20439.n1 VSS 0.34319f $ **FLOATING
C1513 a_1995_20439.t1 VSS 0.1467f $ **FLOATING
C1514 a_1735_20216.t0 VSS 0.16417f $ **FLOATING
C1515 a_1735_20216.t2 VSS 0.18348f $ **FLOATING
C1516 a_1735_20216.n0 VSS 0.98651f $ **FLOATING
C1517 a_1735_20216.t1 VSS 0.18248f $ **FLOATING
C1518 a_1735_20216.t3 VSS 0.17003f $ **FLOATING
C1519 a_1735_20216.n1 VSS 1.06946f $ **FLOATING
C1520 a_2021_20534.t0 VSS 0.26938f $ **FLOATING
C1521 a_2021_20534.t4 VSS 0.24709f $ **FLOATING
C1522 a_2021_20534.t2 VSS 0.27568f $ **FLOATING
C1523 a_2021_20534.n0 VSS 0.49601f $ **FLOATING
C1524 a_2021_20534.t1 VSS 0.1914f $ **FLOATING
C1525 a_2021_20534.n1 VSS 0.50753f $ **FLOATING
C1526 a_2021_20534.t3 VSS 0.27164f $ **FLOATING
C1527 a_2021_20534.n2 VSS 0.81767f $ **FLOATING
C1528 a_2430_20473.t0 VSS 0.15491f $ **FLOATING
C1529 a_2430_20473.t3 VSS 0.60111f $ **FLOATING
C1530 a_2430_20473.n0 VSS 0.31834f $ **FLOATING
C1531 a_2430_20473.t1 VSS 0.2267f $ **FLOATING
C1532 a_2430_20473.n1 VSS 0.1803f $ **FLOATING
C1533 a_2430_20473.t2 VSS 0.25072f $ **FLOATING
C1534 a_2532_20560.t0 VSS 0.20064f $ **FLOATING
C1535 a_2532_20560.t3 VSS 0.28263f $ **FLOATING
C1536 a_2532_20560.n0 VSS 0.63451f $ **FLOATING
C1537 a_2532_20560.t1 VSS 0.30493f $ **FLOATING
C1538 a_2532_20560.t2 VSS 0.27266f $ **FLOATING
C1539 a_2532_20560.n1 VSS 0.34142f $ **FLOATING
C1540 a_1178_20217.t1 VSS 0.09033f $ **FLOATING
C1541 a_1178_20217.t0 VSS 0.09271f $ **FLOATING
C1542 a_1178_20217.t2 VSS 0.08433f $ **FLOATING
C1543 a_1178_20217.n0 VSS 0.26171f $ **FLOATING
C1544 a_3280_20293.t0 VSS 0.15513f $ **FLOATING
C1545 a_3280_20293.t2 VSS 0.78293f $ **FLOATING
C1546 a_3280_20293.n0 VSS 0.44013f $ **FLOATING
C1547 a_3280_20293.t1 VSS 0.23527f $ **FLOATING
C1548 a_3508_20433.t0 VSS 0.10861f $ **FLOATING
C1549 a_3508_20433.t1 VSS 0.1094f $ **FLOATING
C1550 a_3508_20433.n0 VSS 0.47589f $ **FLOATING
C1551 a_3508_20433.t2 VSS 0.21808f $ **FLOATING
C1552 a_4081_20494.t0 VSS 0.08718f $ **FLOATING
C1553 a_4081_20494.t2 VSS 0.28889f $ **FLOATING
C1554 a_4081_20494.t1 VSS 0.13908f $ **FLOATING
C1555 a_4081_20494.n0 VSS 0.3269f $ **FLOATING
C1556 a_7105_20594.t0 VSS 0.06883f $ **FLOATING
C1557 a_7105_20594.t2 VSS 0.23113f $ **FLOATING
C1558 a_7105_20594.t1 VSS 0.10793f $ **FLOATING
C1559 a_7105_20594.n0 VSS 0.28729f $ **FLOATING
C1560 a_2310_20229.t0 VSS 0.4464f $ **FLOATING
C1561 a_2310_20229.t1 VSS 0.38794f $ **FLOATING
C1562 a_3186_20293.t0 VSS 0.37297f $ **FLOATING
C1563 a_3186_20293.t1 VSS 0.37163f $ **FLOATING
C1564 a_5169_20290.t3 VSS 0.07497f $ **FLOATING
C1565 a_5169_20290.t4 VSS 0.07497f $ **FLOATING
C1566 a_5169_20290.n0 VSS 0.12649f $ **FLOATING
C1567 a_5169_20290.t2 VSS 0.07497f $ **FLOATING
C1568 a_5169_20290.t5 VSS 0.07497f $ **FLOATING
C1569 a_5169_20290.n1 VSS 0.16231f $ **FLOATING
C1570 a_5169_20290.t1 VSS 0.07497f $ **FLOATING
C1571 a_5169_20290.t7 VSS 0.07497f $ **FLOATING
C1572 a_5169_20290.n2 VSS 0.16231f $ **FLOATING
C1573 a_5169_20290.t0 VSS 0.07497f $ **FLOATING
C1574 a_5169_20290.t6 VSS 0.07497f $ **FLOATING
C1575 a_5169_20290.n3 VSS 0.12648f $ **FLOATING
C1576 a_7199_20594.t0 VSS 0.03526f $ **FLOATING
C1577 a_7410_20198.t0 VSS 0.12968f $ **FLOATING
C1578 a_7410_20198.t1 VSS 0.19984f $ **FLOATING
C1579 a_7410_20198.n0 VSS 0.5604f $ **FLOATING
C1580 a_7410_20198.t2 VSS 0.27367f $ **FLOATING
C1581 a_7799_20514.t1 VSS 0.16141f $ **FLOATING
C1582 a_7799_20514.t3 VSS 0.18492f $ **FLOATING
C1583 a_7799_20514.t2 VSS 0.25329f $ **FLOATING
C1584 a_7799_20514.t0 VSS 0.25245f $ **FLOATING
C1585 a_7799_20514.n0 VSS 0.39356f $ **FLOATING
C1586 a_7799_20514.n1 VSS 0.36145f $ **FLOATING
C1587 a_8515_20439.t0 VSS 0.14669f $ **FLOATING
C1588 a_8515_20439.t1 VSS 0.14822f $ **FLOATING
C1589 a_8515_20439.t2 VSS 0.13693f $ **FLOATING
C1590 a_8515_20439.t3 VSS 0.31236f $ **FLOATING
C1591 a_8515_20439.n0 VSS 0.43816f $ **FLOATING
C1592 a_8515_20439.n1 VSS 0.34317f $ **FLOATING
C1593 a_8255_20216.t0 VSS 0.17001f $ **FLOATING
C1594 a_8255_20216.t1 VSS 0.16415f $ **FLOATING
C1595 a_8255_20216.n0 VSS 1.06938f $ **FLOATING
C1596 a_8255_20216.t3 VSS 0.18347f $ **FLOATING
C1597 a_8255_20216.n1 VSS 0.98644f $ **FLOATING
C1598 a_8255_20216.t2 VSS 0.18246f $ **FLOATING
C1599 a_8541_20534.t1 VSS 0.26937f $ **FLOATING
C1600 a_8541_20534.t4 VSS 0.24708f $ **FLOATING
C1601 a_8541_20534.t3 VSS 0.27567f $ **FLOATING
C1602 a_8541_20534.n0 VSS 0.49598f $ **FLOATING
C1603 a_8541_20534.t2 VSS 0.19139f $ **FLOATING
C1604 a_8541_20534.n1 VSS 0.5075f $ **FLOATING
C1605 a_8541_20534.t0 VSS 0.27162f $ **FLOATING
C1606 a_8541_20534.n2 VSS 0.81762f $ **FLOATING
C1607 a_8950_20473.t0 VSS 0.15491f $ **FLOATING
C1608 a_8950_20473.t3 VSS 0.60109f $ **FLOATING
C1609 a_8950_20473.n0 VSS 0.31833f $ **FLOATING
C1610 a_8950_20473.t1 VSS 0.2267f $ **FLOATING
C1611 a_8950_20473.n1 VSS 0.1803f $ **FLOATING
C1612 a_8950_20473.t2 VSS 0.25071f $ **FLOATING
C1613 a_9052_20560.t0 VSS 0.20064f $ **FLOATING
C1614 a_9052_20560.t3 VSS 0.28263f $ **FLOATING
C1615 a_9052_20560.n0 VSS 0.63449f $ **FLOATING
C1616 a_9052_20560.t1 VSS 0.30493f $ **FLOATING
C1617 a_9052_20560.t2 VSS 0.27265f $ **FLOATING
C1618 a_9052_20560.n1 VSS 0.34142f $ **FLOATING
C1619 a_7698_20217.t1 VSS 0.09017f $ **FLOATING
C1620 a_7698_20217.t0 VSS 0.09255f $ **FLOATING
C1621 a_7698_20217.t2 VSS 0.08419f $ **FLOATING
C1622 a_7698_20217.n0 VSS 0.26127f $ **FLOATING
C1623 a_9800_20293.t0 VSS 0.15513f $ **FLOATING
C1624 a_9800_20293.t2 VSS 0.78293f $ **FLOATING
C1625 a_9800_20293.n0 VSS 0.44013f $ **FLOATING
C1626 a_9800_20293.t1 VSS 0.23527f $ **FLOATING
C1627 a_10028_20433.t0 VSS 0.1094f $ **FLOATING
C1628 a_10028_20433.t2 VSS 0.21808f $ **FLOATING
C1629 a_10028_20433.t1 VSS 0.10861f $ **FLOATING
C1630 a_10028_20433.n0 VSS 0.47589f $ **FLOATING
C1631 a_10601_20494.t0 VSS 0.08718f $ **FLOATING
C1632 a_10601_20494.t2 VSS 0.28889f $ **FLOATING
C1633 a_10601_20494.t1 VSS 0.13908f $ **FLOATING
C1634 a_10601_20494.n0 VSS 0.3269f $ **FLOATING
C1635 a_13625_20594.t0 VSS 0.06893f $ **FLOATING
C1636 a_13625_20594.t2 VSS 0.23145f $ **FLOATING
C1637 a_13625_20594.t1 VSS 0.10808f $ **FLOATING
C1638 a_13625_20594.n0 VSS 0.28769f $ **FLOATING
C1639 a_8830_20229.t0 VSS 0.44638f $ **FLOATING
C1640 a_8830_20229.t1 VSS 0.38792f $ **FLOATING
C1641 a_9706_20293.t0 VSS 0.37163f $ **FLOATING
C1642 a_9706_20293.t1 VSS 0.37297f $ **FLOATING
C1643 a_11689_20290.t3 VSS 0.07497f $ **FLOATING
C1644 a_11689_20290.t6 VSS 0.07497f $ **FLOATING
C1645 a_11689_20290.n0 VSS 0.12649f $ **FLOATING
C1646 a_11689_20290.t2 VSS 0.07497f $ **FLOATING
C1647 a_11689_20290.t7 VSS 0.07497f $ **FLOATING
C1648 a_11689_20290.n1 VSS 0.16231f $ **FLOATING
C1649 a_11689_20290.t1 VSS 0.07497f $ **FLOATING
C1650 a_11689_20290.t5 VSS 0.07497f $ **FLOATING
C1651 a_11689_20290.n2 VSS 0.16231f $ **FLOATING
C1652 a_11689_20290.t0 VSS 0.07497f $ **FLOATING
C1653 a_11689_20290.t4 VSS 0.07497f $ **FLOATING
C1654 a_11689_20290.n3 VSS 0.12649f $ **FLOATING
C1655 a_13719_20594.t0 VSS 0.03529f $ **FLOATING
C1656 a_13930_20198.t0 VSS 0.12985f $ **FLOATING
C1657 a_13930_20198.t1 VSS 0.2001f $ **FLOATING
C1658 a_13930_20198.n0 VSS 0.56113f $ **FLOATING
C1659 a_13930_20198.t2 VSS 0.27403f $ **FLOATING
C1660 a_14319_20514.t1 VSS 0.16123f $ **FLOATING
C1661 a_14319_20514.t3 VSS 0.18471f $ **FLOATING
C1662 a_14319_20514.t2 VSS 0.253f $ **FLOATING
C1663 a_14319_20514.t0 VSS 0.25216f $ **FLOATING
C1664 a_14319_20514.n0 VSS 0.39312f $ **FLOATING
C1665 a_14319_20514.n1 VSS 0.36104f $ **FLOATING
C1666 a_15035_20439.t0 VSS 0.14668f $ **FLOATING
C1667 a_15035_20439.t1 VSS 0.14821f $ **FLOATING
C1668 a_15035_20439.t2 VSS 0.13693f $ **FLOATING
C1669 a_15035_20439.t3 VSS 0.31234f $ **FLOATING
C1670 a_15035_20439.n0 VSS 0.43814f $ **FLOATING
C1671 a_15035_20439.n1 VSS 0.34315f $ **FLOATING
C1672 a_14775_20216.t0 VSS 0.16414f $ **FLOATING
C1673 a_14775_20216.t2 VSS 0.18345f $ **FLOATING
C1674 a_14775_20216.n0 VSS 0.98637f $ **FLOATING
C1675 a_14775_20216.t3 VSS 0.18245f $ **FLOATING
C1676 a_14775_20216.t1 VSS 0.17f $ **FLOATING
C1677 a_14775_20216.n1 VSS 1.0693f $ **FLOATING
C1678 a_15061_20534.t0 VSS 0.26935f $ **FLOATING
C1679 a_15061_20534.t4 VSS 0.24706f $ **FLOATING
C1680 a_15061_20534.t3 VSS 0.27565f $ **FLOATING
C1681 a_15061_20534.n0 VSS 0.49595f $ **FLOATING
C1682 a_15061_20534.t2 VSS 0.19138f $ **FLOATING
C1683 a_15061_20534.n1 VSS 0.50747f $ **FLOATING
C1684 a_15061_20534.t1 VSS 0.27161f $ **FLOATING
C1685 a_15061_20534.n2 VSS 0.81757f $ **FLOATING
C1686 a_15470_20473.t0 VSS 0.1549f $ **FLOATING
C1687 a_15470_20473.t3 VSS 0.60104f $ **FLOATING
C1688 a_15470_20473.n0 VSS 0.3183f $ **FLOATING
C1689 a_15470_20473.t1 VSS 0.22668f $ **FLOATING
C1690 a_15470_20473.n1 VSS 0.18028f $ **FLOATING
C1691 a_15470_20473.t2 VSS 0.25069f $ **FLOATING
C1692 a_15572_20560.t0 VSS 0.20063f $ **FLOATING
C1693 a_15572_20560.t3 VSS 0.28262f $ **FLOATING
C1694 a_15572_20560.n0 VSS 0.63448f $ **FLOATING
C1695 a_15572_20560.t1 VSS 0.30492f $ **FLOATING
C1696 a_15572_20560.t2 VSS 0.27265f $ **FLOATING
C1697 a_15572_20560.n1 VSS 0.34141f $ **FLOATING
C1698 a_14218_20217.t1 VSS 0.09002f $ **FLOATING
C1699 a_14218_20217.t0 VSS 0.0924f $ **FLOATING
C1700 a_14218_20217.t2 VSS 0.08405f $ **FLOATING
C1701 a_14218_20217.n0 VSS 0.26084f $ **FLOATING
C1702 a_16320_20293.t1 VSS 0.15513f $ **FLOATING
C1703 a_16320_20293.t2 VSS 0.78293f $ **FLOATING
C1704 a_16320_20293.n0 VSS 0.44013f $ **FLOATING
C1705 a_16320_20293.t0 VSS 0.23527f $ **FLOATING
C1706 a_16548_20433.t0 VSS 0.10861f $ **FLOATING
C1707 a_16548_20433.t1 VSS 0.1094f $ **FLOATING
C1708 a_16548_20433.n0 VSS 0.47589f $ **FLOATING
C1709 a_16548_20433.t2 VSS 0.21808f $ **FLOATING
C1710 a_17121_20494.t0 VSS 0.08718f $ **FLOATING
C1711 a_17121_20494.t2 VSS 0.28889f $ **FLOATING
C1712 a_17121_20494.t1 VSS 0.13908f $ **FLOATING
C1713 a_17121_20494.n0 VSS 0.3269f $ **FLOATING
C1714 a_20145_20594.t0 VSS 0.06881f $ **FLOATING
C1715 a_20145_20594.t2 VSS 0.23106f $ **FLOATING
C1716 a_20145_20594.t1 VSS 0.1079f $ **FLOATING
C1717 a_20145_20594.n0 VSS 0.28721f $ **FLOATING
C1718 a_15350_20229.t0 VSS 0.38791f $ **FLOATING
C1719 a_15350_20229.t1 VSS 0.44637f $ **FLOATING
C1720 a_16226_20293.t0 VSS 0.37163f $ **FLOATING
C1721 a_16226_20293.t1 VSS 0.37297f $ **FLOATING
C1722 a_18209_20290.t3 VSS 0.07497f $ **FLOATING
C1723 a_18209_20290.t4 VSS 0.07496f $ **FLOATING
C1724 a_18209_20290.n0 VSS 0.12648f $ **FLOATING
C1725 a_18209_20290.t2 VSS 0.07497f $ **FLOATING
C1726 a_18209_20290.t5 VSS 0.07496f $ **FLOATING
C1727 a_18209_20290.n1 VSS 0.1623f $ **FLOATING
C1728 a_18209_20290.t1 VSS 0.07497f $ **FLOATING
C1729 a_18209_20290.t7 VSS 0.07496f $ **FLOATING
C1730 a_18209_20290.n2 VSS 0.1623f $ **FLOATING
C1731 a_18209_20290.t0 VSS 0.07497f $ **FLOATING
C1732 a_18209_20290.t6 VSS 0.07497f $ **FLOATING
C1733 a_18209_20290.n3 VSS 0.12648f $ **FLOATING
C1734 a_20239_20594.t0 VSS 0.03525f $ **FLOATING
C1735 a_20450_20198.t0 VSS 0.12965f $ **FLOATING
C1736 a_20450_20198.t1 VSS 0.1998f $ **FLOATING
C1737 a_20450_20198.n0 VSS 0.56027f $ **FLOATING
C1738 a_20450_20198.t2 VSS 0.2736f $ **FLOATING
C1739 a_20839_20514.t1 VSS 0.1615f $ **FLOATING
C1740 a_20839_20514.t3 VSS 0.18502f $ **FLOATING
C1741 a_20839_20514.t2 VSS 0.25343f $ **FLOATING
C1742 a_20839_20514.t0 VSS 0.25259f $ **FLOATING
C1743 a_20839_20514.n0 VSS 0.39378f $ **FLOATING
C1744 a_20839_20514.n1 VSS 0.36165f $ **FLOATING
C1745 a_21555_20439.t0 VSS 0.14823f $ **FLOATING
C1746 a_21555_20439.t2 VSS 0.13694f $ **FLOATING
C1747 a_21555_20439.t3 VSS 0.31237f $ **FLOATING
C1748 a_21555_20439.n0 VSS 0.43818f $ **FLOATING
C1749 a_21555_20439.n1 VSS 0.34318f $ **FLOATING
C1750 a_21555_20439.t1 VSS 0.1467f $ **FLOATING
C1751 a_21295_20216.t0 VSS 0.17002f $ **FLOATING
C1752 a_21295_20216.t1 VSS 0.16416f $ **FLOATING
C1753 a_21295_20216.n0 VSS 1.06942f $ **FLOATING
C1754 a_21295_20216.t3 VSS 0.18347f $ **FLOATING
C1755 a_21295_20216.n1 VSS 0.98647f $ **FLOATING
C1756 a_21295_20216.t2 VSS 0.18247f $ **FLOATING
C1757 a_21581_20534.t1 VSS 0.26937f $ **FLOATING
C1758 a_21581_20534.t4 VSS 0.24708f $ **FLOATING
C1759 a_21581_20534.t3 VSS 0.27567f $ **FLOATING
C1760 a_21581_20534.n0 VSS 0.49599f $ **FLOATING
C1761 a_21581_20534.t2 VSS 0.1914f $ **FLOATING
C1762 a_21581_20534.n1 VSS 0.50752f $ **FLOATING
C1763 a_21581_20534.t0 VSS 0.27163f $ **FLOATING
C1764 a_21581_20534.n2 VSS 0.81764f $ **FLOATING
C1765 a_21990_20473.t0 VSS 0.15491f $ **FLOATING
C1766 a_21990_20473.t3 VSS 0.6011f $ **FLOATING
C1767 a_21990_20473.n0 VSS 0.31833f $ **FLOATING
C1768 a_21990_20473.t1 VSS 0.2267f $ **FLOATING
C1769 a_21990_20473.n1 VSS 0.1803f $ **FLOATING
C1770 a_21990_20473.t2 VSS 0.25072f $ **FLOATING
C1771 a_22092_20560.t0 VSS 0.20064f $ **FLOATING
C1772 a_22092_20560.t3 VSS 0.28263f $ **FLOATING
C1773 a_22092_20560.n0 VSS 0.6345f $ **FLOATING
C1774 a_22092_20560.t1 VSS 0.30493f $ **FLOATING
C1775 a_22092_20560.t2 VSS 0.27266f $ **FLOATING
C1776 a_22092_20560.n1 VSS 0.34142f $ **FLOATING
C1777 a_20738_20217.t1 VSS 0.09027f $ **FLOATING
C1778 a_20738_20217.t0 VSS 0.09266f $ **FLOATING
C1779 a_20738_20217.t2 VSS 0.08428f $ **FLOATING
C1780 a_20738_20217.n0 VSS 0.26155f $ **FLOATING
C1781 a_22840_20293.t0 VSS 0.15513f $ **FLOATING
C1782 a_22840_20293.t2 VSS 0.78293f $ **FLOATING
C1783 a_22840_20293.n0 VSS 0.44013f $ **FLOATING
C1784 a_22840_20293.t1 VSS 0.23527f $ **FLOATING
C1785 a_23068_20433.t0 VSS 0.1094f $ **FLOATING
C1786 a_23068_20433.t2 VSS 0.21808f $ **FLOATING
C1787 a_23068_20433.t1 VSS 0.10861f $ **FLOATING
C1788 a_23068_20433.n0 VSS 0.47589f $ **FLOATING
C1789 a_23641_20494.t0 VSS 0.08718f $ **FLOATING
C1790 a_23641_20494.t2 VSS 0.28889f $ **FLOATING
C1791 a_23641_20494.t1 VSS 0.13908f $ **FLOATING
C1792 a_23641_20494.n0 VSS 0.3269f $ **FLOATING
C1793 a_26665_20594.t0 VSS 0.06885f $ **FLOATING
C1794 a_26665_20594.t2 VSS 0.2312f $ **FLOATING
C1795 a_26665_20594.t1 VSS 0.10796f $ **FLOATING
C1796 a_26665_20594.n0 VSS 0.28738f $ **FLOATING
C1797 a_21870_20229.t0 VSS 0.44639f $ **FLOATING
C1798 a_21870_20229.t1 VSS 0.38793f $ **FLOATING
C1799 a_22746_20293.t0 VSS 0.37297f $ **FLOATING
C1800 a_22746_20293.t1 VSS 0.37163f $ **FLOATING
C1801 a_24729_20290.t3 VSS 0.07497f $ **FLOATING
C1802 a_24729_20290.t6 VSS 0.07497f $ **FLOATING
C1803 a_24729_20290.n0 VSS 0.12649f $ **FLOATING
C1804 a_24729_20290.t2 VSS 0.07497f $ **FLOATING
C1805 a_24729_20290.t5 VSS 0.07497f $ **FLOATING
C1806 a_24729_20290.n1 VSS 0.16231f $ **FLOATING
C1807 a_24729_20290.t1 VSS 0.07497f $ **FLOATING
C1808 a_24729_20290.t4 VSS 0.07497f $ **FLOATING
C1809 a_24729_20290.n2 VSS 0.16231f $ **FLOATING
C1810 a_24729_20290.t0 VSS 0.07497f $ **FLOATING
C1811 a_24729_20290.t7 VSS 0.07497f $ **FLOATING
C1812 a_24729_20290.n3 VSS 0.12649f $ **FLOATING
C1813 a_26759_20594.t0 VSS 0.03528f $ **FLOATING
C1814 a_26970_20198.t0 VSS 0.12977f $ **FLOATING
C1815 a_26970_20198.t1 VSS 0.19998f $ **FLOATING
C1816 a_26970_20198.n0 VSS 0.56077f $ **FLOATING
C1817 a_26970_20198.t2 VSS 0.27385f $ **FLOATING
C1818 a_27359_20514.t1 VSS 0.16132f $ **FLOATING
C1819 a_27359_20514.t3 VSS 0.18482f $ **FLOATING
C1820 a_27359_20514.t2 VSS 0.25315f $ **FLOATING
C1821 a_27359_20514.t0 VSS 0.25231f $ **FLOATING
C1822 a_27359_20514.n0 VSS 0.39334f $ **FLOATING
C1823 a_27359_20514.n1 VSS 0.36125f $ **FLOATING
C1824 a_28075_20439.t0 VSS 0.14822f $ **FLOATING
C1825 a_28075_20439.t2 VSS 0.13693f $ **FLOATING
C1826 a_28075_20439.t3 VSS 0.31235f $ **FLOATING
C1827 a_28075_20439.n0 VSS 0.43815f $ **FLOATING
C1828 a_28075_20439.n1 VSS 0.34316f $ **FLOATING
C1829 a_28075_20439.t1 VSS 0.14669f $ **FLOATING
C1830 a_27815_20216.t0 VSS 0.17001f $ **FLOATING
C1831 a_27815_20216.t1 VSS 0.16415f $ **FLOATING
C1832 a_27815_20216.n0 VSS 1.06934f $ **FLOATING
C1833 a_27815_20216.t2 VSS 0.18346f $ **FLOATING
C1834 a_27815_20216.n1 VSS 0.9864f $ **FLOATING
C1835 a_27815_20216.t3 VSS 0.18246f $ **FLOATING
C1836 a_28101_20534.t1 VSS 0.26936f $ **FLOATING
C1837 a_28101_20534.t4 VSS 0.24707f $ **FLOATING
C1838 a_28101_20534.t3 VSS 0.27566f $ **FLOATING
C1839 a_28101_20534.n0 VSS 0.49596f $ **FLOATING
C1840 a_28101_20534.t2 VSS 0.19139f $ **FLOATING
C1841 a_28101_20534.n1 VSS 0.50749f $ **FLOATING
C1842 a_28101_20534.t0 VSS 0.27161f $ **FLOATING
C1843 a_28101_20534.n2 VSS 0.81759f $ **FLOATING
C1844 a_28510_20473.t0 VSS 0.1549f $ **FLOATING
C1845 a_28510_20473.t3 VSS 0.60107f $ **FLOATING
C1846 a_28510_20473.n0 VSS 0.31831f $ **FLOATING
C1847 a_28510_20473.t1 VSS 0.22669f $ **FLOATING
C1848 a_28510_20473.n1 VSS 0.18029f $ **FLOATING
C1849 a_28510_20473.t2 VSS 0.2507f $ **FLOATING
C1850 a_28612_20560.t0 VSS 0.20064f $ **FLOATING
C1851 a_28612_20560.t3 VSS 0.28262f $ **FLOATING
C1852 a_28612_20560.n0 VSS 0.63449f $ **FLOATING
C1853 a_28612_20560.t1 VSS 0.30492f $ **FLOATING
C1854 a_28612_20560.t2 VSS 0.27265f $ **FLOATING
C1855 a_28612_20560.n1 VSS 0.34141f $ **FLOATING
C1856 a_27258_20217.t1 VSS 0.0901f $ **FLOATING
C1857 a_27258_20217.t0 VSS 0.09248f $ **FLOATING
C1858 a_27258_20217.t2 VSS 0.08412f $ **FLOATING
C1859 a_27258_20217.n0 VSS 0.26106f $ **FLOATING
C1860 a_29360_20293.t0 VSS 0.15513f $ **FLOATING
C1861 a_29360_20293.t2 VSS 0.78293f $ **FLOATING
C1862 a_29360_20293.n0 VSS 0.44013f $ **FLOATING
C1863 a_29360_20293.t1 VSS 0.23527f $ **FLOATING
C1864 a_29588_20433.t0 VSS 0.1094f $ **FLOATING
C1865 a_29588_20433.t2 VSS 0.21808f $ **FLOATING
C1866 a_29588_20433.t1 VSS 0.10861f $ **FLOATING
C1867 a_29588_20433.n0 VSS 0.47589f $ **FLOATING
C1868 a_30161_20494.t0 VSS 0.08718f $ **FLOATING
C1869 a_30161_20494.t2 VSS 0.28889f $ **FLOATING
C1870 a_30161_20494.t1 VSS 0.13908f $ **FLOATING
C1871 a_30161_20494.n0 VSS 0.3269f $ **FLOATING
C1872 a_33185_20594.t0 VSS 0.06875f $ **FLOATING
C1873 a_33185_20594.t2 VSS 0.23084f $ **FLOATING
C1874 a_33185_20594.t1 VSS 0.1078f $ **FLOATING
C1875 a_33185_20594.n0 VSS 0.28693f $ **FLOATING
C1876 a_28390_20229.t0 VSS 0.44638f $ **FLOATING
C1877 a_28390_20229.t1 VSS 0.38792f $ **FLOATING
C1878 a_29266_20293.t0 VSS 0.37163f $ **FLOATING
C1879 a_29266_20293.t1 VSS 0.37297f $ **FLOATING
C1880 a_31249_20290.t3 VSS 0.07496f $ **FLOATING
C1881 a_31249_20290.t7 VSS 0.07496f $ **FLOATING
C1882 a_31249_20290.n0 VSS 0.12648f $ **FLOATING
C1883 a_31249_20290.t2 VSS 0.07496f $ **FLOATING
C1884 a_31249_20290.t6 VSS 0.07496f $ **FLOATING
C1885 a_31249_20290.n1 VSS 0.1623f $ **FLOATING
C1886 a_31249_20290.t1 VSS 0.07496f $ **FLOATING
C1887 a_31249_20290.t5 VSS 0.07496f $ **FLOATING
C1888 a_31249_20290.n2 VSS 0.1623f $ **FLOATING
C1889 a_31249_20290.t0 VSS 0.07496f $ **FLOATING
C1890 a_31249_20290.t4 VSS 0.07496f $ **FLOATING
C1891 a_31249_20290.n3 VSS 0.12648f $ **FLOATING
C1892 a_33279_20594.t0 VSS 0.03521f $ **FLOATING
C1893 a_33490_20198.t0 VSS 0.12995f $ **FLOATING
C1894 a_33490_20198.t1 VSS 0.20026f $ **FLOATING
C1895 a_33490_20198.n0 VSS 0.56157f $ **FLOATING
C1896 a_33490_20198.t2 VSS 0.27424f $ **FLOATING
C1897 a_33879_20514.t2 VSS 0.16201f $ **FLOATING
C1898 a_33879_20514.t3 VSS 0.18561f $ **FLOATING
C1899 a_33879_20514.t1 VSS 0.25423f $ **FLOATING
C1900 a_33879_20514.t0 VSS 0.25339f $ **FLOATING
C1901 a_33879_20514.n0 VSS 0.39503f $ **FLOATING
C1902 a_33879_20514.n1 VSS 0.3628f $ **FLOATING
C1903 a_34595_20439.t0 VSS 0.14671f $ **FLOATING
C1904 a_34595_20439.t1 VSS 0.14824f $ **FLOATING
C1905 a_34595_20439.t2 VSS 0.13695f $ **FLOATING
C1906 a_34595_20439.t3 VSS 0.31241f $ **FLOATING
C1907 a_34595_20439.n0 VSS 0.43823f $ **FLOATING
C1908 a_34595_20439.n1 VSS 0.34322f $ **FLOATING
C1909 a_34335_20216.t0 VSS 0.1825f $ **FLOATING
C1910 a_34335_20216.t1 VSS 0.1835f $ **FLOATING
C1911 a_34335_20216.n0 VSS 0.98663f $ **FLOATING
C1912 a_34335_20216.t2 VSS 0.16419f $ **FLOATING
C1913 a_34335_20216.n1 VSS 1.06959f $ **FLOATING
C1914 a_34335_20216.t3 VSS 0.17005f $ **FLOATING
C1915 a_34621_20534.t0 VSS 0.26941f $ **FLOATING
C1916 a_34621_20534.t4 VSS 0.24711f $ **FLOATING
C1917 a_34621_20534.t2 VSS 0.27571f $ **FLOATING
C1918 a_34621_20534.n0 VSS 0.49605f $ **FLOATING
C1919 a_34621_20534.t1 VSS 0.19142f $ **FLOATING
C1920 a_34621_20534.n1 VSS 0.50758f $ **FLOATING
C1921 a_34621_20534.t3 VSS 0.27166f $ **FLOATING
C1922 a_34621_20534.n2 VSS 0.81774f $ **FLOATING
C1923 a_35030_20473.t0 VSS 0.15492f $ **FLOATING
C1924 a_35030_20473.t3 VSS 0.60114f $ **FLOATING
C1925 a_35030_20473.n0 VSS 0.31835f $ **FLOATING
C1926 a_35030_20473.t1 VSS 0.22671f $ **FLOATING
C1927 a_35030_20473.n1 VSS 0.18031f $ **FLOATING
C1928 a_35030_20473.t2 VSS 0.25073f $ **FLOATING
C1929 a_35132_20560.t0 VSS 0.20065f $ **FLOATING
C1930 a_35132_20560.t3 VSS 0.28264f $ **FLOATING
C1931 a_35132_20560.n0 VSS 0.63453f $ **FLOATING
C1932 a_35132_20560.t1 VSS 0.30494f $ **FLOATING
C1933 a_35132_20560.t2 VSS 0.27267f $ **FLOATING
C1934 a_35132_20560.n1 VSS 0.34144f $ **FLOATING
C1935 a_33778_20217.t1 VSS 0.09073f $ **FLOATING
C1936 a_33778_20217.t0 VSS 0.09312f $ **FLOATING
C1937 a_33778_20217.t2 VSS 0.08471f $ **FLOATING
C1938 a_33778_20217.n0 VSS 0.26287f $ **FLOATING
C1939 a_35880_20293.t0 VSS 0.15513f $ **FLOATING
C1940 a_35880_20293.t2 VSS 0.78293f $ **FLOATING
C1941 a_35880_20293.n0 VSS 0.44013f $ **FLOATING
C1942 a_35880_20293.t1 VSS 0.23527f $ **FLOATING
C1943 a_36108_20433.t0 VSS 0.10861f $ **FLOATING
C1944 a_36108_20433.t1 VSS 0.1094f $ **FLOATING
C1945 a_36108_20433.n0 VSS 0.47589f $ **FLOATING
C1946 a_36108_20433.t2 VSS 0.21808f $ **FLOATING
C1947 a_36681_20494.t0 VSS 0.08718f $ **FLOATING
C1948 a_36681_20494.t2 VSS 0.28889f $ **FLOATING
C1949 a_36681_20494.t1 VSS 0.13908f $ **FLOATING
C1950 a_36681_20494.n0 VSS 0.3269f $ **FLOATING
C1951 a_39705_20594.t0 VSS 0.06878f $ **FLOATING
C1952 a_39705_20594.t2 VSS 0.23095f $ **FLOATING
C1953 a_39705_20594.t1 VSS 0.10785f $ **FLOATING
C1954 a_39705_20594.n0 VSS 0.28707f $ **FLOATING
C1955 a_34910_20229.t0 VSS 0.44642f $ **FLOATING
C1956 a_34910_20229.t1 VSS 0.38795f $ **FLOATING
C1957 a_35786_20293.t0 VSS 0.37297f $ **FLOATING
C1958 a_35786_20293.t1 VSS 0.37163f $ **FLOATING
C1959 a_37769_20290.t3 VSS 0.07496f $ **FLOATING
C1960 a_37769_20290.t4 VSS 0.07496f $ **FLOATING
C1961 a_37769_20290.n0 VSS 0.12648f $ **FLOATING
C1962 a_37769_20290.t2 VSS 0.07496f $ **FLOATING
C1963 a_37769_20290.t5 VSS 0.07496f $ **FLOATING
C1964 a_37769_20290.n1 VSS 0.1623f $ **FLOATING
C1965 a_37769_20290.t1 VSS 0.07496f $ **FLOATING
C1966 a_37769_20290.t7 VSS 0.07496f $ **FLOATING
C1967 a_37769_20290.n2 VSS 0.1623f $ **FLOATING
C1968 a_37769_20290.t0 VSS 0.07496f $ **FLOATING
C1969 a_37769_20290.t6 VSS 0.07496f $ **FLOATING
C1970 a_37769_20290.n3 VSS 0.12648f $ **FLOATING
C1971 a_39799_20594.t0 VSS 0.03523f $ **FLOATING
C1972 a_40010_20198.t0 VSS 0.12983f $ **FLOATING
C1973 a_40010_20198.t1 VSS 0.20007f $ **FLOATING
C1974 a_40010_20198.n0 VSS 0.56103f $ **FLOATING
C1975 a_40010_20198.t2 VSS 0.27398f $ **FLOATING
C1976 a_40399_20514.t2 VSS 0.16172f $ **FLOATING
C1977 a_40399_20514.t3 VSS 0.18527f $ **FLOATING
C1978 a_40399_20514.t1 VSS 0.25377f $ **FLOATING
C1979 a_40399_20514.t0 VSS 0.25293f $ **FLOATING
C1980 a_40399_20514.n0 VSS 0.39432f $ **FLOATING
C1981 a_40399_20514.n1 VSS 0.36214f $ **FLOATING
C1982 a_41115_20439.t0 VSS 0.14823f $ **FLOATING
C1983 a_41115_20439.t2 VSS 0.13695f $ **FLOATING
C1984 a_41115_20439.t3 VSS 0.31239f $ **FLOATING
C1985 a_41115_20439.n0 VSS 0.4382f $ **FLOATING
C1986 a_41115_20439.n1 VSS 0.3432f $ **FLOATING
C1987 a_41115_20439.t1 VSS 0.1467f $ **FLOATING
C1988 a_40855_20216.t0 VSS 0.16417f $ **FLOATING
C1989 a_40855_20216.t2 VSS 0.18349f $ **FLOATING
C1990 a_40855_20216.n0 VSS 0.98655f $ **FLOATING
C1991 a_40855_20216.t1 VSS 0.18248f $ **FLOATING
C1992 a_40855_20216.t3 VSS 0.17004f $ **FLOATING
C1993 a_40855_20216.n1 VSS 1.0695f $ **FLOATING
C1994 a_41141_20534.t0 VSS 0.26939f $ **FLOATING
C1995 a_41141_20534.t4 VSS 0.2471f $ **FLOATING
C1996 a_41141_20534.t2 VSS 0.27569f $ **FLOATING
C1997 a_41141_20534.n0 VSS 0.49602f $ **FLOATING
C1998 a_41141_20534.t1 VSS 0.19141f $ **FLOATING
C1999 a_41141_20534.n1 VSS 0.50755f $ **FLOATING
C2000 a_41141_20534.t3 VSS 0.27164f $ **FLOATING
C2001 a_41141_20534.n2 VSS 0.81769f $ **FLOATING
C2002 a_41550_20473.t0 VSS 0.15491f $ **FLOATING
C2003 a_41550_20473.t3 VSS 0.60112f $ **FLOATING
C2004 a_41550_20473.n0 VSS 0.31834f $ **FLOATING
C2005 a_41550_20473.t1 VSS 0.22671f $ **FLOATING
C2006 a_41550_20473.n1 VSS 0.1803f $ **FLOATING
C2007 a_41550_20473.t2 VSS 0.25072f $ **FLOATING
C2008 a_41652_20560.t0 VSS 0.20064f $ **FLOATING
C2009 a_41652_20560.t3 VSS 0.28264f $ **FLOATING
C2010 a_41652_20560.n0 VSS 0.63451f $ **FLOATING
C2011 a_41652_20560.t1 VSS 0.30494f $ **FLOATING
C2012 a_41652_20560.t2 VSS 0.27266f $ **FLOATING
C2013 a_41652_20560.n1 VSS 0.34143f $ **FLOATING
C2014 a_40298_20217.t1 VSS 0.09045f $ **FLOATING
C2015 a_40298_20217.t0 VSS 0.09284f $ **FLOATING
C2016 a_40298_20217.t2 VSS 0.08445f $ **FLOATING
C2017 a_40298_20217.n0 VSS 0.26208f $ **FLOATING
C2018 a_42400_20293.t1 VSS 0.15513f $ **FLOATING
C2019 a_42400_20293.t2 VSS 0.78293f $ **FLOATING
C2020 a_42400_20293.n0 VSS 0.44013f $ **FLOATING
C2021 a_42400_20293.t0 VSS 0.23527f $ **FLOATING
C2022 a_42628_20433.t0 VSS 0.10861f $ **FLOATING
C2023 a_42628_20433.t1 VSS 0.1094f $ **FLOATING
C2024 a_42628_20433.n0 VSS 0.47589f $ **FLOATING
C2025 a_42628_20433.t2 VSS 0.21808f $ **FLOATING
C2026 a_43201_20494.t0 VSS 0.08718f $ **FLOATING
C2027 a_43201_20494.t2 VSS 0.28889f $ **FLOATING
C2028 a_43201_20494.t1 VSS 0.13908f $ **FLOATING
C2029 a_43201_20494.n0 VSS 0.3269f $ **FLOATING
C2030 a_41430_20229.t0 VSS 0.4464f $ **FLOATING
C2031 a_41430_20229.t1 VSS 0.38794f $ **FLOATING
C2032 a_42306_20293.t0 VSS 0.37297f $ **FLOATING
C2033 a_42306_20293.t1 VSS 0.37163f $ **FLOATING
C2034 a_44289_20290.t3 VSS 0.0747f $ **FLOATING
C2035 a_44289_20290.t6 VSS 0.0747f $ **FLOATING
C2036 a_44289_20290.n0 VSS 0.12604f $ **FLOATING
C2037 a_44289_20290.t2 VSS 0.0747f $ **FLOATING
C2038 a_44289_20290.t7 VSS 0.0747f $ **FLOATING
C2039 a_44289_20290.n1 VSS 0.16173f $ **FLOATING
C2040 a_44289_20290.t1 VSS 0.0747f $ **FLOATING
C2041 a_44289_20290.t5 VSS 0.0747f $ **FLOATING
C2042 a_44289_20290.n2 VSS 0.16173f $ **FLOATING
C2043 a_44289_20290.t0 VSS 0.0747f $ **FLOATING
C2044 a_44289_20290.t4 VSS 0.0747f $ **FLOATING
C2045 a_44289_20290.n3 VSS 0.12604f $ **FLOATING
C2046 a_3877_17694.t0 VSS 0.06039f $ **FLOATING
C2047 a_3877_17694.n0 VSS 0.63583f $ **FLOATING
C2048 a_3877_17694.t2 VSS 0.43776f $ **FLOATING
C2049 a_3877_17694.t1 VSS 0.09863f $ **FLOATING
C2050 a_10397_17694.t0 VSS 0.06039f $ **FLOATING
C2051 a_10397_17694.n0 VSS 0.63584f $ **FLOATING
C2052 a_10397_17694.t2 VSS 0.43777f $ **FLOATING
C2053 a_10397_17694.t1 VSS 0.09863f $ **FLOATING
C2054 a_4298_17714.t0 VSS 0.06067f $ **FLOATING
C2055 a_4298_17714.t1 VSS 0.09886f $ **FLOATING
C2056 a_4298_17714.n0 VSS 0.62315f $ **FLOATING
C2057 a_4298_17714.t2 VSS 0.26475f $ **FLOATING
C2058 a_16917_17694.t0 VSS 0.06039f $ **FLOATING
C2059 a_16917_17694.n0 VSS 0.63581f $ **FLOATING
C2060 a_16917_17694.t2 VSS 0.43775f $ **FLOATING
C2061 a_16917_17694.t1 VSS 0.09863f $ **FLOATING
C2062 a_10818_17714.t0 VSS 0.06067f $ **FLOATING
C2063 a_10818_17714.t1 VSS 0.09886f $ **FLOATING
C2064 a_10818_17714.n0 VSS 0.62316f $ **FLOATING
C2065 a_10818_17714.t2 VSS 0.26475f $ **FLOATING
C2066 a_23437_17694.t0 VSS 0.06039f $ **FLOATING
C2067 a_23437_17694.n0 VSS 0.63584f $ **FLOATING
C2068 a_23437_17694.t2 VSS 0.43777f $ **FLOATING
C2069 a_23437_17694.t1 VSS 0.09863f $ **FLOATING
C2070 a_17338_17714.t0 VSS 0.06067f $ **FLOATING
C2071 a_17338_17714.t1 VSS 0.09886f $ **FLOATING
C2072 a_17338_17714.n0 VSS 0.62316f $ **FLOATING
C2073 a_17338_17714.t2 VSS 0.26475f $ **FLOATING
C2074 a_29957_17694.t0 VSS 0.06038f $ **FLOATING
C2075 a_29957_17694.n0 VSS 0.63573f $ **FLOATING
C2076 a_29957_17694.t2 VSS 0.43769f $ **FLOATING
C2077 a_29957_17694.t1 VSS 0.09861f $ **FLOATING
C2078 a_23858_17714.t0 VSS 0.06067f $ **FLOATING
C2079 a_23858_17714.t1 VSS 0.09886f $ **FLOATING
C2080 a_23858_17714.n0 VSS 0.62316f $ **FLOATING
C2081 a_23858_17714.t2 VSS 0.26475f $ **FLOATING
C2082 a_36477_17694.t0 VSS 0.06038f $ **FLOATING
C2083 a_36477_17694.n0 VSS 0.63575f $ **FLOATING
C2084 a_36477_17694.t2 VSS 0.43771f $ **FLOATING
C2085 a_36477_17694.t1 VSS 0.09862f $ **FLOATING
C2086 a_30378_17714.t0 VSS 0.06067f $ **FLOATING
C2087 a_30378_17714.t1 VSS 0.09886f $ **FLOATING
C2088 a_30378_17714.n0 VSS 0.62315f $ **FLOATING
C2089 a_30378_17714.t2 VSS 0.26475f $ **FLOATING
C2090 a_42997_17694.t0 VSS 0.06037f $ **FLOATING
C2091 a_42997_17694.n0 VSS 0.63567f $ **FLOATING
C2092 a_42997_17694.t2 VSS 0.43765f $ **FLOATING
C2093 a_42997_17694.t1 VSS 0.09861f $ **FLOATING
C2094 a_36898_17714.t0 VSS 0.06067f $ **FLOATING
C2095 a_36898_17714.t1 VSS 0.09886f $ **FLOATING
C2096 a_36898_17714.n0 VSS 0.62316f $ **FLOATING
C2097 a_36898_17714.t2 VSS 0.26475f $ **FLOATING
C2098 a_49517_17694.t0 VSS 0.06036f $ **FLOATING
C2099 a_49517_17694.n0 VSS 0.6355f $ **FLOATING
C2100 a_49517_17694.t2 VSS 0.43753f $ **FLOATING
C2101 a_49517_17694.t1 VSS 0.09858f $ **FLOATING
C2102 a_43418_17714.t0 VSS 0.06066f $ **FLOATING
C2103 a_43418_17714.t1 VSS 0.09885f $ **FLOATING
C2104 a_43418_17714.n0 VSS 0.62309f $ **FLOATING
C2105 a_43418_17714.t2 VSS 0.26472f $ **FLOATING
C2106 a_49938_17714.t0 VSS 0.06066f $ **FLOATING
C2107 a_49938_17714.t1 VSS 0.09884f $ **FLOATING
C2108 a_49938_17714.n0 VSS 0.62303f $ **FLOATING
C2109 a_49938_17714.t2 VSS 0.2647f $ **FLOATING
C2110 a_5003_17750.t3 VSS 0.14548f $ **FLOATING
C2111 a_5003_17750.t8 VSS 0.12742f $ **FLOATING
C2112 a_5003_17750.n0 VSS 0.31237f $ **FLOATING
C2113 a_5003_17750.t5 VSS 0.09877f $ **FLOATING
C2114 a_5003_17750.n1 VSS 0.38034f $ **FLOATING
C2115 a_5003_17750.t4 VSS 0.0965f $ **FLOATING
C2116 a_5003_17750.n2 VSS 0.33102f $ **FLOATING
C2117 a_5003_17750.t0 VSS 0.1108f $ **FLOATING
C2118 a_5003_17750.t6 VSS 0.0965f $ **FLOATING
C2119 a_5003_17750.n3 VSS 0.33102f $ **FLOATING
C2120 a_5003_17750.t1 VSS 0.1108f $ **FLOATING
C2121 a_5003_17750.t2 VSS 0.14548f $ **FLOATING
C2122 a_5003_17750.t7 VSS 0.12816f $ **FLOATING
C2123 a_5003_17750.n4 VSS 0.34636f $ **FLOATING
C2124 a_5003_17750.t9 VSS 0.12816f $ **FLOATING
C2125 a_5003_17750.n5 VSS 0.34636f $ **FLOATING
C2126 a_11523_17750.t3 VSS 0.14549f $ **FLOATING
C2127 a_11523_17750.t5 VSS 0.12742f $ **FLOATING
C2128 a_11523_17750.n0 VSS 0.31239f $ **FLOATING
C2129 a_11523_17750.t9 VSS 0.09878f $ **FLOATING
C2130 a_11523_17750.n1 VSS 0.38036f $ **FLOATING
C2131 a_11523_17750.t7 VSS 0.0965f $ **FLOATING
C2132 a_11523_17750.n2 VSS 0.33104f $ **FLOATING
C2133 a_11523_17750.t0 VSS 0.1108f $ **FLOATING
C2134 a_11523_17750.t8 VSS 0.0965f $ **FLOATING
C2135 a_11523_17750.n3 VSS 0.33104f $ **FLOATING
C2136 a_11523_17750.t1 VSS 0.1108f $ **FLOATING
C2137 a_11523_17750.t2 VSS 0.14549f $ **FLOATING
C2138 a_11523_17750.t4 VSS 0.12816f $ **FLOATING
C2139 a_11523_17750.n4 VSS 0.34637f $ **FLOATING
C2140 a_11523_17750.t6 VSS 0.12816f $ **FLOATING
C2141 a_11523_17750.n5 VSS 0.34637f $ **FLOATING
C2142 a_18043_17750.t3 VSS 0.14548f $ **FLOATING
C2143 a_18043_17750.t7 VSS 0.12741f $ **FLOATING
C2144 a_18043_17750.n0 VSS 0.31237f $ **FLOATING
C2145 a_18043_17750.t9 VSS 0.09877f $ **FLOATING
C2146 a_18043_17750.n1 VSS 0.38034f $ **FLOATING
C2147 a_18043_17750.t5 VSS 0.0965f $ **FLOATING
C2148 a_18043_17750.n2 VSS 0.33102f $ **FLOATING
C2149 a_18043_17750.t0 VSS 0.1108f $ **FLOATING
C2150 a_18043_17750.t4 VSS 0.0965f $ **FLOATING
C2151 a_18043_17750.n3 VSS 0.33102f $ **FLOATING
C2152 a_18043_17750.t1 VSS 0.1108f $ **FLOATING
C2153 a_18043_17750.t2 VSS 0.14548f $ **FLOATING
C2154 a_18043_17750.t6 VSS 0.12816f $ **FLOATING
C2155 a_18043_17750.n4 VSS 0.34635f $ **FLOATING
C2156 a_18043_17750.t8 VSS 0.12816f $ **FLOATING
C2157 a_18043_17750.n5 VSS 0.34635f $ **FLOATING
C2158 a_24563_17750.t3 VSS 0.14548f $ **FLOATING
C2159 a_24563_17750.t7 VSS 0.12742f $ **FLOATING
C2160 a_24563_17750.n0 VSS 0.31238f $ **FLOATING
C2161 a_24563_17750.t9 VSS 0.09877f $ **FLOATING
C2162 a_24563_17750.n1 VSS 0.38035f $ **FLOATING
C2163 a_24563_17750.t4 VSS 0.0965f $ **FLOATING
C2164 a_24563_17750.n2 VSS 0.33103f $ **FLOATING
C2165 a_24563_17750.t0 VSS 0.1108f $ **FLOATING
C2166 a_24563_17750.t5 VSS 0.0965f $ **FLOATING
C2167 a_24563_17750.n3 VSS 0.33103f $ **FLOATING
C2168 a_24563_17750.t1 VSS 0.1108f $ **FLOATING
C2169 a_24563_17750.t2 VSS 0.14548f $ **FLOATING
C2170 a_24563_17750.t6 VSS 0.12816f $ **FLOATING
C2171 a_24563_17750.n4 VSS 0.34636f $ **FLOATING
C2172 a_24563_17750.t8 VSS 0.12816f $ **FLOATING
C2173 a_24563_17750.n5 VSS 0.34636f $ **FLOATING
C2174 a_31083_17750.t3 VSS 0.14548f $ **FLOATING
C2175 a_31083_17750.t8 VSS 0.12741f $ **FLOATING
C2176 a_31083_17750.n0 VSS 0.31236f $ **FLOATING
C2177 a_31083_17750.t5 VSS 0.09877f $ **FLOATING
C2178 a_31083_17750.n1 VSS 0.38033f $ **FLOATING
C2179 a_31083_17750.t4 VSS 0.09649f $ **FLOATING
C2180 a_31083_17750.n2 VSS 0.331f $ **FLOATING
C2181 a_31083_17750.t0 VSS 0.11079f $ **FLOATING
C2182 a_31083_17750.t6 VSS 0.09649f $ **FLOATING
C2183 a_31083_17750.n3 VSS 0.331f $ **FLOATING
C2184 a_31083_17750.t1 VSS 0.11079f $ **FLOATING
C2185 a_31083_17750.t2 VSS 0.14548f $ **FLOATING
C2186 a_31083_17750.t7 VSS 0.12815f $ **FLOATING
C2187 a_31083_17750.n4 VSS 0.34634f $ **FLOATING
C2188 a_31083_17750.t9 VSS 0.12815f $ **FLOATING
C2189 a_31083_17750.n5 VSS 0.34634f $ **FLOATING
C2190 a_37603_17750.t9 VSS 0.12815f $ **FLOATING
C2191 a_37603_17750.t8 VSS 0.12741f $ **FLOATING
C2192 a_37603_17750.n0 VSS 0.31236f $ **FLOATING
C2193 a_37603_17750.t6 VSS 0.09877f $ **FLOATING
C2194 a_37603_17750.n1 VSS 0.38033f $ **FLOATING
C2195 a_37603_17750.t4 VSS 0.0965f $ **FLOATING
C2196 a_37603_17750.n2 VSS 0.33101f $ **FLOATING
C2197 a_37603_17750.t0 VSS 0.11079f $ **FLOATING
C2198 a_37603_17750.t5 VSS 0.0965f $ **FLOATING
C2199 a_37603_17750.n3 VSS 0.33101f $ **FLOATING
C2200 a_37603_17750.t1 VSS 0.11079f $ **FLOATING
C2201 a_37603_17750.t2 VSS 0.14548f $ **FLOATING
C2202 a_37603_17750.t7 VSS 0.12815f $ **FLOATING
C2203 a_37603_17750.n4 VSS 0.34635f $ **FLOATING
C2204 a_37603_17750.t3 VSS 0.14548f $ **FLOATING
C2205 a_37603_17750.n5 VSS 0.34635f $ **FLOATING
C2206 a_44123_17750.t3 VSS 0.14509f $ **FLOATING
C2207 a_44123_17750.t5 VSS 0.12707f $ **FLOATING
C2208 a_44123_17750.n0 VSS 0.31153f $ **FLOATING
C2209 a_44123_17750.t8 VSS 0.09851f $ **FLOATING
C2210 a_44123_17750.n1 VSS 0.37932f $ **FLOATING
C2211 a_44123_17750.t7 VSS 0.09624f $ **FLOATING
C2212 a_44123_17750.n2 VSS 0.33013f $ **FLOATING
C2213 a_44123_17750.t0 VSS 0.1105f $ **FLOATING
C2214 a_44123_17750.t9 VSS 0.09624f $ **FLOATING
C2215 a_44123_17750.n3 VSS 0.33013f $ **FLOATING
C2216 a_44123_17750.t1 VSS 0.1105f $ **FLOATING
C2217 a_44123_17750.t2 VSS 0.14509f $ **FLOATING
C2218 a_44123_17750.t4 VSS 0.12781f $ **FLOATING
C2219 a_44123_17750.n4 VSS 0.34543f $ **FLOATING
C2220 a_44123_17750.t6 VSS 0.12781f $ **FLOATING
C2221 a_44123_17750.n5 VSS 0.34543f $ **FLOATING
C2222 a_50643_17750.t3 VSS 0.14501f $ **FLOATING
C2223 a_50643_17750.t5 VSS 0.127f $ **FLOATING
C2224 a_50643_17750.n0 VSS 0.31135f $ **FLOATING
C2225 a_50643_17750.t8 VSS 0.09845f $ **FLOATING
C2226 a_50643_17750.n1 VSS 0.37911f $ **FLOATING
C2227 a_50643_17750.t7 VSS 0.09618f $ **FLOATING
C2228 a_50643_17750.n2 VSS 0.32994f $ **FLOATING
C2229 a_50643_17750.t0 VSS 0.11044f $ **FLOATING
C2230 a_50643_17750.t9 VSS 0.09618f $ **FLOATING
C2231 a_50643_17750.n3 VSS 0.32994f $ **FLOATING
C2232 a_50643_17750.t1 VSS 0.11044f $ **FLOATING
C2233 a_50643_17750.t2 VSS 0.14501f $ **FLOATING
C2234 a_50643_17750.t4 VSS 0.12774f $ **FLOATING
C2235 a_50643_17750.n4 VSS 0.34523f $ **FLOATING
C2236 a_50643_17750.t6 VSS 0.12774f $ **FLOATING
C2237 a_50643_17750.n5 VSS 0.34523f $ **FLOATING
C2238 a_585_17794.t0 VSS 0.08906f $ **FLOATING
C2239 a_585_17794.t2 VSS 0.29904f $ **FLOATING
C2240 a_585_17794.t1 VSS 0.13965f $ **FLOATING
C2241 a_585_17794.n0 VSS 0.37172f $ **FLOATING
C2242 a_679_17794.t0 VSS 0.03714f $ **FLOATING
C2243 a_890_17398.t0 VSS 0.13394f $ **FLOATING
C2244 a_890_17398.t1 VSS 0.20641f $ **FLOATING
C2245 a_890_17398.n0 VSS 0.57881f $ **FLOATING
C2246 a_890_17398.t2 VSS 0.28266f $ **FLOATING
C2247 a_n2648_3264.t0 VSS 0.10932f $ **FLOATING
C2248 a_n2648_3264.n0 VSS 7.18729f $ **FLOATING
C2249 a_n2648_3264.t10 VSS 0.49624f $ **FLOATING
C2250 a_n2648_3264.n1 VSS 13.0463f $ **FLOATING
C2251 a_n2648_3264.t2 VSS 0.37791f $ **FLOATING
C2252 a_n2648_3264.n2 VSS 4.72959f $ **FLOATING
C2253 a_n2648_3264.t11 VSS 0.35129f $ **FLOATING
C2254 a_n2648_3264.n3 VSS 5.328f $ **FLOATING
C2255 a_n2648_3264.t3 VSS 0.37791f $ **FLOATING
C2256 a_n2648_3264.n4 VSS 4.72959f $ **FLOATING
C2257 a_n2648_3264.t12 VSS 0.35129f $ **FLOATING
C2258 a_n2648_3264.n5 VSS 5.328f $ **FLOATING
C2259 a_n2648_3264.t4 VSS 0.37791f $ **FLOATING
C2260 a_n2648_3264.n6 VSS 4.72959f $ **FLOATING
C2261 a_n2648_3264.t13 VSS 0.35129f $ **FLOATING
C2262 a_n2648_3264.n7 VSS 5.328f $ **FLOATING
C2263 a_n2648_3264.t5 VSS 0.37791f $ **FLOATING
C2264 a_n2648_3264.n8 VSS 4.72959f $ **FLOATING
C2265 a_n2648_3264.t14 VSS 0.35129f $ **FLOATING
C2266 a_n2648_3264.n9 VSS 5.328f $ **FLOATING
C2267 a_n2648_3264.t6 VSS 0.37791f $ **FLOATING
C2268 a_n2648_3264.n10 VSS 4.72959f $ **FLOATING
C2269 a_n2648_3264.t15 VSS 0.35129f $ **FLOATING
C2270 a_n2648_3264.n11 VSS 5.328f $ **FLOATING
C2271 a_n2648_3264.t7 VSS 0.37791f $ **FLOATING
C2272 a_n2648_3264.n12 VSS 4.72959f $ **FLOATING
C2273 a_n2648_3264.t16 VSS 0.35129f $ **FLOATING
C2274 a_n2648_3264.n13 VSS 5.328f $ **FLOATING
C2275 a_n2648_3264.t8 VSS 0.37791f $ **FLOATING
C2276 a_n2648_3264.n14 VSS 4.72959f $ **FLOATING
C2277 a_n2648_3264.t17 VSS 0.35129f $ **FLOATING
C2278 a_n2648_3264.n15 VSS 20.3421f $ **FLOATING
C2279 a_n2648_3264.t9 VSS 0.37791f $ **FLOATING
C2280 a_n2648_3264.t1 VSS 0.16876f $ **FLOATING
C2281 a_1279_17714.t2 VSS 0.16148f $ **FLOATING
C2282 a_1279_17714.t3 VSS 0.18499f $ **FLOATING
C2283 a_1279_17714.t1 VSS 0.25339f $ **FLOATING
C2284 a_1279_17714.t0 VSS 0.25255f $ **FLOATING
C2285 a_1279_17714.n0 VSS 0.39372f $ **FLOATING
C2286 a_1279_17714.n1 VSS 0.3616f $ **FLOATING
C2287 a_1995_17639.t0 VSS 0.14783f $ **FLOATING
C2288 a_1995_17639.t2 VSS 0.13657f $ **FLOATING
C2289 a_1995_17639.t3 VSS 0.31154f $ **FLOATING
C2290 a_1995_17639.n0 VSS 0.43701f $ **FLOATING
C2291 a_1995_17639.n1 VSS 0.34227f $ **FLOATING
C2292 a_1995_17639.t1 VSS 0.1463f $ **FLOATING
C2293 a_1735_17416.t0 VSS 0.16376f $ **FLOATING
C2294 a_1735_17416.t2 VSS 0.18303f $ **FLOATING
C2295 a_1735_17416.n0 VSS 0.98409f $ **FLOATING
C2296 a_1735_17416.t1 VSS 0.18203f $ **FLOATING
C2297 a_1735_17416.t3 VSS 0.16961f $ **FLOATING
C2298 a_1735_17416.n1 VSS 1.06683f $ **FLOATING
C2299 a_2021_17734.t0 VSS 0.19099f $ **FLOATING
C2300 a_2021_17734.t4 VSS 0.24656f $ **FLOATING
C2301 a_2021_17734.n0 VSS 0.50644f $ **FLOATING
C2302 a_2021_17734.t2 VSS 0.2688f $ **FLOATING
C2303 a_2021_17734.t3 VSS 0.27105f $ **FLOATING
C2304 a_2021_17734.n1 VSS 0.81591f $ **FLOATING
C2305 a_2021_17734.t1 VSS 0.27509f $ **FLOATING
C2306 a_2021_17734.n2 VSS 0.49494f $ **FLOATING
C2307 a_2430_17673.t0 VSS 0.15438f $ **FLOATING
C2308 a_2430_17673.t3 VSS 0.59903f $ **FLOATING
C2309 a_2430_17673.n0 VSS 0.31723f $ **FLOATING
C2310 a_2430_17673.t1 VSS 0.22592f $ **FLOATING
C2311 a_2430_17673.n1 VSS 0.17968f $ **FLOATING
C2312 a_2430_17673.t2 VSS 0.24985f $ **FLOATING
C2313 a_2532_17760.t0 VSS 0.19992f $ **FLOATING
C2314 a_2532_17760.t3 VSS 0.28161f $ **FLOATING
C2315 a_2532_17760.n0 VSS 0.63221f $ **FLOATING
C2316 a_2532_17760.t1 VSS 0.30383f $ **FLOATING
C2317 a_2532_17760.t2 VSS 0.27167f $ **FLOATING
C2318 a_2532_17760.n1 VSS 0.34019f $ **FLOATING
C2319 a_1178_17417.t1 VSS 0.09016f $ **FLOATING
C2320 a_1178_17417.t0 VSS 0.09254f $ **FLOATING
C2321 a_1178_17417.t2 VSS 0.08418f $ **FLOATING
C2322 a_1178_17417.n0 VSS 0.26124f $ **FLOATING
C2323 a_3280_17493.t1 VSS 0.15436f $ **FLOATING
C2324 a_3280_17493.t2 VSS 0.77903f $ **FLOATING
C2325 a_3280_17493.n0 VSS 0.43794f $ **FLOATING
C2326 a_3280_17493.t0 VSS 0.2341f $ **FLOATING
C2327 a_3508_17633.t0 VSS 0.10822f $ **FLOATING
C2328 a_3508_17633.t1 VSS 0.10901f $ **FLOATING
C2329 a_3508_17633.n0 VSS 0.47419f $ **FLOATING
C2330 a_3508_17633.t2 VSS 0.2173f $ **FLOATING
C2331 a_4081_17694.t0 VSS 0.08657f $ **FLOATING
C2332 a_4081_17694.t2 VSS 0.28688f $ **FLOATING
C2333 a_4081_17694.t1 VSS 0.13811f $ **FLOATING
C2334 a_4081_17694.n0 VSS 0.32463f $ **FLOATING
C2335 a_7105_17794.t0 VSS 0.08911f $ **FLOATING
C2336 a_7105_17794.t2 VSS 0.29919f $ **FLOATING
C2337 a_7105_17794.t1 VSS 0.13972f $ **FLOATING
C2338 a_7105_17794.n0 VSS 0.3719f $ **FLOATING
C2339 a_2310_17429.t0 VSS 0.38743f $ **FLOATING
C2340 a_2310_17429.t1 VSS 0.44582f $ **FLOATING
C2341 a_3186_17493.t0 VSS 0.37257f $ **FLOATING
C2342 a_3186_17493.t1 VSS 0.37124f $ **FLOATING
C2343 a_5169_17490.t3 VSS 0.07442f $ **FLOATING
C2344 a_5169_17490.t6 VSS 0.07442f $ **FLOATING
C2345 a_5169_17490.n0 VSS 0.12557f $ **FLOATING
C2346 a_5169_17490.t2 VSS 0.07442f $ **FLOATING
C2347 a_5169_17490.t7 VSS 0.07442f $ **FLOATING
C2348 a_5169_17490.n1 VSS 0.16113f $ **FLOATING
C2349 a_5169_17490.t1 VSS 0.07442f $ **FLOATING
C2350 a_5169_17490.t5 VSS 0.07442f $ **FLOATING
C2351 a_5169_17490.n2 VSS 0.16113f $ **FLOATING
C2352 a_5169_17490.t0 VSS 0.07442f $ **FLOATING
C2353 a_5169_17490.t4 VSS 0.07442f $ **FLOATING
C2354 a_5169_17490.n3 VSS 0.12557f $ **FLOATING
C2355 a_7199_17794.t0 VSS 0.03717f $ **FLOATING
C2356 a_7410_17398.t0 VSS 0.13386f $ **FLOATING
C2357 a_7410_17398.t1 VSS 0.20629f $ **FLOATING
C2358 a_7410_17398.n0 VSS 0.57847f $ **FLOATING
C2359 a_7410_17398.t2 VSS 0.28249f $ **FLOATING
C2360 a_7799_17714.t0 VSS 0.16125f $ **FLOATING
C2361 a_7799_17714.t3 VSS 0.18474f $ **FLOATING
C2362 a_7799_17714.t1 VSS 0.25304f $ **FLOATING
C2363 a_7799_17714.t2 VSS 0.2522f $ **FLOATING
C2364 a_7799_17714.n0 VSS 0.39317f $ **FLOATING
C2365 a_7799_17714.n1 VSS 0.36109f $ **FLOATING
C2366 a_8515_17639.t0 VSS 0.1463f $ **FLOATING
C2367 a_8515_17639.t1 VSS 0.14782f $ **FLOATING
C2368 a_8515_17639.t2 VSS 0.13656f $ **FLOATING
C2369 a_8515_17639.t3 VSS 0.31152f $ **FLOATING
C2370 a_8515_17639.n0 VSS 0.43698f $ **FLOATING
C2371 a_8515_17639.n1 VSS 0.34225f $ **FLOATING
C2372 a_8255_17416.t0 VSS 0.16375f $ **FLOATING
C2373 a_8255_17416.t3 VSS 0.18302f $ **FLOATING
C2374 a_8255_17416.n0 VSS 0.98402f $ **FLOATING
C2375 a_8255_17416.t2 VSS 0.18202f $ **FLOATING
C2376 a_8255_17416.t1 VSS 0.1696f $ **FLOATING
C2377 a_8255_17416.n1 VSS 1.06675f $ **FLOATING
C2378 a_8541_17734.t0 VSS 0.26879f $ **FLOATING
C2379 a_8541_17734.t4 VSS 0.24655f $ **FLOATING
C2380 a_8541_17734.t3 VSS 0.27508f $ **FLOATING
C2381 a_8541_17734.n0 VSS 0.49491f $ **FLOATING
C2382 a_8541_17734.t2 VSS 0.19098f $ **FLOATING
C2383 a_8541_17734.n1 VSS 0.50641f $ **FLOATING
C2384 a_8541_17734.t1 VSS 0.27104f $ **FLOATING
C2385 a_8541_17734.n2 VSS 0.81586f $ **FLOATING
C2386 a_8950_17673.t0 VSS 0.15437f $ **FLOATING
C2387 a_8950_17673.t3 VSS 0.59901f $ **FLOATING
C2388 a_8950_17673.n0 VSS 0.31722f $ **FLOATING
C2389 a_8950_17673.t1 VSS 0.22591f $ **FLOATING
C2390 a_8950_17673.n1 VSS 0.17967f $ **FLOATING
C2391 a_8950_17673.t2 VSS 0.24984f $ **FLOATING
C2392 a_9052_17760.t0 VSS 0.19991f $ **FLOATING
C2393 a_9052_17760.t3 VSS 0.28161f $ **FLOATING
C2394 a_9052_17760.n0 VSS 0.6322f $ **FLOATING
C2395 a_9052_17760.t1 VSS 0.30382f $ **FLOATING
C2396 a_9052_17760.t2 VSS 0.27167f $ **FLOATING
C2397 a_9052_17760.n1 VSS 0.34018f $ **FLOATING
C2398 a_7698_17417.t1 VSS 0.08404f $ **FLOATING
C2399 a_7698_17417.n0 VSS 0.2608f $ **FLOATING
C2400 a_7698_17417.t0 VSS 0.09001f $ **FLOATING
C2401 a_7698_17417.t2 VSS 0.09239f $ **FLOATING
C2402 a_9800_17493.t0 VSS 0.15436f $ **FLOATING
C2403 a_9800_17493.t2 VSS 0.77903f $ **FLOATING
C2404 a_9800_17493.n0 VSS 0.43794f $ **FLOATING
C2405 a_9800_17493.t1 VSS 0.2341f $ **FLOATING
C2406 a_10028_17633.t0 VSS 0.10822f $ **FLOATING
C2407 a_10028_17633.t1 VSS 0.10901f $ **FLOATING
C2408 a_10028_17633.n0 VSS 0.47419f $ **FLOATING
C2409 a_10028_17633.t2 VSS 0.2173f $ **FLOATING
C2410 a_10601_17694.t0 VSS 0.08657f $ **FLOATING
C2411 a_10601_17694.t2 VSS 0.28688f $ **FLOATING
C2412 a_10601_17694.t1 VSS 0.13811f $ **FLOATING
C2413 a_10601_17694.n0 VSS 0.32463f $ **FLOATING
C2414 a_13625_17794.t0 VSS 0.08923f $ **FLOATING
C2415 a_13625_17794.t2 VSS 0.2996f $ **FLOATING
C2416 a_13625_17794.t1 VSS 0.13991f $ **FLOATING
C2417 a_13625_17794.n0 VSS 0.37241f $ **FLOATING
C2418 a_8830_17429.t0 VSS 0.44581f $ **FLOATING
C2419 a_8830_17429.t1 VSS 0.38742f $ **FLOATING
C2420 a_9706_17493.t0 VSS 0.37124f $ **FLOATING
C2421 a_9706_17493.t1 VSS 0.37257f $ **FLOATING
C2422 a_11689_17490.t3 VSS 0.07443f $ **FLOATING
C2423 a_11689_17490.t4 VSS 0.07443f $ **FLOATING
C2424 a_11689_17490.n0 VSS 0.12558f $ **FLOATING
C2425 a_11689_17490.t2 VSS 0.07443f $ **FLOATING
C2426 a_11689_17490.t5 VSS 0.07443f $ **FLOATING
C2427 a_11689_17490.n1 VSS 0.16114f $ **FLOATING
C2428 a_11689_17490.t1 VSS 0.07443f $ **FLOATING
C2429 a_11689_17490.t7 VSS 0.07443f $ **FLOATING
C2430 a_11689_17490.n2 VSS 0.16114f $ **FLOATING
C2431 a_11689_17490.t0 VSS 0.07443f $ **FLOATING
C2432 a_11689_17490.t6 VSS 0.07443f $ **FLOATING
C2433 a_11689_17490.n3 VSS 0.12558f $ **FLOATING
C2434 a_13719_17794.t0 VSS 0.0372f $ **FLOATING
C2435 a_13930_17398.t0 VSS 0.13402f $ **FLOATING
C2436 a_13930_17398.t1 VSS 0.20653f $ **FLOATING
C2437 a_13930_17398.n0 VSS 0.57914f $ **FLOATING
C2438 a_13930_17398.t2 VSS 0.28282f $ **FLOATING
C2439 a_14319_17714.t1 VSS 0.16102f $ **FLOATING
C2440 a_14319_17714.t3 VSS 0.18448f $ **FLOATING
C2441 a_14319_17714.t2 VSS 0.25268f $ **FLOATING
C2442 a_14319_17714.t0 VSS 0.25185f $ **FLOATING
C2443 a_14319_17714.n0 VSS 0.39262f $ **FLOATING
C2444 a_14319_17714.n1 VSS 0.36058f $ **FLOATING
C2445 a_15035_17639.t0 VSS 0.14781f $ **FLOATING
C2446 a_15035_17639.t2 VSS 0.13656f $ **FLOATING
C2447 a_15035_17639.t3 VSS 0.3115f $ **FLOATING
C2448 a_15035_17639.n0 VSS 0.43696f $ **FLOATING
C2449 a_15035_17639.n1 VSS 0.34223f $ **FLOATING
C2450 a_15035_17639.t1 VSS 0.14629f $ **FLOATING
C2451 a_14775_17416.t0 VSS 0.16374f $ **FLOATING
C2452 a_14775_17416.t2 VSS 0.183f $ **FLOATING
C2453 a_14775_17416.n0 VSS 0.98395f $ **FLOATING
C2454 a_14775_17416.t1 VSS 0.182f $ **FLOATING
C2455 a_14775_17416.t3 VSS 0.16959f $ **FLOATING
C2456 a_14775_17416.n1 VSS 1.06667f $ **FLOATING
C2457 a_15061_17734.t0 VSS 0.26877f $ **FLOATING
C2458 a_15061_17734.t4 VSS 0.24653f $ **FLOATING
C2459 a_15061_17734.t2 VSS 0.27506f $ **FLOATING
C2460 a_15061_17734.n0 VSS 0.49488f $ **FLOATING
C2461 a_15061_17734.t1 VSS 0.19097f $ **FLOATING
C2462 a_15061_17734.n1 VSS 0.50638f $ **FLOATING
C2463 a_15061_17734.t3 VSS 0.27102f $ **FLOATING
C2464 a_15061_17734.n2 VSS 0.81582f $ **FLOATING
C2465 a_15470_17673.t0 VSS 0.15436f $ **FLOATING
C2466 a_15470_17673.t3 VSS 0.59896f $ **FLOATING
C2467 a_15470_17673.n0 VSS 0.3172f $ **FLOATING
C2468 a_15470_17673.t1 VSS 0.22589f $ **FLOATING
C2469 a_15470_17673.n1 VSS 0.17966f $ **FLOATING
C2470 a_15470_17673.t2 VSS 0.24982f $ **FLOATING
C2471 a_15572_17760.t0 VSS 0.19991f $ **FLOATING
C2472 a_15572_17760.t3 VSS 0.2816f $ **FLOATING
C2473 a_15572_17760.n0 VSS 0.63219f $ **FLOATING
C2474 a_15572_17760.t1 VSS 0.30382f $ **FLOATING
C2475 a_15572_17760.t2 VSS 0.27166f $ **FLOATING
C2476 a_15572_17760.n1 VSS 0.34018f $ **FLOATING
C2477 a_14218_17417.t1 VSS 0.08985f $ **FLOATING
C2478 a_14218_17417.t0 VSS 0.09223f $ **FLOATING
C2479 a_14218_17417.t2 VSS 0.08389f $ **FLOATING
C2480 a_14218_17417.n0 VSS 0.26035f $ **FLOATING
C2481 a_16320_17493.t1 VSS 0.15436f $ **FLOATING
C2482 a_16320_17493.t2 VSS 0.77903f $ **FLOATING
C2483 a_16320_17493.n0 VSS 0.43794f $ **FLOATING
C2484 a_16320_17493.t0 VSS 0.2341f $ **FLOATING
C2485 a_16548_17633.t0 VSS 0.10822f $ **FLOATING
C2486 a_16548_17633.t1 VSS 0.10901f $ **FLOATING
C2487 a_16548_17633.n0 VSS 0.47419f $ **FLOATING
C2488 a_16548_17633.t2 VSS 0.2173f $ **FLOATING
C2489 a_17121_17694.t0 VSS 0.08657f $ **FLOATING
C2490 a_17121_17694.t2 VSS 0.28688f $ **FLOATING
C2491 a_17121_17694.t1 VSS 0.13811f $ **FLOATING
C2492 a_17121_17694.n0 VSS 0.32463f $ **FLOATING
C2493 a_20145_17794.t0 VSS 0.08909f $ **FLOATING
C2494 a_20145_17794.t2 VSS 0.29913f $ **FLOATING
C2495 a_20145_17794.t1 VSS 0.13969f $ **FLOATING
C2496 a_20145_17794.n0 VSS 0.37182f $ **FLOATING
C2497 a_15350_17429.t0 VSS 0.44579f $ **FLOATING
C2498 a_15350_17429.t1 VSS 0.38741f $ **FLOATING
C2499 a_16226_17493.t0 VSS 0.37257f $ **FLOATING
C2500 a_16226_17493.t1 VSS 0.37124f $ **FLOATING
C2501 a_18209_17490.t3 VSS 0.07442f $ **FLOATING
C2502 a_18209_17490.t4 VSS 0.07442f $ **FLOATING
C2503 a_18209_17490.n0 VSS 0.12557f $ **FLOATING
C2504 a_18209_17490.t2 VSS 0.07442f $ **FLOATING
C2505 a_18209_17490.t7 VSS 0.07442f $ **FLOATING
C2506 a_18209_17490.n1 VSS 0.16113f $ **FLOATING
C2507 a_18209_17490.t1 VSS 0.07442f $ **FLOATING
C2508 a_18209_17490.t6 VSS 0.07442f $ **FLOATING
C2509 a_18209_17490.n2 VSS 0.16113f $ **FLOATING
C2510 a_18209_17490.t0 VSS 0.07442f $ **FLOATING
C2511 a_18209_17490.t5 VSS 0.07442f $ **FLOATING
C2512 a_18209_17490.n3 VSS 0.12557f $ **FLOATING
C2513 a_20239_17794.t0 VSS 0.03716f $ **FLOATING
C2514 a_20450_17398.t0 VSS 0.13387f $ **FLOATING
C2515 a_20450_17398.t1 VSS 0.2063f $ **FLOATING
C2516 a_20450_17398.n0 VSS 0.5785f $ **FLOATING
C2517 a_20450_17398.t2 VSS 0.28251f $ **FLOATING
C2518 a_20839_17714.t1 VSS 0.16136f $ **FLOATING
C2519 a_20839_17714.t3 VSS 0.18487f $ **FLOATING
C2520 a_20839_17714.t2 VSS 0.25321f $ **FLOATING
C2521 a_20839_17714.t0 VSS 0.25238f $ **FLOATING
C2522 a_20839_17714.n0 VSS 0.39345f $ **FLOATING
C2523 a_20839_17714.n1 VSS 0.36134f $ **FLOATING
C2524 a_21555_17639.t0 VSS 0.14783f $ **FLOATING
C2525 a_21555_17639.t2 VSS 0.13657f $ **FLOATING
C2526 a_21555_17639.t3 VSS 0.31153f $ **FLOATING
C2527 a_21555_17639.n0 VSS 0.43699f $ **FLOATING
C2528 a_21555_17639.n1 VSS 0.34226f $ **FLOATING
C2529 a_21555_17639.t1 VSS 0.1463f $ **FLOATING
C2530 a_21295_17416.t0 VSS 0.18202f $ **FLOATING
C2531 a_21295_17416.t1 VSS 0.18302f $ **FLOATING
C2532 a_21295_17416.n0 VSS 0.98405f $ **FLOATING
C2533 a_21295_17416.t2 VSS 0.16376f $ **FLOATING
C2534 a_21295_17416.n1 VSS 1.06679f $ **FLOATING
C2535 a_21295_17416.t3 VSS 0.1696f $ **FLOATING
C2536 a_21581_17734.t0 VSS 0.19099f $ **FLOATING
C2537 a_21581_17734.t4 VSS 0.24655f $ **FLOATING
C2538 a_21581_17734.n0 VSS 0.50643f $ **FLOATING
C2539 a_21581_17734.t2 VSS 0.2688f $ **FLOATING
C2540 a_21581_17734.t3 VSS 0.27104f $ **FLOATING
C2541 a_21581_17734.n1 VSS 0.81589f $ **FLOATING
C2542 a_21581_17734.t1 VSS 0.27508f $ **FLOATING
C2543 a_21581_17734.n2 VSS 0.49493f $ **FLOATING
C2544 a_21990_17673.t0 VSS 0.15437f $ **FLOATING
C2545 a_21990_17673.t3 VSS 0.59902f $ **FLOATING
C2546 a_21990_17673.n0 VSS 0.31723f $ **FLOATING
C2547 a_21990_17673.t1 VSS 0.22591f $ **FLOATING
C2548 a_21990_17673.n1 VSS 0.17967f $ **FLOATING
C2549 a_21990_17673.t2 VSS 0.24985f $ **FLOATING
C2550 a_22092_17760.t0 VSS 0.19991f $ **FLOATING
C2551 a_22092_17760.t3 VSS 0.28161f $ **FLOATING
C2552 a_22092_17760.n0 VSS 0.63221f $ **FLOATING
C2553 a_22092_17760.t1 VSS 0.30383f $ **FLOATING
C2554 a_22092_17760.t2 VSS 0.27167f $ **FLOATING
C2555 a_22092_17760.n1 VSS 0.34019f $ **FLOATING
C2556 a_20738_17417.t1 VSS 0.0901f $ **FLOATING
C2557 a_20738_17417.t0 VSS 0.09248f $ **FLOATING
C2558 a_20738_17417.t2 VSS 0.08412f $ **FLOATING
C2559 a_20738_17417.n0 VSS 0.26107f $ **FLOATING
C2560 a_22840_17493.t0 VSS 0.15436f $ **FLOATING
C2561 a_22840_17493.t2 VSS 0.77903f $ **FLOATING
C2562 a_22840_17493.n0 VSS 0.43794f $ **FLOATING
C2563 a_22840_17493.t1 VSS 0.2341f $ **FLOATING
C2564 a_23068_17633.t0 VSS 0.10822f $ **FLOATING
C2565 a_23068_17633.t1 VSS 0.10901f $ **FLOATING
C2566 a_23068_17633.n0 VSS 0.47419f $ **FLOATING
C2567 a_23068_17633.t2 VSS 0.2173f $ **FLOATING
C2568 a_23641_17694.t0 VSS 0.08657f $ **FLOATING
C2569 a_23641_17694.t2 VSS 0.28688f $ **FLOATING
C2570 a_23641_17694.t1 VSS 0.13811f $ **FLOATING
C2571 a_23641_17694.n0 VSS 0.32463f $ **FLOATING
C2572 a_26665_17794.t0 VSS 0.08913f $ **FLOATING
C2573 a_26665_17794.t2 VSS 0.29926f $ **FLOATING
C2574 a_26665_17794.t1 VSS 0.13975f $ **FLOATING
C2575 a_26665_17794.n0 VSS 0.37199f $ **FLOATING
C2576 a_21870_17429.t0 VSS 0.44581f $ **FLOATING
C2577 a_21870_17429.t1 VSS 0.38743f $ **FLOATING
C2578 a_22746_17493.t0 VSS 0.37124f $ **FLOATING
C2579 a_22746_17493.t1 VSS 0.37257f $ **FLOATING
C2580 a_24729_17490.t3 VSS 0.07443f $ **FLOATING
C2581 a_24729_17490.t4 VSS 0.07442f $ **FLOATING
C2582 a_24729_17490.n0 VSS 0.12557f $ **FLOATING
C2583 a_24729_17490.t2 VSS 0.07443f $ **FLOATING
C2584 a_24729_17490.t7 VSS 0.07442f $ **FLOATING
C2585 a_24729_17490.n1 VSS 0.16114f $ **FLOATING
C2586 a_24729_17490.t1 VSS 0.07443f $ **FLOATING
C2587 a_24729_17490.t6 VSS 0.07442f $ **FLOATING
C2588 a_24729_17490.n2 VSS 0.16114f $ **FLOATING
C2589 a_24729_17490.t0 VSS 0.07443f $ **FLOATING
C2590 a_24729_17490.t5 VSS 0.07443f $ **FLOATING
C2591 a_24729_17490.n3 VSS 0.12557f $ **FLOATING
C2592 a_26759_17794.t0 VSS 0.03718f $ **FLOATING
C2593 a_26970_17398.t0 VSS 0.13394f $ **FLOATING
C2594 a_26970_17398.t1 VSS 0.20641f $ **FLOATING
C2595 a_26970_17398.n0 VSS 0.57881f $ **FLOATING
C2596 a_26970_17398.t2 VSS 0.28266f $ **FLOATING
C2597 a_27359_17714.t1 VSS 0.16114f $ **FLOATING
C2598 a_27359_17714.t3 VSS 0.18461f $ **FLOATING
C2599 a_27359_17714.t0 VSS 0.25286f $ **FLOATING
C2600 a_27359_17714.t2 VSS 0.25202f $ **FLOATING
C2601 a_27359_17714.n0 VSS 0.3929f $ **FLOATING
C2602 a_27359_17714.n1 VSS 0.36084f $ **FLOATING
C2603 a_28075_17639.t0 VSS 0.14629f $ **FLOATING
C2604 a_28075_17639.t1 VSS 0.14782f $ **FLOATING
C2605 a_28075_17639.t2 VSS 0.13656f $ **FLOATING
C2606 a_28075_17639.t3 VSS 0.31151f $ **FLOATING
C2607 a_28075_17639.n0 VSS 0.43697f $ **FLOATING
C2608 a_28075_17639.n1 VSS 0.34224f $ **FLOATING
C2609 a_27815_17416.t0 VSS 0.16375f $ **FLOATING
C2610 a_27815_17416.t2 VSS 0.18301f $ **FLOATING
C2611 a_27815_17416.n0 VSS 0.98398f $ **FLOATING
C2612 a_27815_17416.t3 VSS 0.18201f $ **FLOATING
C2613 a_27815_17416.t1 VSS 0.16959f $ **FLOATING
C2614 a_27815_17416.n1 VSS 1.06671f $ **FLOATING
C2615 a_28101_17734.t0 VSS 0.26878f $ **FLOATING
C2616 a_28101_17734.t4 VSS 0.24654f $ **FLOATING
C2617 a_28101_17734.t3 VSS 0.27507f $ **FLOATING
C2618 a_28101_17734.n0 VSS 0.4949f $ **FLOATING
C2619 a_28101_17734.t2 VSS 0.19098f $ **FLOATING
C2620 a_28101_17734.n1 VSS 0.5064f $ **FLOATING
C2621 a_28101_17734.t1 VSS 0.27103f $ **FLOATING
C2622 a_28101_17734.n2 VSS 0.81584f $ **FLOATING
C2623 a_28510_17673.t0 VSS 0.15436f $ **FLOATING
C2624 a_28510_17673.t3 VSS 0.59898f $ **FLOATING
C2625 a_28510_17673.n0 VSS 0.31721f $ **FLOATING
C2626 a_28510_17673.t1 VSS 0.2259f $ **FLOATING
C2627 a_28510_17673.n1 VSS 0.17966f $ **FLOATING
C2628 a_28510_17673.t2 VSS 0.24983f $ **FLOATING
C2629 a_28612_17760.t0 VSS 0.19991f $ **FLOATING
C2630 a_28612_17760.t3 VSS 0.2816f $ **FLOATING
C2631 a_28612_17760.n0 VSS 0.63219f $ **FLOATING
C2632 a_28612_17760.t1 VSS 0.30382f $ **FLOATING
C2633 a_28612_17760.t2 VSS 0.27167f $ **FLOATING
C2634 a_28612_17760.n1 VSS 0.34018f $ **FLOATING
C2635 a_27258_17417.t1 VSS 0.08397f $ **FLOATING
C2636 a_27258_17417.n0 VSS 0.26059f $ **FLOATING
C2637 a_27258_17417.t0 VSS 0.08994f $ **FLOATING
C2638 a_27258_17417.t2 VSS 0.09232f $ **FLOATING
C2639 a_29360_17493.t1 VSS 0.15436f $ **FLOATING
C2640 a_29360_17493.t2 VSS 0.77903f $ **FLOATING
C2641 a_29360_17493.n0 VSS 0.43794f $ **FLOATING
C2642 a_29360_17493.t0 VSS 0.2341f $ **FLOATING
C2643 a_29588_17633.t0 VSS 0.10901f $ **FLOATING
C2644 a_29588_17633.t2 VSS 0.2173f $ **FLOATING
C2645 a_29588_17633.t1 VSS 0.10822f $ **FLOATING
C2646 a_29588_17633.n0 VSS 0.47419f $ **FLOATING
C2647 a_30161_17694.t0 VSS 0.08657f $ **FLOATING
C2648 a_30161_17694.t2 VSS 0.28688f $ **FLOATING
C2649 a_30161_17694.t1 VSS 0.13811f $ **FLOATING
C2650 a_30161_17694.n0 VSS 0.32463f $ **FLOATING
C2651 a_33185_17794.t0 VSS 0.08902f $ **FLOATING
C2652 a_33185_17794.t2 VSS 0.2989f $ **FLOATING
C2653 a_33185_17794.t1 VSS 0.13958f $ **FLOATING
C2654 a_33185_17794.n0 VSS 0.37154f $ **FLOATING
C2655 a_28390_17429.t0 VSS 0.4458f $ **FLOATING
C2656 a_28390_17429.t1 VSS 0.38742f $ **FLOATING
C2657 a_29266_17493.t0 VSS 0.37124f $ **FLOATING
C2658 a_29266_17493.t1 VSS 0.37257f $ **FLOATING
C2659 a_31249_17490.t3 VSS 0.07442f $ **FLOATING
C2660 a_31249_17490.t6 VSS 0.07442f $ **FLOATING
C2661 a_31249_17490.n0 VSS 0.12556f $ **FLOATING
C2662 a_31249_17490.t2 VSS 0.07442f $ **FLOATING
C2663 a_31249_17490.t7 VSS 0.07442f $ **FLOATING
C2664 a_31249_17490.n1 VSS 0.16112f $ **FLOATING
C2665 a_31249_17490.t1 VSS 0.07442f $ **FLOATING
C2666 a_31249_17490.t5 VSS 0.07442f $ **FLOATING
C2667 a_31249_17490.n2 VSS 0.16112f $ **FLOATING
C2668 a_31249_17490.t0 VSS 0.07442f $ **FLOATING
C2669 a_31249_17490.t4 VSS 0.07442f $ **FLOATING
C2670 a_31249_17490.n3 VSS 0.12556f $ **FLOATING
C2671 a_33279_17794.t0 VSS 0.03712f $ **FLOATING
C2672 a_33490_17398.t0 VSS 0.13421f $ **FLOATING
C2673 a_33490_17398.t1 VSS 0.20682f $ **FLOATING
C2674 a_33490_17398.n0 VSS 0.57996f $ **FLOATING
C2675 a_33490_17398.t2 VSS 0.28322f $ **FLOATING
C2676 a_33879_17714.t1 VSS 0.16195f $ **FLOATING
C2677 a_33879_17714.t3 VSS 0.18553f $ **FLOATING
C2678 a_33879_17714.t2 VSS 0.25413f $ **FLOATING
C2679 a_33879_17714.t0 VSS 0.25329f $ **FLOATING
C2680 a_33879_17714.n0 VSS 0.39487f $ **FLOATING
C2681 a_33879_17714.n1 VSS 0.36265f $ **FLOATING
C2682 a_34595_17639.t0 VSS 0.14632f $ **FLOATING
C2683 a_34595_17639.t1 VSS 0.14784f $ **FLOATING
C2684 a_34595_17639.t2 VSS 0.13658f $ **FLOATING
C2685 a_34595_17639.t3 VSS 0.31156f $ **FLOATING
C2686 a_34595_17639.n0 VSS 0.43705f $ **FLOATING
C2687 a_34595_17639.n1 VSS 0.3423f $ **FLOATING
C2688 a_34335_17416.t0 VSS 0.16378f $ **FLOATING
C2689 a_34335_17416.t3 VSS 0.18305f $ **FLOATING
C2690 a_34335_17416.n0 VSS 0.98421f $ **FLOATING
C2691 a_34335_17416.t2 VSS 0.18205f $ **FLOATING
C2692 a_34335_17416.t1 VSS 0.16963f $ **FLOATING
C2693 a_34335_17416.n1 VSS 1.06696f $ **FLOATING
C2694 a_34621_17734.t0 VSS 0.26883f $ **FLOATING
C2695 a_34621_17734.t4 VSS 0.24658f $ **FLOATING
C2696 a_34621_17734.t3 VSS 0.27512f $ **FLOATING
C2697 a_34621_17734.n0 VSS 0.49499f $ **FLOATING
C2698 a_34621_17734.t2 VSS 0.19101f $ **FLOATING
C2699 a_34621_17734.n1 VSS 0.50649f $ **FLOATING
C2700 a_34621_17734.t1 VSS 0.27108f $ **FLOATING
C2701 a_34621_17734.n2 VSS 0.81599f $ **FLOATING
C2702 a_35030_17673.t0 VSS 0.15438f $ **FLOATING
C2703 a_35030_17673.t3 VSS 0.59906f $ **FLOATING
C2704 a_35030_17673.n0 VSS 0.31725f $ **FLOATING
C2705 a_35030_17673.t1 VSS 0.22593f $ **FLOATING
C2706 a_35030_17673.n1 VSS 0.17969f $ **FLOATING
C2707 a_35030_17673.t2 VSS 0.24986f $ **FLOATING
C2708 a_35132_17760.t0 VSS 0.19992f $ **FLOATING
C2709 a_35132_17760.t3 VSS 0.28162f $ **FLOATING
C2710 a_35132_17760.n0 VSS 0.63224f $ **FLOATING
C2711 a_35132_17760.t1 VSS 0.30384f $ **FLOATING
C2712 a_35132_17760.t2 VSS 0.27168f $ **FLOATING
C2713 a_35132_17760.n1 VSS 0.3402f $ **FLOATING
C2714 a_33778_17417.t1 VSS 0.09057f $ **FLOATING
C2715 a_33778_17417.t0 VSS 0.09296f $ **FLOATING
C2716 a_33778_17417.t2 VSS 0.08456f $ **FLOATING
C2717 a_33778_17417.n0 VSS 0.26242f $ **FLOATING
C2718 a_35880_17493.t1 VSS 0.15436f $ **FLOATING
C2719 a_35880_17493.t2 VSS 0.77903f $ **FLOATING
C2720 a_35880_17493.n0 VSS 0.43794f $ **FLOATING
C2721 a_35880_17493.t0 VSS 0.2341f $ **FLOATING
C2722 a_36108_17633.t0 VSS 0.10901f $ **FLOATING
C2723 a_36108_17633.t2 VSS 0.2173f $ **FLOATING
C2724 a_36108_17633.t1 VSS 0.10822f $ **FLOATING
C2725 a_36108_17633.n0 VSS 0.47419f $ **FLOATING
C2726 a_36681_17694.t0 VSS 0.08657f $ **FLOATING
C2727 a_36681_17694.t2 VSS 0.28688f $ **FLOATING
C2728 a_36681_17694.t1 VSS 0.13811f $ **FLOATING
C2729 a_36681_17694.n0 VSS 0.32463f $ **FLOATING
C2730 a_39705_17794.t0 VSS 0.08905f $ **FLOATING
C2731 a_39705_17794.t2 VSS 0.29902f $ **FLOATING
C2732 a_39705_17794.t1 VSS 0.13963f $ **FLOATING
C2733 a_39705_17794.n0 VSS 0.37168f $ **FLOATING
C2734 a_34910_17429.t0 VSS 0.44584f $ **FLOATING
C2735 a_34910_17429.t1 VSS 0.38745f $ **FLOATING
C2736 a_35786_17493.t0 VSS 0.37257f $ **FLOATING
C2737 a_35786_17493.t1 VSS 0.37124f $ **FLOATING
C2738 a_37769_17490.t3 VSS 0.07442f $ **FLOATING
C2739 a_37769_17490.t6 VSS 0.07442f $ **FLOATING
C2740 a_37769_17490.n0 VSS 0.12557f $ **FLOATING
C2741 a_37769_17490.t2 VSS 0.07442f $ **FLOATING
C2742 a_37769_17490.t7 VSS 0.07442f $ **FLOATING
C2743 a_37769_17490.n1 VSS 0.16113f $ **FLOATING
C2744 a_37769_17490.t1 VSS 0.07442f $ **FLOATING
C2745 a_37769_17490.t5 VSS 0.07442f $ **FLOATING
C2746 a_37769_17490.n2 VSS 0.16113f $ **FLOATING
C2747 a_37769_17490.t0 VSS 0.07442f $ **FLOATING
C2748 a_37769_17490.t4 VSS 0.07442f $ **FLOATING
C2749 a_37769_17490.n3 VSS 0.12557f $ **FLOATING
C2750 a_39799_17794.t0 VSS 0.03714f $ **FLOATING
C2751 a_40010_17398.t0 VSS 0.13399f $ **FLOATING
C2752 a_40010_17398.t1 VSS 0.20648f $ **FLOATING
C2753 a_40010_17398.n0 VSS 0.57902f $ **FLOATING
C2754 a_40010_17398.t2 VSS 0.28276f $ **FLOATING
C2755 a_40399_17714.t0 VSS 0.16162f $ **FLOATING
C2756 a_40399_17714.t3 VSS 0.18516f $ **FLOATING
C2757 a_40399_17714.t1 VSS 0.25362f $ **FLOATING
C2758 a_40399_17714.t2 VSS 0.25278f $ **FLOATING
C2759 a_40399_17714.n0 VSS 0.39408f $ **FLOATING
C2760 a_40399_17714.n1 VSS 0.36193f $ **FLOATING
C2761 a_41115_17639.t0 VSS 0.13658f $ **FLOATING
C2762 a_41115_17639.t3 VSS 0.31154f $ **FLOATING
C2763 a_41115_17639.t1 VSS 0.14783f $ **FLOATING
C2764 a_41115_17639.t2 VSS 0.14631f $ **FLOATING
C2765 a_41115_17639.n0 VSS 0.34228f $ **FLOATING
C2766 a_41115_17639.n1 VSS 0.43702f $ **FLOATING
C2767 a_40855_17416.t0 VSS 0.18304f $ **FLOATING
C2768 a_40855_17416.t2 VSS 0.16377f $ **FLOATING
C2769 a_40855_17416.n0 VSS 1.06687f $ **FLOATING
C2770 a_40855_17416.t3 VSS 0.16962f $ **FLOATING
C2771 a_40855_17416.t1 VSS 0.18204f $ **FLOATING
C2772 a_40855_17416.n1 VSS 0.98413f $ **FLOATING
C2773 a_41141_17734.t0 VSS 0.191f $ **FLOATING
C2774 a_41141_17734.t4 VSS 0.24657f $ **FLOATING
C2775 a_41141_17734.n0 VSS 0.50646f $ **FLOATING
C2776 a_41141_17734.t2 VSS 0.26881f $ **FLOATING
C2777 a_41141_17734.t3 VSS 0.27106f $ **FLOATING
C2778 a_41141_17734.n1 VSS 0.81594f $ **FLOATING
C2779 a_41141_17734.t1 VSS 0.2751f $ **FLOATING
C2780 a_41141_17734.n2 VSS 0.49496f $ **FLOATING
C2781 a_41550_17673.t0 VSS 0.15438f $ **FLOATING
C2782 a_41550_17673.t3 VSS 0.59904f $ **FLOATING
C2783 a_41550_17673.n0 VSS 0.31724f $ **FLOATING
C2784 a_41550_17673.t1 VSS 0.22592f $ **FLOATING
C2785 a_41550_17673.n1 VSS 0.17968f $ **FLOATING
C2786 a_41550_17673.t2 VSS 0.24985f $ **FLOATING
C2787 a_41652_17760.t0 VSS 0.19992f $ **FLOATING
C2788 a_41652_17760.t3 VSS 0.28161f $ **FLOATING
C2789 a_41652_17760.n0 VSS 0.63222f $ **FLOATING
C2790 a_41652_17760.t1 VSS 0.30383f $ **FLOATING
C2791 a_41652_17760.t2 VSS 0.27168f $ **FLOATING
C2792 a_41652_17760.n1 VSS 0.3402f $ **FLOATING
C2793 a_40298_17417.t1 VSS 0.08429f $ **FLOATING
C2794 a_40298_17417.n0 VSS 0.2616f $ **FLOATING
C2795 a_40298_17417.t0 VSS 0.09028f $ **FLOATING
C2796 a_40298_17417.t2 VSS 0.09267f $ **FLOATING
C2797 a_42400_17493.t1 VSS 0.15436f $ **FLOATING
C2798 a_42400_17493.t2 VSS 0.77903f $ **FLOATING
C2799 a_42400_17493.n0 VSS 0.43794f $ **FLOATING
C2800 a_42400_17493.t0 VSS 0.2341f $ **FLOATING
C2801 a_42628_17633.t0 VSS 0.10901f $ **FLOATING
C2802 a_42628_17633.t2 VSS 0.2173f $ **FLOATING
C2803 a_42628_17633.t1 VSS 0.10822f $ **FLOATING
C2804 a_42628_17633.n0 VSS 0.47419f $ **FLOATING
C2805 a_43201_17694.t0 VSS 0.08657f $ **FLOATING
C2806 a_43201_17694.t2 VSS 0.28688f $ **FLOATING
C2807 a_43201_17694.t1 VSS 0.13811f $ **FLOATING
C2808 a_43201_17694.n0 VSS 0.32463f $ **FLOATING
C2809 a_46225_17794.t0 VSS 0.06994f $ **FLOATING
C2810 a_46225_17794.t2 VSS 0.23484f $ **FLOATING
C2811 a_46225_17794.t1 VSS 0.10966f $ **FLOATING
C2812 a_46225_17794.n0 VSS 0.29191f $ **FLOATING
C2813 a_41430_17429.t0 VSS 0.44583f $ **FLOATING
C2814 a_41430_17429.t1 VSS 0.38744f $ **FLOATING
C2815 a_42306_17493.t0 VSS 0.37257f $ **FLOATING
C2816 a_42306_17493.t1 VSS 0.37124f $ **FLOATING
C2817 a_44289_17490.t3 VSS 0.07416f $ **FLOATING
C2818 a_44289_17490.t4 VSS 0.07416f $ **FLOATING
C2819 a_44289_17490.n0 VSS 0.12512f $ **FLOATING
C2820 a_44289_17490.t2 VSS 0.07416f $ **FLOATING
C2821 a_44289_17490.t5 VSS 0.07416f $ **FLOATING
C2822 a_44289_17490.n1 VSS 0.16056f $ **FLOATING
C2823 a_44289_17490.t1 VSS 0.07416f $ **FLOATING
C2824 a_44289_17490.t7 VSS 0.07416f $ **FLOATING
C2825 a_44289_17490.n2 VSS 0.16056f $ **FLOATING
C2826 a_44289_17490.t0 VSS 0.07416f $ **FLOATING
C2827 a_44289_17490.t6 VSS 0.07416f $ **FLOATING
C2828 a_44289_17490.n3 VSS 0.12512f $ **FLOATING
C2829 a_46530_17398.t0 VSS 0.13273f $ **FLOATING
C2830 a_46530_17398.t1 VSS 0.20455f $ **FLOATING
C2831 a_46530_17398.n0 VSS 0.5736f $ **FLOATING
C2832 a_46530_17398.t2 VSS 0.28011f $ **FLOATING
C2833 a_46919_17714.t0 VSS 0.16161f $ **FLOATING
C2834 a_46919_17714.t3 VSS 0.18515f $ **FLOATING
C2835 a_46919_17714.t1 VSS 0.2536f $ **FLOATING
C2836 a_46919_17714.t2 VSS 0.25276f $ **FLOATING
C2837 a_46919_17714.n0 VSS 0.39405f $ **FLOATING
C2838 a_46919_17714.n1 VSS 0.36189f $ **FLOATING
C2839 a_47635_17639.t0 VSS 0.14631f $ **FLOATING
C2840 a_47635_17639.t1 VSS 0.14783f $ **FLOATING
C2841 a_47635_17639.t2 VSS 0.13658f $ **FLOATING
C2842 a_47635_17639.t3 VSS 0.31154f $ **FLOATING
C2843 a_47635_17639.n0 VSS 0.43702f $ **FLOATING
C2844 a_47635_17639.n1 VSS 0.34228f $ **FLOATING
C2845 a_47375_17416.t0 VSS 0.16962f $ **FLOATING
C2846 a_47375_17416.t2 VSS 0.16377f $ **FLOATING
C2847 a_47375_17416.n0 VSS 1.06687f $ **FLOATING
C2848 a_47375_17416.t1 VSS 0.18304f $ **FLOATING
C2849 a_47375_17416.n1 VSS 0.98413f $ **FLOATING
C2850 a_47375_17416.t3 VSS 0.18204f $ **FLOATING
C2851 a_47661_17734.t1 VSS 0.26881f $ **FLOATING
C2852 a_47661_17734.t4 VSS 0.24657f $ **FLOATING
C2853 a_47661_17734.t3 VSS 0.2751f $ **FLOATING
C2854 a_47661_17734.n0 VSS 0.49496f $ **FLOATING
C2855 a_47661_17734.t2 VSS 0.191f $ **FLOATING
C2856 a_47661_17734.n1 VSS 0.50646f $ **FLOATING
C2857 a_47661_17734.t0 VSS 0.27106f $ **FLOATING
C2858 a_47661_17734.n2 VSS 0.81594f $ **FLOATING
C2859 a_48070_17673.t0 VSS 0.15438f $ **FLOATING
C2860 a_48070_17673.t3 VSS 0.59904f $ **FLOATING
C2861 a_48070_17673.n0 VSS 0.31724f $ **FLOATING
C2862 a_48070_17673.t1 VSS 0.22592f $ **FLOATING
C2863 a_48070_17673.n1 VSS 0.17968f $ **FLOATING
C2864 a_48070_17673.t2 VSS 0.24985f $ **FLOATING
C2865 a_48172_17760.t0 VSS 0.19992f $ **FLOATING
C2866 a_48172_17760.t3 VSS 0.28161f $ **FLOATING
C2867 a_48172_17760.n0 VSS 0.63222f $ **FLOATING
C2868 a_48172_17760.t1 VSS 0.30383f $ **FLOATING
C2869 a_48172_17760.t2 VSS 0.27168f $ **FLOATING
C2870 a_48172_17760.n1 VSS 0.3402f $ **FLOATING
C2871 a_46818_17417.t1 VSS 0.08413f $ **FLOATING
C2872 a_46818_17417.n0 VSS 0.2611f $ **FLOATING
C2873 a_46818_17417.t0 VSS 0.09011f $ **FLOATING
C2874 a_46818_17417.t2 VSS 0.09249f $ **FLOATING
C2875 a_48920_17493.t0 VSS 0.15436f $ **FLOATING
C2876 a_48920_17493.t2 VSS 0.77903f $ **FLOATING
C2877 a_48920_17493.n0 VSS 0.43794f $ **FLOATING
C2878 a_48920_17493.t1 VSS 0.2341f $ **FLOATING
C2879 a_49148_17633.t0 VSS 0.10822f $ **FLOATING
C2880 a_49148_17633.t1 VSS 0.10901f $ **FLOATING
C2881 a_49148_17633.n0 VSS 0.47419f $ **FLOATING
C2882 a_49148_17633.t2 VSS 0.2173f $ **FLOATING
C2883 a_49721_17694.t0 VSS 0.08657f $ **FLOATING
C2884 a_49721_17694.t2 VSS 0.28688f $ **FLOATING
C2885 a_49721_17694.t1 VSS 0.13811f $ **FLOATING
C2886 a_49721_17694.n0 VSS 0.32463f $ **FLOATING
C2887 a_47950_17429.t0 VSS 0.44583f $ **FLOATING
C2888 a_47950_17429.t1 VSS 0.38744f $ **FLOATING
C2889 a_48826_17493.t0 VSS 0.37124f $ **FLOATING
C2890 a_48826_17493.t1 VSS 0.37257f $ **FLOATING
C2891 a_50809_17490.t3 VSS 0.07411f $ **FLOATING
C2892 a_50809_17490.t4 VSS 0.07411f $ **FLOATING
C2893 a_50809_17490.n0 VSS 0.12504f $ **FLOATING
C2894 a_50809_17490.t2 VSS 0.07411f $ **FLOATING
C2895 a_50809_17490.t5 VSS 0.07411f $ **FLOATING
C2896 a_50809_17490.n1 VSS 0.16045f $ **FLOATING
C2897 a_50809_17490.t1 VSS 0.07411f $ **FLOATING
C2898 a_50809_17490.t7 VSS 0.07411f $ **FLOATING
C2899 a_50809_17490.n2 VSS 0.16045f $ **FLOATING
C2900 a_50809_17490.t0 VSS 0.07411f $ **FLOATING
C2901 a_50809_17490.t6 VSS 0.07411f $ **FLOATING
C2902 a_50809_17490.n3 VSS 0.12503f $ **FLOATING
C2903 a_3877_14894.t0 VSS 0.06998f $ **FLOATING
C2904 a_3877_14894.n0 VSS 0.73682f $ **FLOATING
C2905 a_3877_14894.t2 VSS 0.50729f $ **FLOATING
C2906 a_3877_14894.t1 VSS 0.11429f $ **FLOATING
C2907 a_10397_14894.t0 VSS 0.06998f $ **FLOATING
C2908 a_10397_14894.n0 VSS 0.73683f $ **FLOATING
C2909 a_10397_14894.t2 VSS 0.5073f $ **FLOATING
C2910 a_10397_14894.t1 VSS 0.1143f $ **FLOATING
C2911 a_4298_14914.t0 VSS 0.06223f $ **FLOATING
C2912 a_4298_14914.t1 VSS 0.1014f $ **FLOATING
C2913 a_4298_14914.n0 VSS 0.63914f $ **FLOATING
C2914 a_4298_14914.t2 VSS 0.27154f $ **FLOATING
C2915 a_16917_14894.t0 VSS 0.06988f $ **FLOATING
C2916 a_16917_14894.n0 VSS 0.73576f $ **FLOATING
C2917 a_16917_14894.t2 VSS 0.50657f $ **FLOATING
C2918 a_16917_14894.t1 VSS 0.11413f $ **FLOATING
C2919 a_10818_14914.t0 VSS 0.06223f $ **FLOATING
C2920 a_10818_14914.t1 VSS 0.1014f $ **FLOATING
C2921 a_10818_14914.n0 VSS 0.63914f $ **FLOATING
C2922 a_10818_14914.t2 VSS 0.27154f $ **FLOATING
C2923 a_23437_14894.t0 VSS 0.06988f $ **FLOATING
C2924 a_23437_14894.n0 VSS 0.73578f $ **FLOATING
C2925 a_23437_14894.t2 VSS 0.50658f $ **FLOATING
C2926 a_23437_14894.t1 VSS 0.11413f $ **FLOATING
C2927 a_17338_14914.t0 VSS 0.0622f $ **FLOATING
C2928 a_17338_14914.t1 VSS 0.10135f $ **FLOATING
C2929 a_17338_14914.n0 VSS 0.63887f $ **FLOATING
C2930 a_17338_14914.t2 VSS 0.27142f $ **FLOATING
C2931 a_29957_14894.t0 VSS 0.06987f $ **FLOATING
C2932 a_29957_14894.n0 VSS 0.73569f $ **FLOATING
C2933 a_29957_14894.t2 VSS 0.50651f $ **FLOATING
C2934 a_29957_14894.t1 VSS 0.11412f $ **FLOATING
C2935 a_23858_14914.t0 VSS 0.0622f $ **FLOATING
C2936 a_23858_14914.t1 VSS 0.10135f $ **FLOATING
C2937 a_23858_14914.n0 VSS 0.63887f $ **FLOATING
C2938 a_23858_14914.t2 VSS 0.27142f $ **FLOATING
C2939 a_36477_14894.t0 VSS 0.06987f $ **FLOATING
C2940 a_36477_14894.n0 VSS 0.73571f $ **FLOATING
C2941 a_36477_14894.t2 VSS 0.50653f $ **FLOATING
C2942 a_36477_14894.t1 VSS 0.11412f $ **FLOATING
C2943 a_30378_14914.t0 VSS 0.0622f $ **FLOATING
C2944 a_30378_14914.t1 VSS 0.10135f $ **FLOATING
C2945 a_30378_14914.n0 VSS 0.63887f $ **FLOATING
C2946 a_30378_14914.t2 VSS 0.27142f $ **FLOATING
C2947 a_42997_14894.t0 VSS 0.06991f $ **FLOATING
C2948 a_42997_14894.n0 VSS 0.73615f $ **FLOATING
C2949 a_42997_14894.t2 VSS 0.50683f $ **FLOATING
C2950 a_42997_14894.t1 VSS 0.11419f $ **FLOATING
C2951 a_36898_14914.t0 VSS 0.0622f $ **FLOATING
C2952 a_36898_14914.t1 VSS 0.10135f $ **FLOATING
C2953 a_36898_14914.n0 VSS 0.63887f $ **FLOATING
C2954 a_36898_14914.t2 VSS 0.27142f $ **FLOATING
C2955 a_49517_14894.t0 VSS 0.06986f $ **FLOATING
C2956 a_49517_14894.n0 VSS 0.73555f $ **FLOATING
C2957 a_49517_14894.t2 VSS 0.50642f $ **FLOATING
C2958 a_49517_14894.t1 VSS 0.1141f $ **FLOATING
C2959 a_43418_14914.t0 VSS 0.06221f $ **FLOATING
C2960 a_43418_14914.t1 VSS 0.10136f $ **FLOATING
C2961 a_43418_14914.n0 VSS 0.63894f $ **FLOATING
C2962 a_43418_14914.t2 VSS 0.27145f $ **FLOATING
C2963 a_49938_14914.t0 VSS 0.0622f $ **FLOATING
C2964 a_49938_14914.t1 VSS 0.10135f $ **FLOATING
C2965 a_49938_14914.n0 VSS 0.63886f $ **FLOATING
C2966 a_49938_14914.t2 VSS 0.27142f $ **FLOATING
C2967 a_5003_14950.t3 VSS 0.14893f $ **FLOATING
C2968 a_5003_14950.t5 VSS 0.13043f $ **FLOATING
C2969 a_5003_14950.n0 VSS 0.31977f $ **FLOATING
C2970 a_5003_14950.t8 VSS 0.10111f $ **FLOATING
C2971 a_5003_14950.n1 VSS 0.38936f $ **FLOATING
C2972 a_5003_14950.t7 VSS 0.09879f $ **FLOATING
C2973 a_5003_14950.n2 VSS 0.33887f $ **FLOATING
C2974 a_5003_14950.t0 VSS 0.11343f $ **FLOATING
C2975 a_5003_14950.t9 VSS 0.09879f $ **FLOATING
C2976 a_5003_14950.n3 VSS 0.33887f $ **FLOATING
C2977 a_5003_14950.t1 VSS 0.11343f $ **FLOATING
C2978 a_5003_14950.t2 VSS 0.14893f $ **FLOATING
C2979 a_5003_14950.t4 VSS 0.13119f $ **FLOATING
C2980 a_5003_14950.n4 VSS 0.35457f $ **FLOATING
C2981 a_5003_14950.t6 VSS 0.13119f $ **FLOATING
C2982 a_5003_14950.n5 VSS 0.35457f $ **FLOATING
C2983 a_11523_14950.t3 VSS 0.14894f $ **FLOATING
C2984 a_11523_14950.t5 VSS 0.13044f $ **FLOATING
C2985 a_11523_14950.n0 VSS 0.31979f $ **FLOATING
C2986 a_11523_14950.t9 VSS 0.10112f $ **FLOATING
C2987 a_11523_14950.n1 VSS 0.38937f $ **FLOATING
C2988 a_11523_14950.t7 VSS 0.09879f $ **FLOATING
C2989 a_11523_14950.n2 VSS 0.33888f $ **FLOATING
C2990 a_11523_14950.t0 VSS 0.11343f $ **FLOATING
C2991 a_11523_14950.t8 VSS 0.09879f $ **FLOATING
C2992 a_11523_14950.n3 VSS 0.33888f $ **FLOATING
C2993 a_11523_14950.t1 VSS 0.11343f $ **FLOATING
C2994 a_11523_14950.t2 VSS 0.14894f $ **FLOATING
C2995 a_11523_14950.t4 VSS 0.1312f $ **FLOATING
C2996 a_11523_14950.n4 VSS 0.35458f $ **FLOATING
C2997 a_11523_14950.t6 VSS 0.1312f $ **FLOATING
C2998 a_11523_14950.n5 VSS 0.35458f $ **FLOATING
C2999 a_18043_14950.t3 VSS 0.14895f $ **FLOATING
C3000 a_18043_14950.t8 VSS 0.13045f $ **FLOATING
C3001 a_18043_14950.n0 VSS 0.31982f $ **FLOATING
C3002 a_18043_14950.t5 VSS 0.10113f $ **FLOATING
C3003 a_18043_14950.n1 VSS 0.38941f $ **FLOATING
C3004 a_18043_14950.t4 VSS 0.0988f $ **FLOATING
C3005 a_18043_14950.n2 VSS 0.33891f $ **FLOATING
C3006 a_18043_14950.t0 VSS 0.11344f $ **FLOATING
C3007 a_18043_14950.t6 VSS 0.0988f $ **FLOATING
C3008 a_18043_14950.n3 VSS 0.33891f $ **FLOATING
C3009 a_18043_14950.t1 VSS 0.11344f $ **FLOATING
C3010 a_18043_14950.t2 VSS 0.14895f $ **FLOATING
C3011 a_18043_14950.t7 VSS 0.13121f $ **FLOATING
C3012 a_18043_14950.n4 VSS 0.35461f $ **FLOATING
C3013 a_18043_14950.t9 VSS 0.13121f $ **FLOATING
C3014 a_18043_14950.n5 VSS 0.35461f $ **FLOATING
C3015 a_24563_14950.t9 VSS 0.13122f $ **FLOATING
C3016 a_24563_14950.t8 VSS 0.13046f $ **FLOATING
C3017 a_24563_14950.n0 VSS 0.31982f $ **FLOATING
C3018 a_24563_14950.t6 VSS 0.10113f $ **FLOATING
C3019 a_24563_14950.n1 VSS 0.38942f $ **FLOATING
C3020 a_24563_14950.t4 VSS 0.0988f $ **FLOATING
C3021 a_24563_14950.n2 VSS 0.33892f $ **FLOATING
C3022 a_24563_14950.t0 VSS 0.11344f $ **FLOATING
C3023 a_24563_14950.t5 VSS 0.0988f $ **FLOATING
C3024 a_24563_14950.n3 VSS 0.33892f $ **FLOATING
C3025 a_24563_14950.t1 VSS 0.11344f $ **FLOATING
C3026 a_24563_14950.t2 VSS 0.14895f $ **FLOATING
C3027 a_24563_14950.t7 VSS 0.13122f $ **FLOATING
C3028 a_24563_14950.n4 VSS 0.35462f $ **FLOATING
C3029 a_24563_14950.t3 VSS 0.14895f $ **FLOATING
C3030 a_24563_14950.n5 VSS 0.35462f $ **FLOATING
C3031 a_31083_14950.t9 VSS 0.13121f $ **FLOATING
C3032 a_31083_14950.t8 VSS 0.13045f $ **FLOATING
C3033 a_31083_14950.n0 VSS 0.3198f $ **FLOATING
C3034 a_31083_14950.t6 VSS 0.10112f $ **FLOATING
C3035 a_31083_14950.n1 VSS 0.38939f $ **FLOATING
C3036 a_31083_14950.t4 VSS 0.09879f $ **FLOATING
C3037 a_31083_14950.n2 VSS 0.3389f $ **FLOATING
C3038 a_31083_14950.t0 VSS 0.11343f $ **FLOATING
C3039 a_31083_14950.t5 VSS 0.09879f $ **FLOATING
C3040 a_31083_14950.n3 VSS 0.3389f $ **FLOATING
C3041 a_31083_14950.t1 VSS 0.11343f $ **FLOATING
C3042 a_31083_14950.t2 VSS 0.14894f $ **FLOATING
C3043 a_31083_14950.t7 VSS 0.13121f $ **FLOATING
C3044 a_31083_14950.n4 VSS 0.3546f $ **FLOATING
C3045 a_31083_14950.t3 VSS 0.14894f $ **FLOATING
C3046 a_31083_14950.n5 VSS 0.3546f $ **FLOATING
C3047 a_37603_14950.t9 VSS 0.13121f $ **FLOATING
C3048 a_37603_14950.t8 VSS 0.13045f $ **FLOATING
C3049 a_37603_14950.n0 VSS 0.31981f $ **FLOATING
C3050 a_37603_14950.t6 VSS 0.10112f $ **FLOATING
C3051 a_37603_14950.n1 VSS 0.3894f $ **FLOATING
C3052 a_37603_14950.t4 VSS 0.0988f $ **FLOATING
C3053 a_37603_14950.n2 VSS 0.3389f $ **FLOATING
C3054 a_37603_14950.t0 VSS 0.11344f $ **FLOATING
C3055 a_37603_14950.t5 VSS 0.0988f $ **FLOATING
C3056 a_37603_14950.n3 VSS 0.3389f $ **FLOATING
C3057 a_37603_14950.t1 VSS 0.11344f $ **FLOATING
C3058 a_37603_14950.t2 VSS 0.14895f $ **FLOATING
C3059 a_37603_14950.t7 VSS 0.13121f $ **FLOATING
C3060 a_37603_14950.n4 VSS 0.35461f $ **FLOATING
C3061 a_37603_14950.t3 VSS 0.14895f $ **FLOATING
C3062 a_37603_14950.n5 VSS 0.35461f $ **FLOATING
C3063 a_44123_14950.t3 VSS 0.14855f $ **FLOATING
C3064 a_44123_14950.t5 VSS 0.1301f $ **FLOATING
C3065 a_44123_14950.n0 VSS 0.31896f $ **FLOATING
C3066 a_44123_14950.t9 VSS 0.10086f $ **FLOATING
C3067 a_44123_14950.n1 VSS 0.38837f $ **FLOATING
C3068 a_44123_14950.t8 VSS 0.09853f $ **FLOATING
C3069 a_44123_14950.n2 VSS 0.338f $ **FLOATING
C3070 a_44123_14950.t0 VSS 0.11314f $ **FLOATING
C3071 a_44123_14950.t7 VSS 0.09853f $ **FLOATING
C3072 a_44123_14950.n3 VSS 0.338f $ **FLOATING
C3073 a_44123_14950.t1 VSS 0.11314f $ **FLOATING
C3074 a_44123_14950.t2 VSS 0.14855f $ **FLOATING
C3075 a_44123_14950.t4 VSS 0.13086f $ **FLOATING
C3076 a_44123_14950.n4 VSS 0.35366f $ **FLOATING
C3077 a_44123_14950.t6 VSS 0.13086f $ **FLOATING
C3078 a_44123_14950.n5 VSS 0.35366f $ **FLOATING
C3079 a_50643_14950.t3 VSS 0.14849f $ **FLOATING
C3080 a_50643_14950.t5 VSS 0.13005f $ **FLOATING
C3081 a_50643_14950.n0 VSS 0.31883f $ **FLOATING
C3082 a_50643_14950.t9 VSS 0.10081f $ **FLOATING
C3083 a_50643_14950.n1 VSS 0.3882f $ **FLOATING
C3084 a_50643_14950.t7 VSS 0.09849f $ **FLOATING
C3085 a_50643_14950.n2 VSS 0.33786f $ **FLOATING
C3086 a_50643_14950.t0 VSS 0.11309f $ **FLOATING
C3087 a_50643_14950.t8 VSS 0.09849f $ **FLOATING
C3088 a_50643_14950.n3 VSS 0.33786f $ **FLOATING
C3089 a_50643_14950.t1 VSS 0.11309f $ **FLOATING
C3090 a_50643_14950.t2 VSS 0.14849f $ **FLOATING
C3091 a_50643_14950.t4 VSS 0.13081f $ **FLOATING
C3092 a_50643_14950.n4 VSS 0.35352f $ **FLOATING
C3093 a_50643_14950.t6 VSS 0.13081f $ **FLOATING
C3094 a_50643_14950.n5 VSS 0.35352f $ **FLOATING
C3095 a_585_14994.t0 VSS 0.09045f $ **FLOATING
C3096 a_585_14994.t2 VSS 0.30371f $ **FLOATING
C3097 a_585_14994.t1 VSS 0.14183f $ **FLOATING
C3098 a_585_14994.n0 VSS 0.37752f $ **FLOATING
C3099 a_679_14994.t0 VSS 0.03794f $ **FLOATING
C3100 a_890_14598.t0 VSS 0.13448f $ **FLOATING
C3101 a_890_14598.t1 VSS 0.20725f $ **FLOATING
C3102 a_890_14598.n0 VSS 0.58116f $ **FLOATING
C3103 a_890_14598.t2 VSS 0.2838f $ **FLOATING
C3104 a_n2044_1752.t0 VSS 0.10696f $ **FLOATING
C3105 a_n2044_1752.n0 VSS 5.4422f $ **FLOATING
C3106 a_n2044_1752.t10 VSS 0.48469f $ **FLOATING
C3107 a_n2044_1752.n1 VSS 12.7426f $ **FLOATING
C3108 a_n2044_1752.t2 VSS 0.36911f $ **FLOATING
C3109 a_n2044_1752.n2 VSS 4.61948f $ **FLOATING
C3110 a_n2044_1752.t11 VSS 0.34311f $ **FLOATING
C3111 a_n2044_1752.n3 VSS 5.20396f $ **FLOATING
C3112 a_n2044_1752.t3 VSS 0.36911f $ **FLOATING
C3113 a_n2044_1752.n4 VSS 4.61948f $ **FLOATING
C3114 a_n2044_1752.t12 VSS 0.34311f $ **FLOATING
C3115 a_n2044_1752.n5 VSS 5.20396f $ **FLOATING
C3116 a_n2044_1752.t4 VSS 0.36911f $ **FLOATING
C3117 a_n2044_1752.n6 VSS 4.61948f $ **FLOATING
C3118 a_n2044_1752.t13 VSS 0.34311f $ **FLOATING
C3119 a_n2044_1752.n7 VSS 5.20396f $ **FLOATING
C3120 a_n2044_1752.t5 VSS 0.36911f $ **FLOATING
C3121 a_n2044_1752.n8 VSS 4.61948f $ **FLOATING
C3122 a_n2044_1752.t14 VSS 0.34311f $ **FLOATING
C3123 a_n2044_1752.n9 VSS 5.20396f $ **FLOATING
C3124 a_n2044_1752.t6 VSS 0.36911f $ **FLOATING
C3125 a_n2044_1752.n10 VSS 4.61948f $ **FLOATING
C3126 a_n2044_1752.t15 VSS 0.34311f $ **FLOATING
C3127 a_n2044_1752.n11 VSS 5.20396f $ **FLOATING
C3128 a_n2044_1752.t7 VSS 0.36911f $ **FLOATING
C3129 a_n2044_1752.n12 VSS 4.61948f $ **FLOATING
C3130 a_n2044_1752.t16 VSS 0.34311f $ **FLOATING
C3131 a_n2044_1752.n13 VSS 5.20396f $ **FLOATING
C3132 a_n2044_1752.t8 VSS 0.36911f $ **FLOATING
C3133 a_n2044_1752.n14 VSS 4.61948f $ **FLOATING
C3134 a_n2044_1752.t17 VSS 0.34311f $ **FLOATING
C3135 a_n2044_1752.n15 VSS 17.3513f $ **FLOATING
C3136 a_n2044_1752.t9 VSS 0.36911f $ **FLOATING
C3137 a_n2044_1752.t1 VSS 0.16443f $ **FLOATING
C3138 a_1279_14914.t0 VSS 0.16199f $ **FLOATING
C3139 a_1279_14914.t3 VSS 0.18559f $ **FLOATING
C3140 a_1279_14914.t1 VSS 0.2542f $ **FLOATING
C3141 a_1279_14914.t2 VSS 0.25336f $ **FLOATING
C3142 a_1279_14914.n0 VSS 0.39498f $ **FLOATING
C3143 a_1279_14914.n1 VSS 0.36275f $ **FLOATING
C3144 a_1995_14839.t0 VSS 0.14826f $ **FLOATING
C3145 a_1995_14839.t2 VSS 0.13697f $ **FLOATING
C3146 a_1995_14839.t3 VSS 0.31243f $ **FLOATING
C3147 a_1995_14839.n0 VSS 0.43827f $ **FLOATING
C3148 a_1995_14839.n1 VSS 0.34325f $ **FLOATING
C3149 a_1995_14839.t1 VSS 0.14673f $ **FLOATING
C3150 a_1735_14616.t0 VSS 0.18251f $ **FLOATING
C3151 a_1735_14616.t1 VSS 0.18351f $ **FLOATING
C3152 a_1735_14616.n0 VSS 0.98668f $ **FLOATING
C3153 a_1735_14616.t3 VSS 0.1642f $ **FLOATING
C3154 a_1735_14616.n1 VSS 1.06964f $ **FLOATING
C3155 a_1735_14616.t2 VSS 0.17006f $ **FLOATING
C3156 a_2021_14934.t0 VSS 0.19143f $ **FLOATING
C3157 a_2021_14934.t4 VSS 0.24713f $ **FLOATING
C3158 a_2021_14934.n0 VSS 0.5076f $ **FLOATING
C3159 a_2021_14934.t3 VSS 0.26942f $ **FLOATING
C3160 a_2021_14934.t2 VSS 0.27167f $ **FLOATING
C3161 a_2021_14934.n1 VSS 0.81778f $ **FLOATING
C3162 a_2021_14934.t1 VSS 0.27572f $ **FLOATING
C3163 a_2021_14934.n2 VSS 0.49608f $ **FLOATING
C3164 a_2430_14873.t0 VSS 0.15491f $ **FLOATING
C3165 a_2430_14873.t3 VSS 0.60111f $ **FLOATING
C3166 a_2430_14873.n0 VSS 0.31834f $ **FLOATING
C3167 a_2430_14873.t1 VSS 0.2267f $ **FLOATING
C3168 a_2430_14873.n1 VSS 0.1803f $ **FLOATING
C3169 a_2430_14873.t2 VSS 0.25072f $ **FLOATING
C3170 a_2532_14960.t0 VSS 0.20064f $ **FLOATING
C3171 a_2532_14960.t3 VSS 0.28263f $ **FLOATING
C3172 a_2532_14960.n0 VSS 0.63451f $ **FLOATING
C3173 a_2532_14960.t1 VSS 0.30493f $ **FLOATING
C3174 a_2532_14960.t2 VSS 0.27266f $ **FLOATING
C3175 a_2532_14960.n1 VSS 0.34142f $ **FLOATING
C3176 a_1178_14617.t1 VSS 0.08434f $ **FLOATING
C3177 a_1178_14617.n0 VSS 0.26173f $ **FLOATING
C3178 a_1178_14617.t0 VSS 0.09033f $ **FLOATING
C3179 a_1178_14617.t2 VSS 0.09272f $ **FLOATING
C3180 a_3280_14693.t1 VSS 0.15513f $ **FLOATING
C3181 a_3280_14693.t2 VSS 0.78293f $ **FLOATING
C3182 a_3280_14693.n0 VSS 0.44013f $ **FLOATING
C3183 a_3280_14693.t0 VSS 0.23527f $ **FLOATING
C3184 a_3508_14833.t0 VSS 0.1094f $ **FLOATING
C3185 a_3508_14833.t2 VSS 0.21808f $ **FLOATING
C3186 a_3508_14833.t1 VSS 0.10861f $ **FLOATING
C3187 a_3508_14833.n0 VSS 0.47589f $ **FLOATING
C3188 a_4081_14894.t0 VSS 0.08718f $ **FLOATING
C3189 a_4081_14894.t2 VSS 0.28889f $ **FLOATING
C3190 a_4081_14894.t1 VSS 0.13908f $ **FLOATING
C3191 a_4081_14894.n0 VSS 0.3269f $ **FLOATING
C3192 a_7105_14994.t0 VSS 0.08965f $ **FLOATING
C3193 a_7105_14994.t2 VSS 0.30104f $ **FLOATING
C3194 a_7105_14994.t1 VSS 0.14058f $ **FLOATING
C3195 a_7105_14994.n0 VSS 0.3742f $ **FLOATING
C3196 a_2310_14629.t0 VSS 0.4464f $ **FLOATING
C3197 a_2310_14629.t1 VSS 0.38794f $ **FLOATING
C3198 a_3186_14693.t0 VSS 0.37163f $ **FLOATING
C3199 a_3186_14693.t1 VSS 0.37297f $ **FLOATING
C3200 a_5169_14690.t3 VSS 0.07497f $ **FLOATING
C3201 a_5169_14690.t4 VSS 0.07497f $ **FLOATING
C3202 a_5169_14690.n0 VSS 0.12649f $ **FLOATING
C3203 a_5169_14690.t2 VSS 0.07497f $ **FLOATING
C3204 a_5169_14690.t5 VSS 0.07497f $ **FLOATING
C3205 a_5169_14690.n1 VSS 0.16231f $ **FLOATING
C3206 a_5169_14690.t1 VSS 0.07497f $ **FLOATING
C3207 a_5169_14690.t7 VSS 0.07497f $ **FLOATING
C3208 a_5169_14690.n2 VSS 0.16231f $ **FLOATING
C3209 a_5169_14690.t0 VSS 0.07497f $ **FLOATING
C3210 a_5169_14690.t6 VSS 0.07497f $ **FLOATING
C3211 a_5169_14690.n3 VSS 0.12648f $ **FLOATING
C3212 a_7199_14994.t0 VSS 0.03797f $ **FLOATING
C3213 a_7410_14598.t0 VSS 0.13437f $ **FLOATING
C3214 a_7410_14598.t1 VSS 0.20707f $ **FLOATING
C3215 a_7410_14598.n0 VSS 0.58066f $ **FLOATING
C3216 a_7410_14598.t2 VSS 0.28357f $ **FLOATING
C3217 a_7799_14914.t0 VSS 0.16181f $ **FLOATING
C3218 a_7799_14914.t3 VSS 0.18538f $ **FLOATING
C3219 a_7799_14914.t1 VSS 0.25392f $ **FLOATING
C3220 a_7799_14914.t2 VSS 0.25308f $ **FLOATING
C3221 a_7799_14914.n0 VSS 0.39454f $ **FLOATING
C3222 a_7799_14914.n1 VSS 0.36235f $ **FLOATING
C3223 a_8515_14839.t0 VSS 0.14825f $ **FLOATING
C3224 a_8515_14839.t2 VSS 0.13696f $ **FLOATING
C3225 a_8515_14839.t3 VSS 0.31242f $ **FLOATING
C3226 a_8515_14839.n0 VSS 0.43824f $ **FLOATING
C3227 a_8515_14839.n1 VSS 0.34324f $ **FLOATING
C3228 a_8515_14839.t1 VSS 0.14672f $ **FLOATING
C3229 a_8255_14616.t0 VSS 0.16418f $ **FLOATING
C3230 a_8255_14616.t2 VSS 0.1835f $ **FLOATING
C3231 a_8255_14616.n0 VSS 0.9866f $ **FLOATING
C3232 a_8255_14616.t3 VSS 0.18249f $ **FLOATING
C3233 a_8255_14616.t1 VSS 0.17004f $ **FLOATING
C3234 a_8255_14616.n1 VSS 1.06956f $ **FLOATING
C3235 a_8541_14934.t0 VSS 0.26941f $ **FLOATING
C3236 a_8541_14934.t4 VSS 0.24711f $ **FLOATING
C3237 a_8541_14934.t3 VSS 0.2757f $ **FLOATING
C3238 a_8541_14934.n0 VSS 0.49604f $ **FLOATING
C3239 a_8541_14934.t2 VSS 0.19142f $ **FLOATING
C3240 a_8541_14934.n1 VSS 0.50757f $ **FLOATING
C3241 a_8541_14934.t1 VSS 0.27166f $ **FLOATING
C3242 a_8541_14934.n2 VSS 0.81773f $ **FLOATING
C3243 a_8950_14873.t0 VSS 0.15491f $ **FLOATING
C3244 a_8950_14873.t3 VSS 0.60109f $ **FLOATING
C3245 a_8950_14873.n0 VSS 0.31833f $ **FLOATING
C3246 a_8950_14873.t1 VSS 0.2267f $ **FLOATING
C3247 a_8950_14873.n1 VSS 0.1803f $ **FLOATING
C3248 a_8950_14873.t2 VSS 0.25071f $ **FLOATING
C3249 a_9052_14960.t0 VSS 0.20064f $ **FLOATING
C3250 a_9052_14960.t3 VSS 0.28263f $ **FLOATING
C3251 a_9052_14960.n0 VSS 0.63449f $ **FLOATING
C3252 a_9052_14960.t1 VSS 0.30493f $ **FLOATING
C3253 a_9052_14960.t2 VSS 0.27265f $ **FLOATING
C3254 a_9052_14960.n1 VSS 0.34142f $ **FLOATING
C3255 a_7698_14617.t1 VSS 0.08421f $ **FLOATING
C3256 a_7698_14617.n0 VSS 0.26132f $ **FLOATING
C3257 a_7698_14617.t0 VSS 0.09019f $ **FLOATING
C3258 a_7698_14617.t2 VSS 0.09257f $ **FLOATING
C3259 a_9800_14693.t0 VSS 0.15513f $ **FLOATING
C3260 a_9800_14693.t2 VSS 0.78293f $ **FLOATING
C3261 a_9800_14693.n0 VSS 0.44013f $ **FLOATING
C3262 a_9800_14693.t1 VSS 0.23527f $ **FLOATING
C3263 a_10028_14833.t0 VSS 0.10861f $ **FLOATING
C3264 a_10028_14833.t1 VSS 0.1094f $ **FLOATING
C3265 a_10028_14833.n0 VSS 0.47589f $ **FLOATING
C3266 a_10028_14833.t2 VSS 0.21808f $ **FLOATING
C3267 a_10601_14894.t0 VSS 0.08718f $ **FLOATING
C3268 a_10601_14894.t2 VSS 0.28889f $ **FLOATING
C3269 a_10601_14894.t1 VSS 0.13908f $ **FLOATING
C3270 a_10601_14894.n0 VSS 0.3269f $ **FLOATING
C3271 a_13625_14994.t0 VSS 0.08975f $ **FLOATING
C3272 a_13625_14994.t2 VSS 0.30136f $ **FLOATING
C3273 a_13625_14994.t1 VSS 0.14073f $ **FLOATING
C3274 a_13625_14994.n0 VSS 0.3746f $ **FLOATING
C3275 a_8830_14629.t0 VSS 0.44638f $ **FLOATING
C3276 a_8830_14629.t1 VSS 0.38792f $ **FLOATING
C3277 a_9706_14693.t0 VSS 0.37163f $ **FLOATING
C3278 a_9706_14693.t1 VSS 0.37297f $ **FLOATING
C3279 a_11689_14690.t3 VSS 0.07497f $ **FLOATING
C3280 a_11689_14690.t4 VSS 0.07497f $ **FLOATING
C3281 a_11689_14690.n0 VSS 0.12649f $ **FLOATING
C3282 a_11689_14690.t2 VSS 0.07497f $ **FLOATING
C3283 a_11689_14690.t5 VSS 0.07497f $ **FLOATING
C3284 a_11689_14690.n1 VSS 0.16231f $ **FLOATING
C3285 a_11689_14690.t1 VSS 0.07497f $ **FLOATING
C3286 a_11689_14690.t7 VSS 0.07497f $ **FLOATING
C3287 a_11689_14690.n2 VSS 0.16231f $ **FLOATING
C3288 a_11689_14690.t0 VSS 0.07497f $ **FLOATING
C3289 a_11689_14690.t6 VSS 0.07497f $ **FLOATING
C3290 a_11689_14690.n3 VSS 0.12649f $ **FLOATING
C3291 a_13719_14994.t0 VSS 0.03799f $ **FLOATING
C3292 a_13930_14598.t0 VSS 0.13454f $ **FLOATING
C3293 a_13930_14598.t1 VSS 0.20733f $ **FLOATING
C3294 a_13930_14598.n0 VSS 0.5814f $ **FLOATING
C3295 a_13930_14598.t2 VSS 0.28392f $ **FLOATING
C3296 a_14319_14914.t1 VSS 0.16163f $ **FLOATING
C3297 a_14319_14914.t3 VSS 0.18517f $ **FLOATING
C3298 a_14319_14914.t2 VSS 0.25363f $ **FLOATING
C3299 a_14319_14914.t0 VSS 0.25279f $ **FLOATING
C3300 a_14319_14914.n0 VSS 0.3941f $ **FLOATING
C3301 a_14319_14914.n1 VSS 0.36194f $ **FLOATING
C3302 a_15035_14839.t0 VSS 0.14671f $ **FLOATING
C3303 a_15035_14839.t1 VSS 0.14824f $ **FLOATING
C3304 a_15035_14839.t2 VSS 0.13695f $ **FLOATING
C3305 a_15035_14839.t3 VSS 0.3124f $ **FLOATING
C3306 a_15035_14839.n0 VSS 0.43822f $ **FLOATING
C3307 a_15035_14839.n1 VSS 0.34322f $ **FLOATING
C3308 a_14775_14616.t0 VSS 0.18248f $ **FLOATING
C3309 a_14775_14616.t1 VSS 0.18348f $ **FLOATING
C3310 a_14775_14616.n0 VSS 0.98653f $ **FLOATING
C3311 a_14775_14616.t2 VSS 0.16417f $ **FLOATING
C3312 a_14775_14616.n1 VSS 1.06948f $ **FLOATING
C3313 a_14775_14616.t3 VSS 0.17003f $ **FLOATING
C3314 a_15061_14934.t0 VSS 0.19141f $ **FLOATING
C3315 a_15061_14934.t4 VSS 0.2471f $ **FLOATING
C3316 a_15061_14934.n0 VSS 0.50754f $ **FLOATING
C3317 a_15061_14934.t2 VSS 0.26939f $ **FLOATING
C3318 a_15061_14934.t3 VSS 0.27164f $ **FLOATING
C3319 a_15061_14934.n1 VSS 0.81769f $ **FLOATING
C3320 a_15061_14934.t1 VSS 0.27569f $ **FLOATING
C3321 a_15061_14934.n2 VSS 0.49602f $ **FLOATING
C3322 a_15470_14873.t0 VSS 0.1549f $ **FLOATING
C3323 a_15470_14873.t3 VSS 0.60104f $ **FLOATING
C3324 a_15470_14873.n0 VSS 0.3183f $ **FLOATING
C3325 a_15470_14873.t1 VSS 0.22668f $ **FLOATING
C3326 a_15470_14873.n1 VSS 0.18028f $ **FLOATING
C3327 a_15470_14873.t2 VSS 0.25069f $ **FLOATING
C3328 a_15572_14960.t0 VSS 0.20063f $ **FLOATING
C3329 a_15572_14960.t3 VSS 0.28262f $ **FLOATING
C3330 a_15572_14960.n0 VSS 0.63448f $ **FLOATING
C3331 a_15572_14960.t1 VSS 0.30492f $ **FLOATING
C3332 a_15572_14960.t2 VSS 0.27265f $ **FLOATING
C3333 a_15572_14960.n1 VSS 0.34141f $ **FLOATING
C3334 a_14218_14617.t1 VSS 0.09005f $ **FLOATING
C3335 a_14218_14617.t0 VSS 0.09243f $ **FLOATING
C3336 a_14218_14617.t2 VSS 0.08407f $ **FLOATING
C3337 a_14218_14617.n0 VSS 0.26091f $ **FLOATING
C3338 a_16320_14693.t1 VSS 0.15513f $ **FLOATING
C3339 a_16320_14693.t2 VSS 0.78293f $ **FLOATING
C3340 a_16320_14693.n0 VSS 0.44013f $ **FLOATING
C3341 a_16320_14693.t0 VSS 0.23527f $ **FLOATING
C3342 a_16548_14833.t0 VSS 0.10861f $ **FLOATING
C3343 a_16548_14833.t1 VSS 0.1094f $ **FLOATING
C3344 a_16548_14833.n0 VSS 0.47589f $ **FLOATING
C3345 a_16548_14833.t2 VSS 0.21808f $ **FLOATING
C3346 a_17121_14894.t0 VSS 0.08718f $ **FLOATING
C3347 a_17121_14894.t2 VSS 0.28889f $ **FLOATING
C3348 a_17121_14894.t1 VSS 0.13908f $ **FLOATING
C3349 a_17121_14894.n0 VSS 0.3269f $ **FLOATING
C3350 a_20145_14994.t0 VSS 0.08964f $ **FLOATING
C3351 a_20145_14994.t2 VSS 0.30097f $ **FLOATING
C3352 a_20145_14994.t1 VSS 0.14055f $ **FLOATING
C3353 a_20145_14994.n0 VSS 0.37411f $ **FLOATING
C3354 a_15350_14629.t0 VSS 0.44637f $ **FLOATING
C3355 a_15350_14629.t1 VSS 0.38791f $ **FLOATING
C3356 a_16226_14693.t0 VSS 0.37297f $ **FLOATING
C3357 a_16226_14693.t1 VSS 0.37163f $ **FLOATING
C3358 a_18209_14690.t3 VSS 0.07497f $ **FLOATING
C3359 a_18209_14690.t6 VSS 0.07496f $ **FLOATING
C3360 a_18209_14690.n0 VSS 0.12648f $ **FLOATING
C3361 a_18209_14690.t2 VSS 0.07497f $ **FLOATING
C3362 a_18209_14690.t7 VSS 0.07496f $ **FLOATING
C3363 a_18209_14690.n1 VSS 0.1623f $ **FLOATING
C3364 a_18209_14690.t1 VSS 0.07497f $ **FLOATING
C3365 a_18209_14690.t5 VSS 0.07496f $ **FLOATING
C3366 a_18209_14690.n2 VSS 0.1623f $ **FLOATING
C3367 a_18209_14690.t0 VSS 0.07497f $ **FLOATING
C3368 a_18209_14690.t4 VSS 0.07497f $ **FLOATING
C3369 a_18209_14690.n3 VSS 0.12648f $ **FLOATING
C3370 a_20239_14994.t0 VSS 0.03796f $ **FLOATING
C3371 a_20450_14598.t0 VSS 0.13432f $ **FLOATING
C3372 a_20450_14598.t1 VSS 0.20699f $ **FLOATING
C3373 a_20450_14598.n0 VSS 0.58045f $ **FLOATING
C3374 a_20450_14598.t2 VSS 0.28346f $ **FLOATING
C3375 a_20839_14914.t2 VSS 0.1619f $ **FLOATING
C3376 a_20839_14914.t3 VSS 0.18548f $ **FLOATING
C3377 a_20839_14914.t1 VSS 0.25406f $ **FLOATING
C3378 a_20839_14914.t0 VSS 0.25322f $ **FLOATING
C3379 a_20839_14914.n0 VSS 0.39476f $ **FLOATING
C3380 a_20839_14914.n1 VSS 0.36255f $ **FLOATING
C3381 a_21555_14839.t0 VSS 0.14825f $ **FLOATING
C3382 a_21555_14839.t2 VSS 0.13696f $ **FLOATING
C3383 a_21555_14839.t3 VSS 0.31243f $ **FLOATING
C3384 a_21555_14839.n0 VSS 0.43826f $ **FLOATING
C3385 a_21555_14839.n1 VSS 0.34325f $ **FLOATING
C3386 a_21555_14839.t1 VSS 0.14672f $ **FLOATING
C3387 a_21295_14616.t0 VSS 0.1825f $ **FLOATING
C3388 a_21295_14616.t1 VSS 0.1835f $ **FLOATING
C3389 a_21295_14616.n0 VSS 0.98664f $ **FLOATING
C3390 a_21295_14616.t3 VSS 0.16419f $ **FLOATING
C3391 a_21295_14616.n1 VSS 1.0696f $ **FLOATING
C3392 a_21295_14616.t2 VSS 0.17005f $ **FLOATING
C3393 a_21581_14934.t0 VSS 0.19142f $ **FLOATING
C3394 a_21581_14934.t4 VSS 0.24712f $ **FLOATING
C3395 a_21581_14934.n0 VSS 0.50759f $ **FLOATING
C3396 a_21581_14934.t3 VSS 0.26941f $ **FLOATING
C3397 a_21581_14934.t2 VSS 0.27167f $ **FLOATING
C3398 a_21581_14934.n1 VSS 0.81776f $ **FLOATING
C3399 a_21581_14934.t1 VSS 0.27571f $ **FLOATING
C3400 a_21581_14934.n2 VSS 0.49606f $ **FLOATING
C3401 a_21990_14873.t0 VSS 0.15491f $ **FLOATING
C3402 a_21990_14873.t3 VSS 0.6011f $ **FLOATING
C3403 a_21990_14873.n0 VSS 0.31833f $ **FLOATING
C3404 a_21990_14873.t1 VSS 0.2267f $ **FLOATING
C3405 a_21990_14873.n1 VSS 0.1803f $ **FLOATING
C3406 a_21990_14873.t2 VSS 0.25072f $ **FLOATING
C3407 a_22092_14960.t0 VSS 0.20064f $ **FLOATING
C3408 a_22092_14960.t3 VSS 0.28263f $ **FLOATING
C3409 a_22092_14960.n0 VSS 0.6345f $ **FLOATING
C3410 a_22092_14960.t1 VSS 0.30493f $ **FLOATING
C3411 a_22092_14960.t2 VSS 0.27266f $ **FLOATING
C3412 a_22092_14960.n1 VSS 0.34142f $ **FLOATING
C3413 a_20738_14617.t1 VSS 0.09026f $ **FLOATING
C3414 a_20738_14617.t0 VSS 0.09264f $ **FLOATING
C3415 a_20738_14617.t2 VSS 0.08427f $ **FLOATING
C3416 a_20738_14617.n0 VSS 0.26152f $ **FLOATING
C3417 a_22840_14693.t0 VSS 0.15513f $ **FLOATING
C3418 a_22840_14693.t2 VSS 0.78293f $ **FLOATING
C3419 a_22840_14693.n0 VSS 0.44013f $ **FLOATING
C3420 a_22840_14693.t1 VSS 0.23527f $ **FLOATING
C3421 a_23068_14833.t0 VSS 0.10861f $ **FLOATING
C3422 a_23068_14833.t1 VSS 0.1094f $ **FLOATING
C3423 a_23068_14833.n0 VSS 0.47589f $ **FLOATING
C3424 a_23068_14833.t2 VSS 0.21808f $ **FLOATING
C3425 a_23641_14894.t0 VSS 0.08718f $ **FLOATING
C3426 a_23641_14894.t2 VSS 0.28889f $ **FLOATING
C3427 a_23641_14894.t1 VSS 0.13908f $ **FLOATING
C3428 a_23641_14894.n0 VSS 0.3269f $ **FLOATING
C3429 a_26665_14994.t0 VSS 0.08968f $ **FLOATING
C3430 a_26665_14994.t2 VSS 0.30111f $ **FLOATING
C3431 a_26665_14994.t1 VSS 0.14061f $ **FLOATING
C3432 a_26665_14994.n0 VSS 0.37428f $ **FLOATING
C3433 a_21870_14629.t0 VSS 0.44639f $ **FLOATING
C3434 a_21870_14629.t1 VSS 0.38793f $ **FLOATING
C3435 a_22746_14693.t0 VSS 0.37297f $ **FLOATING
C3436 a_22746_14693.t1 VSS 0.37163f $ **FLOATING
C3437 a_24729_14690.t3 VSS 0.07497f $ **FLOATING
C3438 a_24729_14690.t4 VSS 0.07497f $ **FLOATING
C3439 a_24729_14690.n0 VSS 0.12649f $ **FLOATING
C3440 a_24729_14690.t2 VSS 0.07497f $ **FLOATING
C3441 a_24729_14690.t7 VSS 0.07497f $ **FLOATING
C3442 a_24729_14690.n1 VSS 0.16231f $ **FLOATING
C3443 a_24729_14690.t1 VSS 0.07497f $ **FLOATING
C3444 a_24729_14690.t6 VSS 0.07497f $ **FLOATING
C3445 a_24729_14690.n2 VSS 0.16231f $ **FLOATING
C3446 a_24729_14690.t0 VSS 0.07497f $ **FLOATING
C3447 a_24729_14690.t5 VSS 0.07497f $ **FLOATING
C3448 a_24729_14690.n3 VSS 0.12649f $ **FLOATING
C3449 a_26759_14994.t0 VSS 0.03798f $ **FLOATING
C3450 a_26970_14598.t0 VSS 0.13446f $ **FLOATING
C3451 a_26970_14598.t1 VSS 0.2072f $ **FLOATING
C3452 a_26970_14598.n0 VSS 0.58104f $ **FLOATING
C3453 a_26970_14598.t2 VSS 0.28375f $ **FLOATING
C3454 a_27359_14914.t2 VSS 0.16172f $ **FLOATING
C3455 a_27359_14914.t3 VSS 0.18527f $ **FLOATING
C3456 a_27359_14914.t1 VSS 0.25378f $ **FLOATING
C3457 a_27359_14914.t0 VSS 0.25293f $ **FLOATING
C3458 a_27359_14914.n0 VSS 0.39432f $ **FLOATING
C3459 a_27359_14914.n1 VSS 0.36214f $ **FLOATING
C3460 a_28075_14839.t0 VSS 0.14671f $ **FLOATING
C3461 a_28075_14839.t1 VSS 0.14824f $ **FLOATING
C3462 a_28075_14839.t2 VSS 0.13696f $ **FLOATING
C3463 a_28075_14839.t3 VSS 0.31241f $ **FLOATING
C3464 a_28075_14839.n0 VSS 0.43823f $ **FLOATING
C3465 a_28075_14839.n1 VSS 0.34323f $ **FLOATING
C3466 a_27815_14616.t0 VSS 0.17004f $ **FLOATING
C3467 a_27815_14616.t3 VSS 0.16418f $ **FLOATING
C3468 a_27815_14616.n0 VSS 1.06952f $ **FLOATING
C3469 a_27815_14616.t2 VSS 0.18349f $ **FLOATING
C3470 a_27815_14616.n1 VSS 0.98657f $ **FLOATING
C3471 a_27815_14616.t1 VSS 0.18249f $ **FLOATING
C3472 a_28101_14934.t1 VSS 0.19141f $ **FLOATING
C3473 a_28101_14934.t4 VSS 0.2471f $ **FLOATING
C3474 a_28101_14934.n0 VSS 0.50756f $ **FLOATING
C3475 a_28101_14934.t3 VSS 0.2694f $ **FLOATING
C3476 a_28101_14934.t0 VSS 0.27165f $ **FLOATING
C3477 a_28101_14934.n1 VSS 0.81771f $ **FLOATING
C3478 a_28101_14934.t2 VSS 0.2757f $ **FLOATING
C3479 a_28101_14934.n2 VSS 0.49603f $ **FLOATING
C3480 a_28510_14873.t0 VSS 0.1549f $ **FLOATING
C3481 a_28510_14873.t3 VSS 0.60107f $ **FLOATING
C3482 a_28510_14873.n0 VSS 0.31831f $ **FLOATING
C3483 a_28510_14873.t1 VSS 0.22669f $ **FLOATING
C3484 a_28510_14873.n1 VSS 0.18029f $ **FLOATING
C3485 a_28510_14873.t2 VSS 0.2507f $ **FLOATING
C3486 a_28612_14960.t0 VSS 0.20064f $ **FLOATING
C3487 a_28612_14960.t3 VSS 0.28262f $ **FLOATING
C3488 a_28612_14960.n0 VSS 0.63449f $ **FLOATING
C3489 a_28612_14960.t1 VSS 0.30492f $ **FLOATING
C3490 a_28612_14960.t2 VSS 0.27265f $ **FLOATING
C3491 a_28612_14960.n1 VSS 0.34141f $ **FLOATING
C3492 a_27258_14617.t1 VSS 0.0901f $ **FLOATING
C3493 a_27258_14617.t0 VSS 0.09248f $ **FLOATING
C3494 a_27258_14617.t2 VSS 0.08412f $ **FLOATING
C3495 a_27258_14617.n0 VSS 0.26107f $ **FLOATING
C3496 a_29360_14693.t0 VSS 0.15513f $ **FLOATING
C3497 a_29360_14693.t2 VSS 0.78293f $ **FLOATING
C3498 a_29360_14693.n0 VSS 0.44013f $ **FLOATING
C3499 a_29360_14693.t1 VSS 0.23527f $ **FLOATING
C3500 a_29588_14833.t0 VSS 0.10861f $ **FLOATING
C3501 a_29588_14833.t1 VSS 0.1094f $ **FLOATING
C3502 a_29588_14833.n0 VSS 0.47589f $ **FLOATING
C3503 a_29588_14833.t2 VSS 0.21808f $ **FLOATING
C3504 a_30161_14894.t0 VSS 0.08718f $ **FLOATING
C3505 a_30161_14894.t2 VSS 0.28889f $ **FLOATING
C3506 a_30161_14894.t1 VSS 0.13908f $ **FLOATING
C3507 a_30161_14894.n0 VSS 0.3269f $ **FLOATING
C3508 a_33185_14994.t0 VSS 0.08957f $ **FLOATING
C3509 a_33185_14994.t2 VSS 0.30075f $ **FLOATING
C3510 a_33185_14994.t1 VSS 0.14044f $ **FLOATING
C3511 a_33185_14994.n0 VSS 0.37383f $ **FLOATING
C3512 a_28390_14629.t0 VSS 0.44638f $ **FLOATING
C3513 a_28390_14629.t1 VSS 0.38792f $ **FLOATING
C3514 a_29266_14693.t0 VSS 0.37163f $ **FLOATING
C3515 a_29266_14693.t1 VSS 0.37297f $ **FLOATING
C3516 a_31249_14690.t3 VSS 0.07496f $ **FLOATING
C3517 a_31249_14690.t6 VSS 0.07496f $ **FLOATING
C3518 a_31249_14690.n0 VSS 0.12648f $ **FLOATING
C3519 a_31249_14690.t2 VSS 0.07496f $ **FLOATING
C3520 a_31249_14690.t7 VSS 0.07496f $ **FLOATING
C3521 a_31249_14690.n1 VSS 0.1623f $ **FLOATING
C3522 a_31249_14690.t1 VSS 0.07496f $ **FLOATING
C3523 a_31249_14690.t5 VSS 0.07496f $ **FLOATING
C3524 a_31249_14690.n2 VSS 0.1623f $ **FLOATING
C3525 a_31249_14690.t0 VSS 0.07496f $ **FLOATING
C3526 a_31249_14690.t4 VSS 0.07496f $ **FLOATING
C3527 a_31249_14690.n3 VSS 0.12648f $ **FLOATING
C3528 a_33279_14994.t0 VSS 0.03791f $ **FLOATING
C3529 a_33490_14598.t0 VSS 0.13464f $ **FLOATING
C3530 a_33490_14598.t1 VSS 0.20749f $ **FLOATING
C3531 a_33490_14598.n0 VSS 0.58184f $ **FLOATING
C3532 a_33490_14598.t2 VSS 0.28414f $ **FLOATING
C3533 a_33879_14914.t0 VSS 0.16246f $ **FLOATING
C3534 a_33879_14914.t3 VSS 0.18612f $ **FLOATING
C3535 a_33879_14914.t1 VSS 0.25494f $ **FLOATING
C3536 a_33879_14914.t2 VSS 0.25409f $ **FLOATING
C3537 a_33879_14914.n0 VSS 0.39612f $ **FLOATING
C3538 a_33879_14914.n1 VSS 0.3638f $ **FLOATING
C3539 a_34595_14839.t0 VSS 0.13698f $ **FLOATING
C3540 a_34595_14839.t3 VSS 0.31246f $ **FLOATING
C3541 a_34595_14839.t1 VSS 0.14827f $ **FLOATING
C3542 a_34595_14839.t2 VSS 0.14674f $ **FLOATING
C3543 a_34595_14839.n0 VSS 0.34329f $ **FLOATING
C3544 a_34595_14839.n1 VSS 0.43831f $ **FLOATING
C3545 a_34335_14616.t0 VSS 0.18353f $ **FLOATING
C3546 a_34335_14616.t2 VSS 0.16421f $ **FLOATING
C3547 a_34335_14616.n0 VSS 1.06977f $ **FLOATING
C3548 a_34335_14616.t1 VSS 0.17008f $ **FLOATING
C3549 a_34335_14616.t3 VSS 0.18253f $ **FLOATING
C3550 a_34335_14616.n1 VSS 0.98679f $ **FLOATING
C3551 a_34621_14934.t1 VSS 0.26945f $ **FLOATING
C3552 a_34621_14934.t4 VSS 0.24715f $ **FLOATING
C3553 a_34621_14934.t3 VSS 0.27575f $ **FLOATING
C3554 a_34621_14934.n0 VSS 0.49612f $ **FLOATING
C3555 a_34621_14934.t2 VSS 0.19145f $ **FLOATING
C3556 a_34621_14934.n1 VSS 0.50765f $ **FLOATING
C3557 a_34621_14934.t0 VSS 0.2717f $ **FLOATING
C3558 a_34621_14934.n2 VSS 0.81786f $ **FLOATING
C3559 a_35030_14873.t0 VSS 0.15492f $ **FLOATING
C3560 a_35030_14873.t3 VSS 0.60114f $ **FLOATING
C3561 a_35030_14873.n0 VSS 0.31835f $ **FLOATING
C3562 a_35030_14873.t1 VSS 0.22671f $ **FLOATING
C3563 a_35030_14873.n1 VSS 0.18031f $ **FLOATING
C3564 a_35030_14873.t2 VSS 0.25073f $ **FLOATING
C3565 a_35132_14960.t0 VSS 0.20065f $ **FLOATING
C3566 a_35132_14960.t3 VSS 0.28264f $ **FLOATING
C3567 a_35132_14960.n0 VSS 0.63453f $ **FLOATING
C3568 a_35132_14960.t1 VSS 0.30494f $ **FLOATING
C3569 a_35132_14960.t2 VSS 0.27267f $ **FLOATING
C3570 a_35132_14960.n1 VSS 0.34144f $ **FLOATING
C3571 a_33778_14617.t1 VSS 0.08471f $ **FLOATING
C3572 a_33778_14617.n0 VSS 0.26288f $ **FLOATING
C3573 a_33778_14617.t0 VSS 0.09073f $ **FLOATING
C3574 a_33778_14617.t2 VSS 0.09313f $ **FLOATING
C3575 a_35880_14693.t1 VSS 0.15513f $ **FLOATING
C3576 a_35880_14693.t2 VSS 0.78293f $ **FLOATING
C3577 a_35880_14693.n0 VSS 0.44013f $ **FLOATING
C3578 a_35880_14693.t0 VSS 0.23527f $ **FLOATING
C3579 a_36108_14833.t0 VSS 0.10861f $ **FLOATING
C3580 a_36108_14833.t1 VSS 0.1094f $ **FLOATING
C3581 a_36108_14833.n0 VSS 0.47589f $ **FLOATING
C3582 a_36108_14833.t2 VSS 0.21808f $ **FLOATING
C3583 a_36681_14894.t0 VSS 0.08718f $ **FLOATING
C3584 a_36681_14894.t2 VSS 0.28889f $ **FLOATING
C3585 a_36681_14894.t1 VSS 0.13908f $ **FLOATING
C3586 a_36681_14894.n0 VSS 0.3269f $ **FLOATING
C3587 a_39705_14994.t0 VSS 0.0896f $ **FLOATING
C3588 a_39705_14994.t2 VSS 0.30086f $ **FLOATING
C3589 a_39705_14994.t1 VSS 0.14049f $ **FLOATING
C3590 a_39705_14994.n0 VSS 0.37397f $ **FLOATING
C3591 a_34910_14629.t0 VSS 0.44642f $ **FLOATING
C3592 a_34910_14629.t1 VSS 0.38795f $ **FLOATING
C3593 a_35786_14693.t0 VSS 0.37163f $ **FLOATING
C3594 a_35786_14693.t1 VSS 0.37297f $ **FLOATING
C3595 a_37769_14690.t3 VSS 0.07496f $ **FLOATING
C3596 a_37769_14690.t6 VSS 0.07496f $ **FLOATING
C3597 a_37769_14690.n0 VSS 0.12648f $ **FLOATING
C3598 a_37769_14690.t2 VSS 0.07496f $ **FLOATING
C3599 a_37769_14690.t7 VSS 0.07496f $ **FLOATING
C3600 a_37769_14690.n1 VSS 0.1623f $ **FLOATING
C3601 a_37769_14690.t1 VSS 0.07496f $ **FLOATING
C3602 a_37769_14690.t5 VSS 0.07496f $ **FLOATING
C3603 a_37769_14690.n2 VSS 0.1623f $ **FLOATING
C3604 a_37769_14690.t0 VSS 0.07496f $ **FLOATING
C3605 a_37769_14690.t4 VSS 0.07496f $ **FLOATING
C3606 a_37769_14690.n3 VSS 0.12648f $ **FLOATING
C3607 a_39799_14994.t0 VSS 0.03794f $ **FLOATING
C3608 a_40010_14598.t0 VSS 0.13452f $ **FLOATING
C3609 a_40010_14598.t1 VSS 0.2073f $ **FLOATING
C3610 a_40010_14598.n0 VSS 0.58131f $ **FLOATING
C3611 a_40010_14598.t2 VSS 0.28388f $ **FLOATING
C3612 a_40399_14914.t0 VSS 0.16212f $ **FLOATING
C3613 a_40399_14914.t3 VSS 0.18573f $ **FLOATING
C3614 a_40399_14914.t1 VSS 0.2544f $ **FLOATING
C3615 a_40399_14914.t2 VSS 0.25356f $ **FLOATING
C3616 a_40399_14914.n0 VSS 0.39529f $ **FLOATING
C3617 a_40399_14914.n1 VSS 0.36304f $ **FLOATING
C3618 a_41115_14839.t0 VSS 0.14826f $ **FLOATING
C3619 a_41115_14839.t2 VSS 0.13697f $ **FLOATING
C3620 a_41115_14839.t3 VSS 0.31244f $ **FLOATING
C3621 a_41115_14839.n0 VSS 0.43828f $ **FLOATING
C3622 a_41115_14839.n1 VSS 0.34327f $ **FLOATING
C3623 a_41115_14839.t1 VSS 0.14673f $ **FLOATING
C3624 a_40855_14616.t0 VSS 0.17006f $ **FLOATING
C3625 a_40855_14616.t1 VSS 0.1642f $ **FLOATING
C3626 a_40855_14616.n0 VSS 1.06968f $ **FLOATING
C3627 a_40855_14616.t2 VSS 0.18352f $ **FLOATING
C3628 a_40855_14616.n1 VSS 0.98672f $ **FLOATING
C3629 a_40855_14616.t3 VSS 0.18251f $ **FLOATING
C3630 a_41141_14934.t1 VSS 0.26943f $ **FLOATING
C3631 a_41141_14934.t4 VSS 0.24713f $ **FLOATING
C3632 a_41141_14934.t3 VSS 0.27573f $ **FLOATING
C3633 a_41141_14934.n0 VSS 0.49609f $ **FLOATING
C3634 a_41141_14934.t2 VSS 0.19144f $ **FLOATING
C3635 a_41141_14934.n1 VSS 0.50762f $ **FLOATING
C3636 a_41141_14934.t0 VSS 0.27168f $ **FLOATING
C3637 a_41141_14934.n2 VSS 0.81781f $ **FLOATING
C3638 a_41550_14873.t0 VSS 0.15491f $ **FLOATING
C3639 a_41550_14873.t3 VSS 0.60112f $ **FLOATING
C3640 a_41550_14873.n0 VSS 0.31834f $ **FLOATING
C3641 a_41550_14873.t1 VSS 0.22671f $ **FLOATING
C3642 a_41550_14873.n1 VSS 0.1803f $ **FLOATING
C3643 a_41550_14873.t2 VSS 0.25072f $ **FLOATING
C3644 a_41652_14960.t0 VSS 0.20064f $ **FLOATING
C3645 a_41652_14960.t3 VSS 0.28264f $ **FLOATING
C3646 a_41652_14960.n0 VSS 0.63451f $ **FLOATING
C3647 a_41652_14960.t1 VSS 0.30494f $ **FLOATING
C3648 a_41652_14960.t2 VSS 0.27266f $ **FLOATING
C3649 a_41652_14960.n1 VSS 0.34143f $ **FLOATING
C3650 a_40298_14617.t1 VSS 0.08445f $ **FLOATING
C3651 a_40298_14617.n0 VSS 0.26208f $ **FLOATING
C3652 a_40298_14617.t0 VSS 0.09045f $ **FLOATING
C3653 a_40298_14617.t2 VSS 0.09284f $ **FLOATING
C3654 a_42400_14693.t0 VSS 0.15513f $ **FLOATING
C3655 a_42400_14693.t2 VSS 0.78293f $ **FLOATING
C3656 a_42400_14693.n0 VSS 0.44013f $ **FLOATING
C3657 a_42400_14693.t1 VSS 0.23527f $ **FLOATING
C3658 a_42628_14833.t0 VSS 0.10861f $ **FLOATING
C3659 a_42628_14833.t1 VSS 0.1094f $ **FLOATING
C3660 a_42628_14833.n0 VSS 0.47589f $ **FLOATING
C3661 a_42628_14833.t2 VSS 0.21808f $ **FLOATING
C3662 a_43201_14894.t0 VSS 0.08718f $ **FLOATING
C3663 a_43201_14894.t2 VSS 0.28889f $ **FLOATING
C3664 a_43201_14894.t1 VSS 0.13908f $ **FLOATING
C3665 a_43201_14894.n0 VSS 0.3269f $ **FLOATING
C3666 a_46225_14994.t0 VSS 0.07049f $ **FLOATING
C3667 a_46225_14994.t2 VSS 0.23668f $ **FLOATING
C3668 a_46225_14994.t1 VSS 0.11053f $ **FLOATING
C3669 a_46225_14994.n0 VSS 0.2942f $ **FLOATING
C3670 a_41430_14629.t0 VSS 0.4464f $ **FLOATING
C3671 a_41430_14629.t1 VSS 0.38794f $ **FLOATING
C3672 a_42306_14693.t0 VSS 0.37163f $ **FLOATING
C3673 a_42306_14693.t1 VSS 0.37297f $ **FLOATING
C3674 a_44289_14690.t3 VSS 0.0747f $ **FLOATING
C3675 a_44289_14690.t4 VSS 0.0747f $ **FLOATING
C3676 a_44289_14690.n0 VSS 0.12604f $ **FLOATING
C3677 a_44289_14690.t2 VSS 0.0747f $ **FLOATING
C3678 a_44289_14690.t5 VSS 0.0747f $ **FLOATING
C3679 a_44289_14690.n1 VSS 0.16173f $ **FLOATING
C3680 a_44289_14690.t1 VSS 0.0747f $ **FLOATING
C3681 a_44289_14690.t7 VSS 0.0747f $ **FLOATING
C3682 a_44289_14690.n2 VSS 0.16173f $ **FLOATING
C3683 a_44289_14690.t0 VSS 0.0747f $ **FLOATING
C3684 a_44289_14690.t6 VSS 0.0747f $ **FLOATING
C3685 a_44289_14690.n3 VSS 0.12604f $ **FLOATING
C3686 a_46319_14994.t0 VSS 0.02042f $ **FLOATING
C3687 a_46530_14598.t0 VSS 0.13327f $ **FLOATING
C3688 a_46530_14598.t1 VSS 0.20538f $ **FLOATING
C3689 a_46530_14598.n0 VSS 0.57593f $ **FLOATING
C3690 a_46530_14598.t2 VSS 0.28125f $ **FLOATING
C3691 a_46919_14914.t1 VSS 0.16211f $ **FLOATING
C3692 a_46919_14914.t3 VSS 0.18572f $ **FLOATING
C3693 a_46919_14914.t2 VSS 0.25438f $ **FLOATING
C3694 a_46919_14914.t0 VSS 0.25354f $ **FLOATING
C3695 a_46919_14914.n0 VSS 0.39526f $ **FLOATING
C3696 a_46919_14914.n1 VSS 0.36301f $ **FLOATING
C3697 a_47635_14839.t0 VSS 0.14826f $ **FLOATING
C3698 a_47635_14839.t2 VSS 0.13697f $ **FLOATING
C3699 a_47635_14839.t3 VSS 0.31244f $ **FLOATING
C3700 a_47635_14839.n0 VSS 0.43828f $ **FLOATING
C3701 a_47635_14839.n1 VSS 0.34327f $ **FLOATING
C3702 a_47635_14839.t1 VSS 0.14673f $ **FLOATING
C3703 a_47375_14616.t0 VSS 0.18251f $ **FLOATING
C3704 a_47375_14616.t1 VSS 0.18352f $ **FLOATING
C3705 a_47375_14616.n0 VSS 0.98672f $ **FLOATING
C3706 a_47375_14616.t2 VSS 0.1642f $ **FLOATING
C3707 a_47375_14616.n1 VSS 1.06968f $ **FLOATING
C3708 a_47375_14616.t3 VSS 0.17006f $ **FLOATING
C3709 a_47661_14934.t0 VSS 0.19144f $ **FLOATING
C3710 a_47661_14934.t4 VSS 0.24713f $ **FLOATING
C3711 a_47661_14934.n0 VSS 0.50762f $ **FLOATING
C3712 a_47661_14934.t2 VSS 0.26943f $ **FLOATING
C3713 a_47661_14934.t3 VSS 0.27168f $ **FLOATING
C3714 a_47661_14934.n1 VSS 0.81781f $ **FLOATING
C3715 a_47661_14934.t1 VSS 0.27573f $ **FLOATING
C3716 a_47661_14934.n2 VSS 0.49609f $ **FLOATING
C3717 a_48070_14873.t0 VSS 0.15491f $ **FLOATING
C3718 a_48070_14873.t3 VSS 0.60112f $ **FLOATING
C3719 a_48070_14873.n0 VSS 0.31834f $ **FLOATING
C3720 a_48070_14873.t1 VSS 0.22671f $ **FLOATING
C3721 a_48070_14873.n1 VSS 0.1803f $ **FLOATING
C3722 a_48070_14873.t2 VSS 0.25072f $ **FLOATING
C3723 a_48172_14960.t0 VSS 0.20064f $ **FLOATING
C3724 a_48172_14960.t3 VSS 0.28264f $ **FLOATING
C3725 a_48172_14960.n0 VSS 0.63451f $ **FLOATING
C3726 a_48172_14960.t1 VSS 0.30494f $ **FLOATING
C3727 a_48172_14960.t2 VSS 0.27266f $ **FLOATING
C3728 a_48172_14960.n1 VSS 0.34143f $ **FLOATING
C3729 a_46818_14617.t1 VSS 0.09028f $ **FLOATING
C3730 a_46818_14617.t0 VSS 0.09266f $ **FLOATING
C3731 a_46818_14617.t2 VSS 0.08429f $ **FLOATING
C3732 a_46818_14617.n0 VSS 0.26158f $ **FLOATING
C3733 a_48920_14693.t1 VSS 0.15513f $ **FLOATING
C3734 a_48920_14693.t2 VSS 0.78293f $ **FLOATING
C3735 a_48920_14693.n0 VSS 0.44013f $ **FLOATING
C3736 a_48920_14693.t0 VSS 0.23527f $ **FLOATING
C3737 a_49148_14833.t0 VSS 0.10861f $ **FLOATING
C3738 a_49148_14833.t1 VSS 0.1094f $ **FLOATING
C3739 a_49148_14833.n0 VSS 0.47589f $ **FLOATING
C3740 a_49148_14833.t2 VSS 0.21808f $ **FLOATING
C3741 a_49721_14894.t0 VSS 0.08718f $ **FLOATING
C3742 a_49721_14894.t2 VSS 0.28889f $ **FLOATING
C3743 a_49721_14894.t1 VSS 0.13908f $ **FLOATING
C3744 a_49721_14894.n0 VSS 0.3269f $ **FLOATING
C3745 a_47950_14629.t0 VSS 0.38794f $ **FLOATING
C3746 a_47950_14629.t1 VSS 0.4464f $ **FLOATING
C3747 a_48826_14693.t0 VSS 0.37163f $ **FLOATING
C3748 a_48826_14693.t1 VSS 0.37297f $ **FLOATING
C3749 a_50809_14690.t3 VSS 0.07465f $ **FLOATING
C3750 a_50809_14690.t4 VSS 0.07465f $ **FLOATING
C3751 a_50809_14690.n0 VSS 0.12595f $ **FLOATING
C3752 a_50809_14690.t2 VSS 0.07465f $ **FLOATING
C3753 a_50809_14690.t5 VSS 0.07465f $ **FLOATING
C3754 a_50809_14690.n1 VSS 0.16162f $ **FLOATING
C3755 a_50809_14690.t1 VSS 0.07465f $ **FLOATING
C3756 a_50809_14690.t7 VSS 0.07465f $ **FLOATING
C3757 a_50809_14690.n2 VSS 0.16162f $ **FLOATING
C3758 a_50809_14690.t0 VSS 0.07465f $ **FLOATING
C3759 a_50809_14690.t6 VSS 0.07465f $ **FLOATING
C3760 a_50809_14690.n3 VSS 0.12595f $ **FLOATING
C3761 a_3877_12094.t0 VSS 0.06039f $ **FLOATING
C3762 a_3877_12094.n0 VSS 0.63583f $ **FLOATING
C3763 a_3877_12094.t2 VSS 0.43776f $ **FLOATING
C3764 a_3877_12094.t1 VSS 0.09863f $ **FLOATING
C3765 a_10397_12094.t0 VSS 0.06039f $ **FLOATING
C3766 a_10397_12094.n0 VSS 0.63584f $ **FLOATING
C3767 a_10397_12094.t2 VSS 0.43777f $ **FLOATING
C3768 a_10397_12094.t1 VSS 0.09863f $ **FLOATING
C3769 a_4298_12114.t0 VSS 0.06067f $ **FLOATING
C3770 a_4298_12114.t1 VSS 0.09886f $ **FLOATING
C3771 a_4298_12114.n0 VSS 0.62316f $ **FLOATING
C3772 a_4298_12114.t2 VSS 0.26475f $ **FLOATING
C3773 a_16917_12094.t0 VSS 0.06039f $ **FLOATING
C3774 a_16917_12094.n0 VSS 0.63581f $ **FLOATING
C3775 a_16917_12094.t2 VSS 0.43775f $ **FLOATING
C3776 a_16917_12094.t1 VSS 0.09863f $ **FLOATING
C3777 a_10818_12114.t0 VSS 0.06067f $ **FLOATING
C3778 a_10818_12114.t1 VSS 0.09886f $ **FLOATING
C3779 a_10818_12114.n0 VSS 0.62316f $ **FLOATING
C3780 a_10818_12114.t2 VSS 0.26475f $ **FLOATING
C3781 a_23437_12094.t0 VSS 0.06039f $ **FLOATING
C3782 a_23437_12094.n0 VSS 0.63584f $ **FLOATING
C3783 a_23437_12094.t2 VSS 0.43777f $ **FLOATING
C3784 a_23437_12094.t1 VSS 0.09863f $ **FLOATING
C3785 a_17338_12114.t0 VSS 0.06067f $ **FLOATING
C3786 a_17338_12114.t1 VSS 0.09886f $ **FLOATING
C3787 a_17338_12114.n0 VSS 0.62316f $ **FLOATING
C3788 a_17338_12114.t2 VSS 0.26475f $ **FLOATING
C3789 a_29957_12094.t0 VSS 0.06038f $ **FLOATING
C3790 a_29957_12094.n0 VSS 0.63573f $ **FLOATING
C3791 a_29957_12094.t2 VSS 0.43769f $ **FLOATING
C3792 a_29957_12094.t1 VSS 0.09861f $ **FLOATING
C3793 a_23858_12114.t0 VSS 0.06067f $ **FLOATING
C3794 a_23858_12114.t1 VSS 0.09886f $ **FLOATING
C3795 a_23858_12114.n0 VSS 0.62316f $ **FLOATING
C3796 a_23858_12114.t2 VSS 0.26475f $ **FLOATING
C3797 a_36477_12094.t0 VSS 0.06038f $ **FLOATING
C3798 a_36477_12094.n0 VSS 0.63575f $ **FLOATING
C3799 a_36477_12094.t2 VSS 0.43771f $ **FLOATING
C3800 a_36477_12094.t1 VSS 0.09862f $ **FLOATING
C3801 a_30378_12114.t0 VSS 0.06067f $ **FLOATING
C3802 a_30378_12114.t1 VSS 0.09886f $ **FLOATING
C3803 a_30378_12114.n0 VSS 0.62316f $ **FLOATING
C3804 a_30378_12114.t2 VSS 0.26475f $ **FLOATING
C3805 a_42997_12094.t0 VSS 0.06037f $ **FLOATING
C3806 a_42997_12094.n0 VSS 0.63567f $ **FLOATING
C3807 a_42997_12094.t2 VSS 0.43765f $ **FLOATING
C3808 a_42997_12094.t1 VSS 0.09861f $ **FLOATING
C3809 a_36898_12114.t0 VSS 0.06067f $ **FLOATING
C3810 a_36898_12114.t1 VSS 0.09886f $ **FLOATING
C3811 a_36898_12114.n0 VSS 0.62315f $ **FLOATING
C3812 a_36898_12114.t2 VSS 0.26475f $ **FLOATING
C3813 a_49517_12094.t0 VSS 0.06037f $ **FLOATING
C3814 a_49517_12094.n0 VSS 0.63561f $ **FLOATING
C3815 a_49517_12094.t2 VSS 0.43761f $ **FLOATING
C3816 a_49517_12094.t1 VSS 0.0986f $ **FLOATING
C3817 a_43418_12114.t0 VSS 0.06066f $ **FLOATING
C3818 a_43418_12114.t1 VSS 0.09885f $ **FLOATING
C3819 a_43418_12114.n0 VSS 0.62309f $ **FLOATING
C3820 a_43418_12114.t2 VSS 0.26472f $ **FLOATING
C3821 a_49938_12114.t0 VSS 0.06067f $ **FLOATING
C3822 a_49938_12114.t1 VSS 0.09886f $ **FLOATING
C3823 a_49938_12114.n0 VSS 0.62315f $ **FLOATING
C3824 a_49938_12114.t2 VSS 0.26474f $ **FLOATING
C3825 a_5003_12150.t9 VSS 0.12816f $ **FLOATING
C3826 a_5003_12150.t8 VSS 0.12742f $ **FLOATING
C3827 a_5003_12150.n0 VSS 0.31237f $ **FLOATING
C3828 a_5003_12150.t5 VSS 0.09877f $ **FLOATING
C3829 a_5003_12150.n1 VSS 0.38034f $ **FLOATING
C3830 a_5003_12150.t4 VSS 0.0965f $ **FLOATING
C3831 a_5003_12150.n2 VSS 0.33102f $ **FLOATING
C3832 a_5003_12150.t0 VSS 0.1108f $ **FLOATING
C3833 a_5003_12150.t6 VSS 0.0965f $ **FLOATING
C3834 a_5003_12150.n3 VSS 0.33102f $ **FLOATING
C3835 a_5003_12150.t1 VSS 0.1108f $ **FLOATING
C3836 a_5003_12150.t2 VSS 0.14548f $ **FLOATING
C3837 a_5003_12150.t7 VSS 0.12816f $ **FLOATING
C3838 a_5003_12150.n4 VSS 0.34636f $ **FLOATING
C3839 a_5003_12150.t3 VSS 0.14548f $ **FLOATING
C3840 a_5003_12150.n5 VSS 0.34636f $ **FLOATING
C3841 a_11523_12150.t9 VSS 0.12816f $ **FLOATING
C3842 a_11523_12150.t8 VSS 0.12742f $ **FLOATING
C3843 a_11523_12150.n0 VSS 0.31239f $ **FLOATING
C3844 a_11523_12150.t5 VSS 0.09878f $ **FLOATING
C3845 a_11523_12150.n1 VSS 0.38036f $ **FLOATING
C3846 a_11523_12150.t4 VSS 0.0965f $ **FLOATING
C3847 a_11523_12150.n2 VSS 0.33104f $ **FLOATING
C3848 a_11523_12150.t0 VSS 0.1108f $ **FLOATING
C3849 a_11523_12150.t6 VSS 0.0965f $ **FLOATING
C3850 a_11523_12150.n3 VSS 0.33104f $ **FLOATING
C3851 a_11523_12150.t1 VSS 0.1108f $ **FLOATING
C3852 a_11523_12150.t2 VSS 0.14549f $ **FLOATING
C3853 a_11523_12150.t7 VSS 0.12816f $ **FLOATING
C3854 a_11523_12150.n4 VSS 0.34637f $ **FLOATING
C3855 a_11523_12150.t3 VSS 0.14549f $ **FLOATING
C3856 a_11523_12150.n5 VSS 0.34637f $ **FLOATING
C3857 a_18043_12150.t9 VSS 0.12816f $ **FLOATING
C3858 a_18043_12150.t8 VSS 0.12741f $ **FLOATING
C3859 a_18043_12150.n0 VSS 0.31237f $ **FLOATING
C3860 a_18043_12150.t6 VSS 0.09877f $ **FLOATING
C3861 a_18043_12150.n1 VSS 0.38034f $ **FLOATING
C3862 a_18043_12150.t4 VSS 0.0965f $ **FLOATING
C3863 a_18043_12150.n2 VSS 0.33102f $ **FLOATING
C3864 a_18043_12150.t0 VSS 0.1108f $ **FLOATING
C3865 a_18043_12150.t5 VSS 0.0965f $ **FLOATING
C3866 a_18043_12150.n3 VSS 0.33102f $ **FLOATING
C3867 a_18043_12150.t1 VSS 0.1108f $ **FLOATING
C3868 a_18043_12150.t2 VSS 0.14548f $ **FLOATING
C3869 a_18043_12150.t7 VSS 0.12816f $ **FLOATING
C3870 a_18043_12150.n4 VSS 0.34635f $ **FLOATING
C3871 a_18043_12150.t3 VSS 0.14548f $ **FLOATING
C3872 a_18043_12150.n5 VSS 0.34635f $ **FLOATING
C3873 a_24563_12150.t9 VSS 0.12816f $ **FLOATING
C3874 a_24563_12150.t8 VSS 0.12742f $ **FLOATING
C3875 a_24563_12150.n0 VSS 0.31238f $ **FLOATING
C3876 a_24563_12150.t6 VSS 0.09877f $ **FLOATING
C3877 a_24563_12150.n1 VSS 0.38035f $ **FLOATING
C3878 a_24563_12150.t4 VSS 0.0965f $ **FLOATING
C3879 a_24563_12150.n2 VSS 0.33103f $ **FLOATING
C3880 a_24563_12150.t0 VSS 0.1108f $ **FLOATING
C3881 a_24563_12150.t5 VSS 0.0965f $ **FLOATING
C3882 a_24563_12150.n3 VSS 0.33103f $ **FLOATING
C3883 a_24563_12150.t1 VSS 0.1108f $ **FLOATING
C3884 a_24563_12150.t2 VSS 0.14548f $ **FLOATING
C3885 a_24563_12150.t7 VSS 0.12816f $ **FLOATING
C3886 a_24563_12150.n4 VSS 0.34636f $ **FLOATING
C3887 a_24563_12150.t3 VSS 0.14548f $ **FLOATING
C3888 a_24563_12150.n5 VSS 0.34636f $ **FLOATING
C3889 a_31083_12150.t9 VSS 0.12815f $ **FLOATING
C3890 a_31083_12150.t8 VSS 0.12741f $ **FLOATING
C3891 a_31083_12150.n0 VSS 0.31236f $ **FLOATING
C3892 a_31083_12150.t6 VSS 0.09877f $ **FLOATING
C3893 a_31083_12150.n1 VSS 0.38033f $ **FLOATING
C3894 a_31083_12150.t4 VSS 0.09649f $ **FLOATING
C3895 a_31083_12150.n2 VSS 0.33101f $ **FLOATING
C3896 a_31083_12150.t0 VSS 0.11079f $ **FLOATING
C3897 a_31083_12150.t5 VSS 0.09649f $ **FLOATING
C3898 a_31083_12150.n3 VSS 0.33101f $ **FLOATING
C3899 a_31083_12150.t1 VSS 0.11079f $ **FLOATING
C3900 a_31083_12150.t2 VSS 0.14548f $ **FLOATING
C3901 a_31083_12150.t7 VSS 0.12815f $ **FLOATING
C3902 a_31083_12150.n4 VSS 0.34634f $ **FLOATING
C3903 a_31083_12150.t3 VSS 0.14548f $ **FLOATING
C3904 a_31083_12150.n5 VSS 0.34634f $ **FLOATING
C3905 a_37603_12150.t3 VSS 0.14548f $ **FLOATING
C3906 a_37603_12150.t7 VSS 0.12741f $ **FLOATING
C3907 a_37603_12150.n0 VSS 0.31236f $ **FLOATING
C3908 a_37603_12150.t9 VSS 0.09877f $ **FLOATING
C3909 a_37603_12150.n1 VSS 0.38033f $ **FLOATING
C3910 a_37603_12150.t4 VSS 0.0965f $ **FLOATING
C3911 a_37603_12150.n2 VSS 0.33101f $ **FLOATING
C3912 a_37603_12150.t0 VSS 0.11079f $ **FLOATING
C3913 a_37603_12150.t5 VSS 0.0965f $ **FLOATING
C3914 a_37603_12150.n3 VSS 0.33101f $ **FLOATING
C3915 a_37603_12150.t1 VSS 0.11079f $ **FLOATING
C3916 a_37603_12150.t2 VSS 0.14548f $ **FLOATING
C3917 a_37603_12150.t6 VSS 0.12815f $ **FLOATING
C3918 a_37603_12150.n4 VSS 0.34635f $ **FLOATING
C3919 a_37603_12150.t8 VSS 0.12815f $ **FLOATING
C3920 a_37603_12150.n5 VSS 0.34635f $ **FLOATING
C3921 a_44123_12150.t3 VSS 0.14509f $ **FLOATING
C3922 a_44123_12150.t7 VSS 0.12707f $ **FLOATING
C3923 a_44123_12150.n0 VSS 0.31153f $ **FLOATING
C3924 a_44123_12150.t9 VSS 0.09851f $ **FLOATING
C3925 a_44123_12150.n1 VSS 0.37932f $ **FLOATING
C3926 a_44123_12150.t4 VSS 0.09624f $ **FLOATING
C3927 a_44123_12150.n2 VSS 0.33013f $ **FLOATING
C3928 a_44123_12150.t0 VSS 0.1105f $ **FLOATING
C3929 a_44123_12150.t5 VSS 0.09624f $ **FLOATING
C3930 a_44123_12150.n3 VSS 0.33013f $ **FLOATING
C3931 a_44123_12150.t1 VSS 0.1105f $ **FLOATING
C3932 a_44123_12150.t2 VSS 0.14509f $ **FLOATING
C3933 a_44123_12150.t6 VSS 0.12781f $ **FLOATING
C3934 a_44123_12150.n4 VSS 0.34543f $ **FLOATING
C3935 a_44123_12150.t8 VSS 0.12781f $ **FLOATING
C3936 a_44123_12150.n5 VSS 0.34543f $ **FLOATING
C3937 a_50643_12150.t3 VSS 0.14502f $ **FLOATING
C3938 a_50643_12150.t5 VSS 0.12701f $ **FLOATING
C3939 a_50643_12150.n0 VSS 0.31138f $ **FLOATING
C3940 a_50643_12150.t9 VSS 0.09846f $ **FLOATING
C3941 a_50643_12150.n1 VSS 0.37913f $ **FLOATING
C3942 a_50643_12150.t7 VSS 0.09619f $ **FLOATING
C3943 a_50643_12150.n2 VSS 0.32997f $ **FLOATING
C3944 a_50643_12150.t0 VSS 0.11045f $ **FLOATING
C3945 a_50643_12150.t8 VSS 0.09619f $ **FLOATING
C3946 a_50643_12150.n3 VSS 0.32997f $ **FLOATING
C3947 a_50643_12150.t1 VSS 0.11045f $ **FLOATING
C3948 a_50643_12150.t2 VSS 0.14502f $ **FLOATING
C3949 a_50643_12150.t4 VSS 0.12775f $ **FLOATING
C3950 a_50643_12150.n4 VSS 0.34526f $ **FLOATING
C3951 a_50643_12150.t6 VSS 0.12775f $ **FLOATING
C3952 a_50643_12150.n5 VSS 0.34526f $ **FLOATING
C3953 a_585_12194.t0 VSS 0.09008f $ **FLOATING
C3954 a_585_12194.t2 VSS 0.30247f $ **FLOATING
C3955 a_585_12194.t1 VSS 0.14125f $ **FLOATING
C3956 a_585_12194.n0 VSS 0.37598f $ **FLOATING
C3957 a_679_12194.t0 VSS 0.03714f $ **FLOATING
C3958 a_890_11798.t0 VSS 0.13392f $ **FLOATING
C3959 a_890_11798.t1 VSS 0.20638f $ **FLOATING
C3960 a_890_11798.n0 VSS 0.57873f $ **FLOATING
C3961 a_890_11798.t2 VSS 0.28262f $ **FLOATING
C3962 a_n2770_240.t0 VSS 0.10533f $ **FLOATING
C3963 a_n2770_240.n0 VSS 4.13267f $ **FLOATING
C3964 a_n2770_240.t10 VSS 0.48083f $ **FLOATING
C3965 a_n2770_240.n1 VSS 12.6411f $ **FLOATING
C3966 a_n2770_240.t2 VSS 0.36617f $ **FLOATING
C3967 a_n2770_240.n2 VSS 4.58268f $ **FLOATING
C3968 a_n2770_240.t11 VSS 0.34038f $ **FLOATING
C3969 a_n2770_240.n3 VSS 5.1625f $ **FLOATING
C3970 a_n2770_240.t3 VSS 0.36617f $ **FLOATING
C3971 a_n2770_240.n4 VSS 4.58268f $ **FLOATING
C3972 a_n2770_240.t12 VSS 0.34038f $ **FLOATING
C3973 a_n2770_240.n5 VSS 5.1625f $ **FLOATING
C3974 a_n2770_240.t4 VSS 0.36617f $ **FLOATING
C3975 a_n2770_240.n6 VSS 4.58268f $ **FLOATING
C3976 a_n2770_240.t13 VSS 0.34038f $ **FLOATING
C3977 a_n2770_240.n7 VSS 5.1625f $ **FLOATING
C3978 a_n2770_240.t5 VSS 0.36617f $ **FLOATING
C3979 a_n2770_240.n8 VSS 4.58268f $ **FLOATING
C3980 a_n2770_240.t14 VSS 0.34038f $ **FLOATING
C3981 a_n2770_240.n9 VSS 5.1625f $ **FLOATING
C3982 a_n2770_240.t6 VSS 0.36617f $ **FLOATING
C3983 a_n2770_240.n10 VSS 4.58268f $ **FLOATING
C3984 a_n2770_240.t15 VSS 0.34038f $ **FLOATING
C3985 a_n2770_240.n11 VSS 5.1625f $ **FLOATING
C3986 a_n2770_240.t7 VSS 0.36617f $ **FLOATING
C3987 a_n2770_240.n12 VSS 4.58268f $ **FLOATING
C3988 a_n2770_240.t16 VSS 0.34038f $ **FLOATING
C3989 a_n2770_240.n13 VSS 5.1625f $ **FLOATING
C3990 a_n2770_240.t8 VSS 0.36617f $ **FLOATING
C3991 a_n2770_240.n14 VSS 4.58268f $ **FLOATING
C3992 a_n2770_240.t17 VSS 0.34038f $ **FLOATING
C3993 a_n2770_240.n15 VSS 15.2158f $ **FLOATING
C3994 a_n2770_240.t9 VSS 0.36617f $ **FLOATING
C3995 a_n2770_240.t1 VSS 0.15694f $ **FLOATING
C3996 a_1279_12114.t1 VSS 0.16148f $ **FLOATING
C3997 a_1279_12114.t3 VSS 0.18499f $ **FLOATING
C3998 a_1279_12114.t2 VSS 0.25339f $ **FLOATING
C3999 a_1279_12114.t0 VSS 0.25255f $ **FLOATING
C4000 a_1279_12114.n0 VSS 0.39372f $ **FLOATING
C4001 a_1279_12114.n1 VSS 0.3616f $ **FLOATING
C4002 a_1995_12039.t0 VSS 0.1463f $ **FLOATING
C4003 a_1995_12039.t1 VSS 0.14783f $ **FLOATING
C4004 a_1995_12039.t2 VSS 0.13657f $ **FLOATING
C4005 a_1995_12039.t3 VSS 0.31154f $ **FLOATING
C4006 a_1995_12039.n0 VSS 0.43701f $ **FLOATING
C4007 a_1995_12039.n1 VSS 0.34227f $ **FLOATING
C4008 a_1735_11816.t0 VSS 0.16961f $ **FLOATING
C4009 a_1735_11816.t1 VSS 0.16376f $ **FLOATING
C4010 a_1735_11816.n0 VSS 1.06683f $ **FLOATING
C4011 a_1735_11816.t2 VSS 0.18303f $ **FLOATING
C4012 a_1735_11816.n1 VSS 0.98409f $ **FLOATING
C4013 a_1735_11816.t3 VSS 0.18203f $ **FLOATING
C4014 a_2021_12134.t1 VSS 0.2688f $ **FLOATING
C4015 a_2021_12134.t4 VSS 0.24656f $ **FLOATING
C4016 a_2021_12134.t3 VSS 0.27509f $ **FLOATING
C4017 a_2021_12134.n0 VSS 0.49494f $ **FLOATING
C4018 a_2021_12134.t2 VSS 0.19099f $ **FLOATING
C4019 a_2021_12134.n1 VSS 0.50644f $ **FLOATING
C4020 a_2021_12134.t0 VSS 0.27105f $ **FLOATING
C4021 a_2021_12134.n2 VSS 0.81591f $ **FLOATING
C4022 a_2430_12073.t0 VSS 0.15438f $ **FLOATING
C4023 a_2430_12073.t3 VSS 0.59903f $ **FLOATING
C4024 a_2430_12073.n0 VSS 0.31723f $ **FLOATING
C4025 a_2430_12073.t1 VSS 0.22592f $ **FLOATING
C4026 a_2430_12073.n1 VSS 0.17968f $ **FLOATING
C4027 a_2430_12073.t2 VSS 0.24985f $ **FLOATING
C4028 a_2532_12160.t0 VSS 0.19992f $ **FLOATING
C4029 a_2532_12160.t3 VSS 0.28161f $ **FLOATING
C4030 a_2532_12160.n0 VSS 0.63221f $ **FLOATING
C4031 a_2532_12160.t1 VSS 0.30383f $ **FLOATING
C4032 a_2532_12160.t2 VSS 0.27167f $ **FLOATING
C4033 a_2532_12160.n1 VSS 0.34019f $ **FLOATING
C4034 a_1178_11817.t1 VSS 0.09016f $ **FLOATING
C4035 a_1178_11817.t0 VSS 0.09254f $ **FLOATING
C4036 a_1178_11817.t2 VSS 0.08418f $ **FLOATING
C4037 a_1178_11817.n0 VSS 0.26124f $ **FLOATING
C4038 a_3280_11893.t0 VSS 0.15436f $ **FLOATING
C4039 a_3280_11893.t2 VSS 0.77903f $ **FLOATING
C4040 a_3280_11893.n0 VSS 0.43794f $ **FLOATING
C4041 a_3280_11893.t1 VSS 0.2341f $ **FLOATING
C4042 a_3508_12033.t0 VSS 0.10822f $ **FLOATING
C4043 a_3508_12033.t1 VSS 0.10901f $ **FLOATING
C4044 a_3508_12033.n0 VSS 0.47419f $ **FLOATING
C4045 a_3508_12033.t2 VSS 0.2173f $ **FLOATING
C4046 a_4081_12094.t0 VSS 0.08657f $ **FLOATING
C4047 a_4081_12094.t2 VSS 0.28688f $ **FLOATING
C4048 a_4081_12094.t1 VSS 0.13811f $ **FLOATING
C4049 a_4081_12094.n0 VSS 0.32463f $ **FLOATING
C4050 a_7105_12194.t0 VSS 0.08911f $ **FLOATING
C4051 a_7105_12194.t2 VSS 0.29919f $ **FLOATING
C4052 a_7105_12194.t1 VSS 0.13972f $ **FLOATING
C4053 a_7105_12194.n0 VSS 0.3719f $ **FLOATING
C4054 a_2310_11829.t0 VSS 0.44582f $ **FLOATING
C4055 a_2310_11829.t1 VSS 0.38743f $ **FLOATING
C4056 a_3186_11893.t0 VSS 0.37257f $ **FLOATING
C4057 a_3186_11893.t1 VSS 0.37124f $ **FLOATING
C4058 a_5169_11890.t3 VSS 0.07442f $ **FLOATING
C4059 a_5169_11890.t4 VSS 0.07442f $ **FLOATING
C4060 a_5169_11890.n0 VSS 0.12557f $ **FLOATING
C4061 a_5169_11890.t2 VSS 0.07442f $ **FLOATING
C4062 a_5169_11890.t7 VSS 0.07442f $ **FLOATING
C4063 a_5169_11890.n1 VSS 0.16113f $ **FLOATING
C4064 a_5169_11890.t1 VSS 0.07442f $ **FLOATING
C4065 a_5169_11890.t6 VSS 0.07442f $ **FLOATING
C4066 a_5169_11890.n2 VSS 0.16113f $ **FLOATING
C4067 a_5169_11890.t0 VSS 0.07442f $ **FLOATING
C4068 a_5169_11890.t5 VSS 0.07442f $ **FLOATING
C4069 a_5169_11890.n3 VSS 0.12557f $ **FLOATING
C4070 a_7199_12194.t0 VSS 0.03717f $ **FLOATING
C4071 a_7410_11798.t0 VSS 0.13386f $ **FLOATING
C4072 a_7410_11798.t1 VSS 0.20629f $ **FLOATING
C4073 a_7410_11798.n0 VSS 0.57847f $ **FLOATING
C4074 a_7410_11798.t2 VSS 0.28249f $ **FLOATING
C4075 a_7799_12114.t1 VSS 0.16125f $ **FLOATING
C4076 a_7799_12114.t3 VSS 0.18474f $ **FLOATING
C4077 a_7799_12114.t2 VSS 0.25304f $ **FLOATING
C4078 a_7799_12114.t0 VSS 0.2522f $ **FLOATING
C4079 a_7799_12114.n0 VSS 0.39317f $ **FLOATING
C4080 a_7799_12114.n1 VSS 0.36109f $ **FLOATING
C4081 a_8515_12039.t0 VSS 0.14782f $ **FLOATING
C4082 a_8515_12039.t2 VSS 0.13656f $ **FLOATING
C4083 a_8515_12039.t3 VSS 0.31152f $ **FLOATING
C4084 a_8515_12039.n0 VSS 0.43698f $ **FLOATING
C4085 a_8515_12039.n1 VSS 0.34225f $ **FLOATING
C4086 a_8515_12039.t1 VSS 0.1463f $ **FLOATING
C4087 a_8255_11816.t0 VSS 0.18202f $ **FLOATING
C4088 a_8255_11816.t1 VSS 0.18302f $ **FLOATING
C4089 a_8255_11816.n0 VSS 0.98402f $ **FLOATING
C4090 a_8255_11816.t3 VSS 0.16375f $ **FLOATING
C4091 a_8255_11816.n1 VSS 1.06675f $ **FLOATING
C4092 a_8255_11816.t2 VSS 0.1696f $ **FLOATING
C4093 a_8541_12134.t0 VSS 0.19098f $ **FLOATING
C4094 a_8541_12134.t4 VSS 0.24655f $ **FLOATING
C4095 a_8541_12134.n0 VSS 0.50641f $ **FLOATING
C4096 a_8541_12134.t3 VSS 0.26879f $ **FLOATING
C4097 a_8541_12134.t2 VSS 0.27104f $ **FLOATING
C4098 a_8541_12134.n1 VSS 0.81586f $ **FLOATING
C4099 a_8541_12134.t1 VSS 0.27508f $ **FLOATING
C4100 a_8541_12134.n2 VSS 0.49491f $ **FLOATING
C4101 a_8950_12073.t0 VSS 0.15437f $ **FLOATING
C4102 a_8950_12073.t3 VSS 0.59901f $ **FLOATING
C4103 a_8950_12073.n0 VSS 0.31722f $ **FLOATING
C4104 a_8950_12073.t1 VSS 0.22591f $ **FLOATING
C4105 a_8950_12073.n1 VSS 0.17967f $ **FLOATING
C4106 a_8950_12073.t2 VSS 0.24984f $ **FLOATING
C4107 a_9052_12160.t0 VSS 0.19991f $ **FLOATING
C4108 a_9052_12160.t3 VSS 0.28161f $ **FLOATING
C4109 a_9052_12160.n0 VSS 0.6322f $ **FLOATING
C4110 a_9052_12160.t1 VSS 0.30382f $ **FLOATING
C4111 a_9052_12160.t2 VSS 0.27167f $ **FLOATING
C4112 a_9052_12160.n1 VSS 0.34018f $ **FLOATING
C4113 a_7698_11817.t1 VSS 0.09002f $ **FLOATING
C4114 a_7698_11817.t0 VSS 0.0924f $ **FLOATING
C4115 a_7698_11817.t2 VSS 0.08405f $ **FLOATING
C4116 a_7698_11817.n0 VSS 0.26084f $ **FLOATING
C4117 a_9800_11893.t1 VSS 0.15436f $ **FLOATING
C4118 a_9800_11893.t2 VSS 0.77903f $ **FLOATING
C4119 a_9800_11893.n0 VSS 0.43794f $ **FLOATING
C4120 a_9800_11893.t0 VSS 0.2341f $ **FLOATING
C4121 a_10028_12033.t0 VSS 0.10822f $ **FLOATING
C4122 a_10028_12033.t1 VSS 0.10901f $ **FLOATING
C4123 a_10028_12033.n0 VSS 0.47419f $ **FLOATING
C4124 a_10028_12033.t2 VSS 0.2173f $ **FLOATING
C4125 a_10601_12094.t0 VSS 0.08657f $ **FLOATING
C4126 a_10601_12094.t2 VSS 0.28688f $ **FLOATING
C4127 a_10601_12094.t1 VSS 0.13811f $ **FLOATING
C4128 a_10601_12094.n0 VSS 0.32463f $ **FLOATING
C4129 a_13625_12194.t0 VSS 0.08923f $ **FLOATING
C4130 a_13625_12194.t2 VSS 0.2996f $ **FLOATING
C4131 a_13625_12194.t1 VSS 0.13991f $ **FLOATING
C4132 a_13625_12194.n0 VSS 0.37241f $ **FLOATING
C4133 a_8830_11829.t0 VSS 0.38742f $ **FLOATING
C4134 a_8830_11829.t1 VSS 0.44581f $ **FLOATING
C4135 a_9706_11893.t0 VSS 0.37257f $ **FLOATING
C4136 a_9706_11893.t1 VSS 0.37124f $ **FLOATING
C4137 a_11689_11890.t3 VSS 0.07443f $ **FLOATING
C4138 a_11689_11890.t6 VSS 0.07443f $ **FLOATING
C4139 a_11689_11890.n0 VSS 0.12558f $ **FLOATING
C4140 a_11689_11890.t2 VSS 0.07443f $ **FLOATING
C4141 a_11689_11890.t7 VSS 0.07443f $ **FLOATING
C4142 a_11689_11890.n1 VSS 0.16114f $ **FLOATING
C4143 a_11689_11890.t1 VSS 0.07443f $ **FLOATING
C4144 a_11689_11890.t5 VSS 0.07443f $ **FLOATING
C4145 a_11689_11890.n2 VSS 0.16114f $ **FLOATING
C4146 a_11689_11890.t0 VSS 0.07443f $ **FLOATING
C4147 a_11689_11890.t4 VSS 0.07443f $ **FLOATING
C4148 a_11689_11890.n3 VSS 0.12558f $ **FLOATING
C4149 a_13719_12194.t0 VSS 0.0372f $ **FLOATING
C4150 a_13930_11798.t0 VSS 0.13402f $ **FLOATING
C4151 a_13930_11798.t1 VSS 0.20653f $ **FLOATING
C4152 a_13930_11798.n0 VSS 0.57914f $ **FLOATING
C4153 a_13930_11798.t2 VSS 0.28282f $ **FLOATING
C4154 a_14319_12114.t0 VSS 0.16102f $ **FLOATING
C4155 a_14319_12114.t3 VSS 0.18448f $ **FLOATING
C4156 a_14319_12114.t1 VSS 0.25268f $ **FLOATING
C4157 a_14319_12114.t2 VSS 0.25185f $ **FLOATING
C4158 a_14319_12114.n0 VSS 0.39262f $ **FLOATING
C4159 a_14319_12114.n1 VSS 0.36058f $ **FLOATING
C4160 a_15035_12039.t0 VSS 0.14629f $ **FLOATING
C4161 a_15035_12039.t1 VSS 0.14781f $ **FLOATING
C4162 a_15035_12039.t2 VSS 0.13656f $ **FLOATING
C4163 a_15035_12039.t3 VSS 0.3115f $ **FLOATING
C4164 a_15035_12039.n0 VSS 0.43696f $ **FLOATING
C4165 a_15035_12039.n1 VSS 0.34223f $ **FLOATING
C4166 a_14775_11816.t0 VSS 0.182f $ **FLOATING
C4167 a_14775_11816.t1 VSS 0.183f $ **FLOATING
C4168 a_14775_11816.n0 VSS 0.98395f $ **FLOATING
C4169 a_14775_11816.t2 VSS 0.16374f $ **FLOATING
C4170 a_14775_11816.n1 VSS 1.06667f $ **FLOATING
C4171 a_14775_11816.t3 VSS 0.16959f $ **FLOATING
C4172 a_15061_12134.t0 VSS 0.19097f $ **FLOATING
C4173 a_15061_12134.t4 VSS 0.24653f $ **FLOATING
C4174 a_15061_12134.n0 VSS 0.50638f $ **FLOATING
C4175 a_15061_12134.t2 VSS 0.26877f $ **FLOATING
C4176 a_15061_12134.t3 VSS 0.27102f $ **FLOATING
C4177 a_15061_12134.n1 VSS 0.81582f $ **FLOATING
C4178 a_15061_12134.t1 VSS 0.27506f $ **FLOATING
C4179 a_15061_12134.n2 VSS 0.49488f $ **FLOATING
C4180 a_15470_12073.t0 VSS 0.15436f $ **FLOATING
C4181 a_15470_12073.t3 VSS 0.59896f $ **FLOATING
C4182 a_15470_12073.n0 VSS 0.3172f $ **FLOATING
C4183 a_15470_12073.t1 VSS 0.22589f $ **FLOATING
C4184 a_15470_12073.n1 VSS 0.17966f $ **FLOATING
C4185 a_15470_12073.t2 VSS 0.24982f $ **FLOATING
C4186 a_15572_12160.t0 VSS 0.19991f $ **FLOATING
C4187 a_15572_12160.t3 VSS 0.2816f $ **FLOATING
C4188 a_15572_12160.n0 VSS 0.63219f $ **FLOATING
C4189 a_15572_12160.t1 VSS 0.30382f $ **FLOATING
C4190 a_15572_12160.t2 VSS 0.27166f $ **FLOATING
C4191 a_15572_12160.n1 VSS 0.34018f $ **FLOATING
C4192 a_14218_11817.t1 VSS 0.08389f $ **FLOATING
C4193 a_14218_11817.n0 VSS 0.26035f $ **FLOATING
C4194 a_14218_11817.t0 VSS 0.08986f $ **FLOATING
C4195 a_14218_11817.t2 VSS 0.09223f $ **FLOATING
C4196 a_16320_11893.t1 VSS 0.15436f $ **FLOATING
C4197 a_16320_11893.t2 VSS 0.77903f $ **FLOATING
C4198 a_16320_11893.n0 VSS 0.43794f $ **FLOATING
C4199 a_16320_11893.t0 VSS 0.2341f $ **FLOATING
C4200 a_16548_12033.t0 VSS 0.10822f $ **FLOATING
C4201 a_16548_12033.t1 VSS 0.10901f $ **FLOATING
C4202 a_16548_12033.n0 VSS 0.47419f $ **FLOATING
C4203 a_16548_12033.t2 VSS 0.2173f $ **FLOATING
C4204 a_17121_12094.t0 VSS 0.08657f $ **FLOATING
C4205 a_17121_12094.t2 VSS 0.28688f $ **FLOATING
C4206 a_17121_12094.t1 VSS 0.13811f $ **FLOATING
C4207 a_17121_12094.n0 VSS 0.32463f $ **FLOATING
C4208 a_20145_12194.t0 VSS 0.08909f $ **FLOATING
C4209 a_20145_12194.t2 VSS 0.29913f $ **FLOATING
C4210 a_20145_12194.t1 VSS 0.13969f $ **FLOATING
C4211 a_20145_12194.n0 VSS 0.37182f $ **FLOATING
C4212 a_15350_11829.t0 VSS 0.44579f $ **FLOATING
C4213 a_15350_11829.t1 VSS 0.38741f $ **FLOATING
C4214 a_16226_11893.t0 VSS 0.37124f $ **FLOATING
C4215 a_16226_11893.t1 VSS 0.37257f $ **FLOATING
C4216 a_18209_11890.t3 VSS 0.07442f $ **FLOATING
C4217 a_18209_11890.t6 VSS 0.07442f $ **FLOATING
C4218 a_18209_11890.n0 VSS 0.12557f $ **FLOATING
C4219 a_18209_11890.t2 VSS 0.07442f $ **FLOATING
C4220 a_18209_11890.t7 VSS 0.07442f $ **FLOATING
C4221 a_18209_11890.n1 VSS 0.16113f $ **FLOATING
C4222 a_18209_11890.t1 VSS 0.07442f $ **FLOATING
C4223 a_18209_11890.t5 VSS 0.07442f $ **FLOATING
C4224 a_18209_11890.n2 VSS 0.16113f $ **FLOATING
C4225 a_18209_11890.t0 VSS 0.07442f $ **FLOATING
C4226 a_18209_11890.t4 VSS 0.07442f $ **FLOATING
C4227 a_18209_11890.n3 VSS 0.12557f $ **FLOATING
C4228 a_20239_12194.t0 VSS 0.03716f $ **FLOATING
C4229 a_20450_11798.t0 VSS 0.13383f $ **FLOATING
C4230 a_20450_11798.t1 VSS 0.20624f $ **FLOATING
C4231 a_20450_11798.n0 VSS 0.57833f $ **FLOATING
C4232 a_20450_11798.t2 VSS 0.28242f $ **FLOATING
C4233 a_20839_12114.t1 VSS 0.16136f $ **FLOATING
C4234 a_20839_12114.t3 VSS 0.18487f $ **FLOATING
C4235 a_20839_12114.t2 VSS 0.25321f $ **FLOATING
C4236 a_20839_12114.t0 VSS 0.25238f $ **FLOATING
C4237 a_20839_12114.n0 VSS 0.39345f $ **FLOATING
C4238 a_20839_12114.n1 VSS 0.36134f $ **FLOATING
C4239 a_21555_12039.t0 VSS 0.14783f $ **FLOATING
C4240 a_21555_12039.t2 VSS 0.13657f $ **FLOATING
C4241 a_21555_12039.t3 VSS 0.31153f $ **FLOATING
C4242 a_21555_12039.n0 VSS 0.43699f $ **FLOATING
C4243 a_21555_12039.n1 VSS 0.34226f $ **FLOATING
C4244 a_21555_12039.t1 VSS 0.1463f $ **FLOATING
C4245 a_21295_11816.t0 VSS 0.18202f $ **FLOATING
C4246 a_21295_11816.t1 VSS 0.18302f $ **FLOATING
C4247 a_21295_11816.n0 VSS 0.98405f $ **FLOATING
C4248 a_21295_11816.t2 VSS 0.16376f $ **FLOATING
C4249 a_21295_11816.n1 VSS 1.06679f $ **FLOATING
C4250 a_21295_11816.t3 VSS 0.1696f $ **FLOATING
C4251 a_21581_12134.t0 VSS 0.19099f $ **FLOATING
C4252 a_21581_12134.t4 VSS 0.24655f $ **FLOATING
C4253 a_21581_12134.n0 VSS 0.50643f $ **FLOATING
C4254 a_21581_12134.t2 VSS 0.2688f $ **FLOATING
C4255 a_21581_12134.t3 VSS 0.27104f $ **FLOATING
C4256 a_21581_12134.n1 VSS 0.81589f $ **FLOATING
C4257 a_21581_12134.t1 VSS 0.27508f $ **FLOATING
C4258 a_21581_12134.n2 VSS 0.49493f $ **FLOATING
C4259 a_21990_12073.t0 VSS 0.15437f $ **FLOATING
C4260 a_21990_12073.t3 VSS 0.59902f $ **FLOATING
C4261 a_21990_12073.n0 VSS 0.31723f $ **FLOATING
C4262 a_21990_12073.t1 VSS 0.22591f $ **FLOATING
C4263 a_21990_12073.n1 VSS 0.17967f $ **FLOATING
C4264 a_21990_12073.t2 VSS 0.24985f $ **FLOATING
C4265 a_22092_12160.t0 VSS 0.19991f $ **FLOATING
C4266 a_22092_12160.t3 VSS 0.28161f $ **FLOATING
C4267 a_22092_12160.n0 VSS 0.63221f $ **FLOATING
C4268 a_22092_12160.t1 VSS 0.30383f $ **FLOATING
C4269 a_22092_12160.t2 VSS 0.27167f $ **FLOATING
C4270 a_22092_12160.n1 VSS 0.34019f $ **FLOATING
C4271 a_20738_11817.t1 VSS 0.0901f $ **FLOATING
C4272 a_20738_11817.t0 VSS 0.09248f $ **FLOATING
C4273 a_20738_11817.t2 VSS 0.08412f $ **FLOATING
C4274 a_20738_11817.n0 VSS 0.26106f $ **FLOATING
C4275 a_22840_11893.t1 VSS 0.15436f $ **FLOATING
C4276 a_22840_11893.t2 VSS 0.77903f $ **FLOATING
C4277 a_22840_11893.n0 VSS 0.43794f $ **FLOATING
C4278 a_22840_11893.t0 VSS 0.2341f $ **FLOATING
C4279 a_23068_12033.t0 VSS 0.10822f $ **FLOATING
C4280 a_23068_12033.t1 VSS 0.10901f $ **FLOATING
C4281 a_23068_12033.n0 VSS 0.47419f $ **FLOATING
C4282 a_23068_12033.t2 VSS 0.2173f $ **FLOATING
C4283 a_23641_12094.t0 VSS 0.08657f $ **FLOATING
C4284 a_23641_12094.t2 VSS 0.28688f $ **FLOATING
C4285 a_23641_12094.t1 VSS 0.13811f $ **FLOATING
C4286 a_23641_12094.n0 VSS 0.32463f $ **FLOATING
C4287 a_26665_12194.t0 VSS 0.08913f $ **FLOATING
C4288 a_26665_12194.t2 VSS 0.29926f $ **FLOATING
C4289 a_26665_12194.t1 VSS 0.13975f $ **FLOATING
C4290 a_26665_12194.n0 VSS 0.37199f $ **FLOATING
C4291 a_21870_11829.t0 VSS 0.44581f $ **FLOATING
C4292 a_21870_11829.t1 VSS 0.38743f $ **FLOATING
C4293 a_22746_11893.t0 VSS 0.37124f $ **FLOATING
C4294 a_22746_11893.t1 VSS 0.37257f $ **FLOATING
C4295 a_24729_11890.t3 VSS 0.07443f $ **FLOATING
C4296 a_24729_11890.t4 VSS 0.07442f $ **FLOATING
C4297 a_24729_11890.n0 VSS 0.12557f $ **FLOATING
C4298 a_24729_11890.t2 VSS 0.07443f $ **FLOATING
C4299 a_24729_11890.t7 VSS 0.07442f $ **FLOATING
C4300 a_24729_11890.n1 VSS 0.16114f $ **FLOATING
C4301 a_24729_11890.t1 VSS 0.07443f $ **FLOATING
C4302 a_24729_11890.t6 VSS 0.07442f $ **FLOATING
C4303 a_24729_11890.n2 VSS 0.16114f $ **FLOATING
C4304 a_24729_11890.t0 VSS 0.07443f $ **FLOATING
C4305 a_24729_11890.t5 VSS 0.07443f $ **FLOATING
C4306 a_24729_11890.n3 VSS 0.12557f $ **FLOATING
C4307 a_26759_12194.t0 VSS 0.03718f $ **FLOATING
C4308 a_26970_11798.t0 VSS 0.13394f $ **FLOATING
C4309 a_26970_11798.t1 VSS 0.20641f $ **FLOATING
C4310 a_26970_11798.n0 VSS 0.57881f $ **FLOATING
C4311 a_26970_11798.t2 VSS 0.28266f $ **FLOATING
C4312 a_27359_12114.t1 VSS 0.16114f $ **FLOATING
C4313 a_27359_12114.t3 VSS 0.18461f $ **FLOATING
C4314 a_27359_12114.t2 VSS 0.25286f $ **FLOATING
C4315 a_27359_12114.t0 VSS 0.25202f $ **FLOATING
C4316 a_27359_12114.n0 VSS 0.3929f $ **FLOATING
C4317 a_27359_12114.n1 VSS 0.36084f $ **FLOATING
C4318 a_28075_12039.t0 VSS 0.14782f $ **FLOATING
C4319 a_28075_12039.t2 VSS 0.13656f $ **FLOATING
C4320 a_28075_12039.t3 VSS 0.31151f $ **FLOATING
C4321 a_28075_12039.n0 VSS 0.43697f $ **FLOATING
C4322 a_28075_12039.n1 VSS 0.34224f $ **FLOATING
C4323 a_28075_12039.t1 VSS 0.14629f $ **FLOATING
C4324 a_27815_11816.t0 VSS 0.18201f $ **FLOATING
C4325 a_27815_11816.t1 VSS 0.18301f $ **FLOATING
C4326 a_27815_11816.n0 VSS 0.98398f $ **FLOATING
C4327 a_27815_11816.t2 VSS 0.16375f $ **FLOATING
C4328 a_27815_11816.n1 VSS 1.06671f $ **FLOATING
C4329 a_27815_11816.t3 VSS 0.16959f $ **FLOATING
C4330 a_28101_12134.t0 VSS 0.19098f $ **FLOATING
C4331 a_28101_12134.t4 VSS 0.24654f $ **FLOATING
C4332 a_28101_12134.n0 VSS 0.5064f $ **FLOATING
C4333 a_28101_12134.t2 VSS 0.26878f $ **FLOATING
C4334 a_28101_12134.t3 VSS 0.27103f $ **FLOATING
C4335 a_28101_12134.n1 VSS 0.81584f $ **FLOATING
C4336 a_28101_12134.t1 VSS 0.27507f $ **FLOATING
C4337 a_28101_12134.n2 VSS 0.4949f $ **FLOATING
C4338 a_28510_12073.t0 VSS 0.15436f $ **FLOATING
C4339 a_28510_12073.t3 VSS 0.59898f $ **FLOATING
C4340 a_28510_12073.n0 VSS 0.31721f $ **FLOATING
C4341 a_28510_12073.t1 VSS 0.2259f $ **FLOATING
C4342 a_28510_12073.n1 VSS 0.17966f $ **FLOATING
C4343 a_28510_12073.t2 VSS 0.24983f $ **FLOATING
C4344 a_28612_12160.t0 VSS 0.19991f $ **FLOATING
C4345 a_28612_12160.t3 VSS 0.2816f $ **FLOATING
C4346 a_28612_12160.n0 VSS 0.63219f $ **FLOATING
C4347 a_28612_12160.t1 VSS 0.30382f $ **FLOATING
C4348 a_28612_12160.t2 VSS 0.27167f $ **FLOATING
C4349 a_28612_12160.n1 VSS 0.34018f $ **FLOATING
C4350 a_27258_11817.t1 VSS 0.08994f $ **FLOATING
C4351 a_27258_11817.t0 VSS 0.09232f $ **FLOATING
C4352 a_27258_11817.t2 VSS 0.08397f $ **FLOATING
C4353 a_27258_11817.n0 VSS 0.2606f $ **FLOATING
C4354 a_29360_11893.t1 VSS 0.15436f $ **FLOATING
C4355 a_29360_11893.t2 VSS 0.77903f $ **FLOATING
C4356 a_29360_11893.n0 VSS 0.43794f $ **FLOATING
C4357 a_29360_11893.t0 VSS 0.2341f $ **FLOATING
C4358 a_29588_12033.t0 VSS 0.10822f $ **FLOATING
C4359 a_29588_12033.t1 VSS 0.10901f $ **FLOATING
C4360 a_29588_12033.n0 VSS 0.47419f $ **FLOATING
C4361 a_29588_12033.t2 VSS 0.2173f $ **FLOATING
C4362 a_30161_12094.t0 VSS 0.08657f $ **FLOATING
C4363 a_30161_12094.t2 VSS 0.28688f $ **FLOATING
C4364 a_30161_12094.t1 VSS 0.13811f $ **FLOATING
C4365 a_30161_12094.n0 VSS 0.32463f $ **FLOATING
C4366 a_33185_12194.t0 VSS 0.08902f $ **FLOATING
C4367 a_33185_12194.t2 VSS 0.2989f $ **FLOATING
C4368 a_33185_12194.t1 VSS 0.13958f $ **FLOATING
C4369 a_33185_12194.n0 VSS 0.37154f $ **FLOATING
C4370 a_28390_11829.t0 VSS 0.4458f $ **FLOATING
C4371 a_28390_11829.t1 VSS 0.38742f $ **FLOATING
C4372 a_29266_11893.t0 VSS 0.37124f $ **FLOATING
C4373 a_29266_11893.t1 VSS 0.37257f $ **FLOATING
C4374 a_31249_11890.t3 VSS 0.07442f $ **FLOATING
C4375 a_31249_11890.t6 VSS 0.07442f $ **FLOATING
C4376 a_31249_11890.n0 VSS 0.12556f $ **FLOATING
C4377 a_31249_11890.t2 VSS 0.07442f $ **FLOATING
C4378 a_31249_11890.t7 VSS 0.07442f $ **FLOATING
C4379 a_31249_11890.n1 VSS 0.16112f $ **FLOATING
C4380 a_31249_11890.t1 VSS 0.07442f $ **FLOATING
C4381 a_31249_11890.t5 VSS 0.07442f $ **FLOATING
C4382 a_31249_11890.n2 VSS 0.16112f $ **FLOATING
C4383 a_31249_11890.t0 VSS 0.07442f $ **FLOATING
C4384 a_31249_11890.t4 VSS 0.07442f $ **FLOATING
C4385 a_31249_11890.n3 VSS 0.12556f $ **FLOATING
C4386 a_33279_12194.t0 VSS 0.03712f $ **FLOATING
C4387 a_33490_11798.t0 VSS 0.13421f $ **FLOATING
C4388 a_33490_11798.t1 VSS 0.20682f $ **FLOATING
C4389 a_33490_11798.n0 VSS 0.57996f $ **FLOATING
C4390 a_33490_11798.t2 VSS 0.28322f $ **FLOATING
C4391 a_33879_12114.t1 VSS 0.16196f $ **FLOATING
C4392 a_33879_12114.t3 VSS 0.18554f $ **FLOATING
C4393 a_33879_12114.t2 VSS 0.25414f $ **FLOATING
C4394 a_33879_12114.t0 VSS 0.2533f $ **FLOATING
C4395 a_33879_12114.n0 VSS 0.39489f $ **FLOATING
C4396 a_33879_12114.n1 VSS 0.36267f $ **FLOATING
C4397 a_34595_12039.t0 VSS 0.14632f $ **FLOATING
C4398 a_34595_12039.t1 VSS 0.14784f $ **FLOATING
C4399 a_34595_12039.t2 VSS 0.13658f $ **FLOATING
C4400 a_34595_12039.t3 VSS 0.31156f $ **FLOATING
C4401 a_34595_12039.n0 VSS 0.43705f $ **FLOATING
C4402 a_34595_12039.n1 VSS 0.3423f $ **FLOATING
C4403 a_34335_11816.t0 VSS 0.18205f $ **FLOATING
C4404 a_34335_11816.t1 VSS 0.18305f $ **FLOATING
C4405 a_34335_11816.n0 VSS 0.98421f $ **FLOATING
C4406 a_34335_11816.t3 VSS 0.16378f $ **FLOATING
C4407 a_34335_11816.n1 VSS 1.06696f $ **FLOATING
C4408 a_34335_11816.t2 VSS 0.16963f $ **FLOATING
C4409 a_34621_12134.t0 VSS 0.19101f $ **FLOATING
C4410 a_34621_12134.t4 VSS 0.24658f $ **FLOATING
C4411 a_34621_12134.n0 VSS 0.50649f $ **FLOATING
C4412 a_34621_12134.t3 VSS 0.26883f $ **FLOATING
C4413 a_34621_12134.t2 VSS 0.27108f $ **FLOATING
C4414 a_34621_12134.n1 VSS 0.81599f $ **FLOATING
C4415 a_34621_12134.t1 VSS 0.27512f $ **FLOATING
C4416 a_34621_12134.n2 VSS 0.49499f $ **FLOATING
C4417 a_35030_12073.t0 VSS 0.15438f $ **FLOATING
C4418 a_35030_12073.t3 VSS 0.59906f $ **FLOATING
C4419 a_35030_12073.n0 VSS 0.31725f $ **FLOATING
C4420 a_35030_12073.t1 VSS 0.22593f $ **FLOATING
C4421 a_35030_12073.n1 VSS 0.17969f $ **FLOATING
C4422 a_35030_12073.t2 VSS 0.24986f $ **FLOATING
C4423 a_35132_12160.t0 VSS 0.19992f $ **FLOATING
C4424 a_35132_12160.t3 VSS 0.28162f $ **FLOATING
C4425 a_35132_12160.n0 VSS 0.63224f $ **FLOATING
C4426 a_35132_12160.t1 VSS 0.30384f $ **FLOATING
C4427 a_35132_12160.t2 VSS 0.27168f $ **FLOATING
C4428 a_35132_12160.n1 VSS 0.3402f $ **FLOATING
C4429 a_33778_11817.t1 VSS 0.09057f $ **FLOATING
C4430 a_33778_11817.t0 VSS 0.09296f $ **FLOATING
C4431 a_33778_11817.t2 VSS 0.08456f $ **FLOATING
C4432 a_33778_11817.n0 VSS 0.26242f $ **FLOATING
C4433 a_35880_11893.t1 VSS 0.15436f $ **FLOATING
C4434 a_35880_11893.t2 VSS 0.77903f $ **FLOATING
C4435 a_35880_11893.n0 VSS 0.43794f $ **FLOATING
C4436 a_35880_11893.t0 VSS 0.2341f $ **FLOATING
C4437 a_36108_12033.t0 VSS 0.10822f $ **FLOATING
C4438 a_36108_12033.t1 VSS 0.10901f $ **FLOATING
C4439 a_36108_12033.n0 VSS 0.47419f $ **FLOATING
C4440 a_36108_12033.t2 VSS 0.2173f $ **FLOATING
C4441 a_36681_12094.t0 VSS 0.08657f $ **FLOATING
C4442 a_36681_12094.t2 VSS 0.28688f $ **FLOATING
C4443 a_36681_12094.t1 VSS 0.13811f $ **FLOATING
C4444 a_36681_12094.n0 VSS 0.32463f $ **FLOATING
C4445 a_39705_12194.t0 VSS 0.08905f $ **FLOATING
C4446 a_39705_12194.t2 VSS 0.29902f $ **FLOATING
C4447 a_39705_12194.t1 VSS 0.13963f $ **FLOATING
C4448 a_39705_12194.n0 VSS 0.37168f $ **FLOATING
C4449 a_34910_11829.t0 VSS 0.44584f $ **FLOATING
C4450 a_34910_11829.t1 VSS 0.38745f $ **FLOATING
C4451 a_35786_11893.t0 VSS 0.37124f $ **FLOATING
C4452 a_35786_11893.t1 VSS 0.37257f $ **FLOATING
C4453 a_37769_11890.t3 VSS 0.07442f $ **FLOATING
C4454 a_37769_11890.t4 VSS 0.07442f $ **FLOATING
C4455 a_37769_11890.n0 VSS 0.12557f $ **FLOATING
C4456 a_37769_11890.t2 VSS 0.07442f $ **FLOATING
C4457 a_37769_11890.t7 VSS 0.07442f $ **FLOATING
C4458 a_37769_11890.n1 VSS 0.16113f $ **FLOATING
C4459 a_37769_11890.t1 VSS 0.07442f $ **FLOATING
C4460 a_37769_11890.t6 VSS 0.07442f $ **FLOATING
C4461 a_37769_11890.n2 VSS 0.16113f $ **FLOATING
C4462 a_37769_11890.t0 VSS 0.07442f $ **FLOATING
C4463 a_37769_11890.t5 VSS 0.07442f $ **FLOATING
C4464 a_37769_11890.n3 VSS 0.12557f $ **FLOATING
C4465 a_39799_12194.t0 VSS 0.03714f $ **FLOATING
C4466 a_40010_11798.t0 VSS 0.13408f $ **FLOATING
C4467 a_40010_11798.t1 VSS 0.20662f $ **FLOATING
C4468 a_40010_11798.n0 VSS 0.5794f $ **FLOATING
C4469 a_40010_11798.t2 VSS 0.28295f $ **FLOATING
C4470 a_40399_12114.t2 VSS 0.16162f $ **FLOATING
C4471 a_40399_12114.t3 VSS 0.18516f $ **FLOATING
C4472 a_40399_12114.t1 VSS 0.25362f $ **FLOATING
C4473 a_40399_12114.t0 VSS 0.25278f $ **FLOATING
C4474 a_40399_12114.n0 VSS 0.39408f $ **FLOATING
C4475 a_40399_12114.n1 VSS 0.36193f $ **FLOATING
C4476 a_41115_12039.t0 VSS 0.14631f $ **FLOATING
C4477 a_41115_12039.t1 VSS 0.14783f $ **FLOATING
C4478 a_41115_12039.t2 VSS 0.13658f $ **FLOATING
C4479 a_41115_12039.t3 VSS 0.31154f $ **FLOATING
C4480 a_41115_12039.n0 VSS 0.43702f $ **FLOATING
C4481 a_41115_12039.n1 VSS 0.34228f $ **FLOATING
C4482 a_40855_11816.t0 VSS 0.18204f $ **FLOATING
C4483 a_40855_11816.t1 VSS 0.18304f $ **FLOATING
C4484 a_40855_11816.n0 VSS 0.98413f $ **FLOATING
C4485 a_40855_11816.t3 VSS 0.16377f $ **FLOATING
C4486 a_40855_11816.n1 VSS 1.06687f $ **FLOATING
C4487 a_40855_11816.t2 VSS 0.16962f $ **FLOATING
C4488 a_41141_12134.t0 VSS 0.191f $ **FLOATING
C4489 a_41141_12134.t4 VSS 0.24657f $ **FLOATING
C4490 a_41141_12134.n0 VSS 0.50646f $ **FLOATING
C4491 a_41141_12134.t3 VSS 0.26881f $ **FLOATING
C4492 a_41141_12134.t2 VSS 0.27106f $ **FLOATING
C4493 a_41141_12134.n1 VSS 0.81594f $ **FLOATING
C4494 a_41141_12134.t1 VSS 0.2751f $ **FLOATING
C4495 a_41141_12134.n2 VSS 0.49496f $ **FLOATING
C4496 a_41550_12073.t0 VSS 0.15438f $ **FLOATING
C4497 a_41550_12073.t3 VSS 0.59904f $ **FLOATING
C4498 a_41550_12073.n0 VSS 0.31724f $ **FLOATING
C4499 a_41550_12073.t1 VSS 0.22592f $ **FLOATING
C4500 a_41550_12073.n1 VSS 0.17968f $ **FLOATING
C4501 a_41550_12073.t2 VSS 0.24985f $ **FLOATING
C4502 a_41652_12160.t0 VSS 0.19992f $ **FLOATING
C4503 a_41652_12160.t3 VSS 0.28161f $ **FLOATING
C4504 a_41652_12160.n0 VSS 0.63222f $ **FLOATING
C4505 a_41652_12160.t1 VSS 0.30383f $ **FLOATING
C4506 a_41652_12160.t2 VSS 0.27168f $ **FLOATING
C4507 a_41652_12160.n1 VSS 0.3402f $ **FLOATING
C4508 a_40298_11817.t1 VSS 0.09029f $ **FLOATING
C4509 a_40298_11817.t0 VSS 0.09268f $ **FLOATING
C4510 a_40298_11817.t2 VSS 0.0843f $ **FLOATING
C4511 a_40298_11817.n0 VSS 0.26161f $ **FLOATING
C4512 a_42400_11893.t1 VSS 0.15436f $ **FLOATING
C4513 a_42400_11893.t2 VSS 0.77903f $ **FLOATING
C4514 a_42400_11893.n0 VSS 0.43794f $ **FLOATING
C4515 a_42400_11893.t0 VSS 0.2341f $ **FLOATING
C4516 a_42628_12033.t0 VSS 0.10822f $ **FLOATING
C4517 a_42628_12033.t1 VSS 0.10901f $ **FLOATING
C4518 a_42628_12033.n0 VSS 0.47419f $ **FLOATING
C4519 a_42628_12033.t2 VSS 0.2173f $ **FLOATING
C4520 a_43201_12094.t0 VSS 0.08657f $ **FLOATING
C4521 a_43201_12094.t2 VSS 0.28688f $ **FLOATING
C4522 a_43201_12094.t1 VSS 0.13811f $ **FLOATING
C4523 a_43201_12094.n0 VSS 0.32463f $ **FLOATING
C4524 a_46225_12194.t0 VSS 0.06994f $ **FLOATING
C4525 a_46225_12194.t2 VSS 0.23484f $ **FLOATING
C4526 a_46225_12194.t1 VSS 0.10966f $ **FLOATING
C4527 a_46225_12194.n0 VSS 0.29191f $ **FLOATING
C4528 a_41430_11829.t0 VSS 0.44583f $ **FLOATING
C4529 a_41430_11829.t1 VSS 0.38744f $ **FLOATING
C4530 a_42306_11893.t0 VSS 0.37124f $ **FLOATING
C4531 a_42306_11893.t1 VSS 0.37257f $ **FLOATING
C4532 a_44289_11890.t3 VSS 0.07416f $ **FLOATING
C4533 a_44289_11890.t6 VSS 0.07416f $ **FLOATING
C4534 a_44289_11890.n0 VSS 0.12512f $ **FLOATING
C4535 a_44289_11890.t2 VSS 0.07416f $ **FLOATING
C4536 a_44289_11890.t5 VSS 0.07416f $ **FLOATING
C4537 a_44289_11890.n1 VSS 0.16056f $ **FLOATING
C4538 a_44289_11890.t1 VSS 0.07416f $ **FLOATING
C4539 a_44289_11890.t4 VSS 0.07416f $ **FLOATING
C4540 a_44289_11890.n2 VSS 0.16056f $ **FLOATING
C4541 a_44289_11890.t0 VSS 0.07416f $ **FLOATING
C4542 a_44289_11890.t7 VSS 0.07416f $ **FLOATING
C4543 a_44289_11890.n3 VSS 0.12512f $ **FLOATING
C4544 a_46530_11798.t0 VSS 0.13277f $ **FLOATING
C4545 a_46530_11798.t1 VSS 0.20461f $ **FLOATING
C4546 a_46530_11798.n0 VSS 0.57378f $ **FLOATING
C4547 a_46530_11798.t2 VSS 0.2802f $ **FLOATING
C4548 a_46919_12114.t1 VSS 0.16161f $ **FLOATING
C4549 a_46919_12114.t3 VSS 0.18515f $ **FLOATING
C4550 a_46919_12114.t2 VSS 0.2536f $ **FLOATING
C4551 a_46919_12114.t0 VSS 0.25276f $ **FLOATING
C4552 a_46919_12114.n0 VSS 0.39405f $ **FLOATING
C4553 a_46919_12114.n1 VSS 0.36189f $ **FLOATING
C4554 a_47635_12039.t0 VSS 0.14631f $ **FLOATING
C4555 a_47635_12039.t1 VSS 0.14783f $ **FLOATING
C4556 a_47635_12039.t2 VSS 0.13658f $ **FLOATING
C4557 a_47635_12039.t3 VSS 0.31154f $ **FLOATING
C4558 a_47635_12039.n0 VSS 0.43702f $ **FLOATING
C4559 a_47635_12039.n1 VSS 0.34228f $ **FLOATING
C4560 a_47375_11816.t0 VSS 0.18204f $ **FLOATING
C4561 a_47375_11816.t1 VSS 0.18304f $ **FLOATING
C4562 a_47375_11816.n0 VSS 0.98413f $ **FLOATING
C4563 a_47375_11816.t2 VSS 0.16377f $ **FLOATING
C4564 a_47375_11816.n1 VSS 1.06687f $ **FLOATING
C4565 a_47375_11816.t3 VSS 0.16962f $ **FLOATING
C4566 a_47661_12134.t0 VSS 0.191f $ **FLOATING
C4567 a_47661_12134.t4 VSS 0.24657f $ **FLOATING
C4568 a_47661_12134.n0 VSS 0.50646f $ **FLOATING
C4569 a_47661_12134.t2 VSS 0.26881f $ **FLOATING
C4570 a_47661_12134.t3 VSS 0.27106f $ **FLOATING
C4571 a_47661_12134.n1 VSS 0.81594f $ **FLOATING
C4572 a_47661_12134.t1 VSS 0.2751f $ **FLOATING
C4573 a_47661_12134.n2 VSS 0.49496f $ **FLOATING
C4574 a_48070_12073.t0 VSS 0.15438f $ **FLOATING
C4575 a_48070_12073.t3 VSS 0.59904f $ **FLOATING
C4576 a_48070_12073.n0 VSS 0.31724f $ **FLOATING
C4577 a_48070_12073.t1 VSS 0.22592f $ **FLOATING
C4578 a_48070_12073.n1 VSS 0.17968f $ **FLOATING
C4579 a_48070_12073.t2 VSS 0.24985f $ **FLOATING
C4580 a_48172_12160.t0 VSS 0.19992f $ **FLOATING
C4581 a_48172_12160.t3 VSS 0.28161f $ **FLOATING
C4582 a_48172_12160.n0 VSS 0.63222f $ **FLOATING
C4583 a_48172_12160.t1 VSS 0.30383f $ **FLOATING
C4584 a_48172_12160.t2 VSS 0.27168f $ **FLOATING
C4585 a_48172_12160.n1 VSS 0.3402f $ **FLOATING
C4586 a_46818_11817.t1 VSS 0.09011f $ **FLOATING
C4587 a_46818_11817.t0 VSS 0.0925f $ **FLOATING
C4588 a_46818_11817.t2 VSS 0.08414f $ **FLOATING
C4589 a_46818_11817.n0 VSS 0.26111f $ **FLOATING
C4590 a_48920_11893.t1 VSS 0.15436f $ **FLOATING
C4591 a_48920_11893.t2 VSS 0.77903f $ **FLOATING
C4592 a_48920_11893.n0 VSS 0.43794f $ **FLOATING
C4593 a_48920_11893.t0 VSS 0.2341f $ **FLOATING
C4594 a_49148_12033.t0 VSS 0.10822f $ **FLOATING
C4595 a_49148_12033.t1 VSS 0.10901f $ **FLOATING
C4596 a_49148_12033.n0 VSS 0.47419f $ **FLOATING
C4597 a_49148_12033.t2 VSS 0.2173f $ **FLOATING
C4598 a_49721_12094.t0 VSS 0.08657f $ **FLOATING
C4599 a_49721_12094.t2 VSS 0.28688f $ **FLOATING
C4600 a_49721_12094.t1 VSS 0.13811f $ **FLOATING
C4601 a_49721_12094.n0 VSS 0.32463f $ **FLOATING
C4602 a_47950_11829.t0 VSS 0.44583f $ **FLOATING
C4603 a_47950_11829.t1 VSS 0.38744f $ **FLOATING
C4604 a_48826_11893.t0 VSS 0.37124f $ **FLOATING
C4605 a_48826_11893.t1 VSS 0.37257f $ **FLOATING
C4606 a_50809_11890.t3 VSS 0.07411f $ **FLOATING
C4607 a_50809_11890.t4 VSS 0.07411f $ **FLOATING
C4608 a_50809_11890.n0 VSS 0.12504f $ **FLOATING
C4609 a_50809_11890.t2 VSS 0.07411f $ **FLOATING
C4610 a_50809_11890.t5 VSS 0.07411f $ **FLOATING
C4611 a_50809_11890.n1 VSS 0.16045f $ **FLOATING
C4612 a_50809_11890.t1 VSS 0.07411f $ **FLOATING
C4613 a_50809_11890.t7 VSS 0.07411f $ **FLOATING
C4614 a_50809_11890.n2 VSS 0.16045f $ **FLOATING
C4615 a_50809_11890.t0 VSS 0.07411f $ **FLOATING
C4616 a_50809_11890.t6 VSS 0.07411f $ **FLOATING
C4617 a_50809_11890.n3 VSS 0.12503f $ **FLOATING
C4618 a_3877_9294.t0 VSS 0.06998f $ **FLOATING
C4619 a_3877_9294.n0 VSS 0.73682f $ **FLOATING
C4620 a_3877_9294.t2 VSS 0.50729f $ **FLOATING
C4621 a_3877_9294.t1 VSS 0.11429f $ **FLOATING
C4622 a_10397_9294.t0 VSS 0.06998f $ **FLOATING
C4623 a_10397_9294.n0 VSS 0.73683f $ **FLOATING
C4624 a_10397_9294.t2 VSS 0.5073f $ **FLOATING
C4625 a_10397_9294.t1 VSS 0.1143f $ **FLOATING
C4626 a_4298_9314.t0 VSS 0.06223f $ **FLOATING
C4627 a_4298_9314.t1 VSS 0.1014f $ **FLOATING
C4628 a_4298_9314.n0 VSS 0.63914f $ **FLOATING
C4629 a_4298_9314.t2 VSS 0.27154f $ **FLOATING
C4630 a_16917_9294.t0 VSS 0.06988f $ **FLOATING
C4631 a_16917_9294.n0 VSS 0.73576f $ **FLOATING
C4632 a_16917_9294.t2 VSS 0.50657f $ **FLOATING
C4633 a_16917_9294.t1 VSS 0.11413f $ **FLOATING
C4634 a_10818_9314.t0 VSS 0.06223f $ **FLOATING
C4635 a_10818_9314.t1 VSS 0.1014f $ **FLOATING
C4636 a_10818_9314.n0 VSS 0.63914f $ **FLOATING
C4637 a_10818_9314.t2 VSS 0.27154f $ **FLOATING
C4638 a_23437_9294.t0 VSS 0.06988f $ **FLOATING
C4639 a_23437_9294.n0 VSS 0.73578f $ **FLOATING
C4640 a_23437_9294.t2 VSS 0.50658f $ **FLOATING
C4641 a_23437_9294.t1 VSS 0.11413f $ **FLOATING
C4642 a_17338_9314.t0 VSS 0.0622f $ **FLOATING
C4643 a_17338_9314.t1 VSS 0.10135f $ **FLOATING
C4644 a_17338_9314.n0 VSS 0.63887f $ **FLOATING
C4645 a_17338_9314.t2 VSS 0.27142f $ **FLOATING
C4646 a_29957_9294.t0 VSS 0.06987f $ **FLOATING
C4647 a_29957_9294.n0 VSS 0.73569f $ **FLOATING
C4648 a_29957_9294.t2 VSS 0.50651f $ **FLOATING
C4649 a_29957_9294.t1 VSS 0.11412f $ **FLOATING
C4650 a_23858_9314.t0 VSS 0.0622f $ **FLOATING
C4651 a_23858_9314.t1 VSS 0.10135f $ **FLOATING
C4652 a_23858_9314.n0 VSS 0.63887f $ **FLOATING
C4653 a_23858_9314.t2 VSS 0.27142f $ **FLOATING
C4654 a_36477_9294.t0 VSS 0.06987f $ **FLOATING
C4655 a_36477_9294.n0 VSS 0.73571f $ **FLOATING
C4656 a_36477_9294.t2 VSS 0.50653f $ **FLOATING
C4657 a_36477_9294.t1 VSS 0.11412f $ **FLOATING
C4658 a_30378_9314.t0 VSS 0.0622f $ **FLOATING
C4659 a_30378_9314.t1 VSS 0.10135f $ **FLOATING
C4660 a_30378_9314.n0 VSS 0.63887f $ **FLOATING
C4661 a_30378_9314.t2 VSS 0.27142f $ **FLOATING
C4662 a_42997_9294.t0 VSS 0.06992f $ **FLOATING
C4663 a_42997_9294.n0 VSS 0.73617f $ **FLOATING
C4664 a_42997_9294.t2 VSS 0.50684f $ **FLOATING
C4665 a_42997_9294.t1 VSS 0.11419f $ **FLOATING
C4666 a_36898_9314.t0 VSS 0.0622f $ **FLOATING
C4667 a_36898_9314.t1 VSS 0.10135f $ **FLOATING
C4668 a_36898_9314.n0 VSS 0.63887f $ **FLOATING
C4669 a_36898_9314.t2 VSS 0.27142f $ **FLOATING
C4670 a_49517_9294.t0 VSS 0.06986f $ **FLOATING
C4671 a_49517_9294.n0 VSS 0.73555f $ **FLOATING
C4672 a_49517_9294.t2 VSS 0.50642f $ **FLOATING
C4673 a_49517_9294.t1 VSS 0.1141f $ **FLOATING
C4674 a_43418_9314.t0 VSS 0.06221f $ **FLOATING
C4675 a_43418_9314.t1 VSS 0.10136f $ **FLOATING
C4676 a_43418_9314.n0 VSS 0.63894f $ **FLOATING
C4677 a_43418_9314.t2 VSS 0.27145f $ **FLOATING
C4678 a_49938_9314.t0 VSS 0.0622f $ **FLOATING
C4679 a_49938_9314.t1 VSS 0.10135f $ **FLOATING
C4680 a_49938_9314.n0 VSS 0.63886f $ **FLOATING
C4681 a_49938_9314.t2 VSS 0.27142f $ **FLOATING
C4682 a_5003_9350.t9 VSS 0.13119f $ **FLOATING
C4683 a_5003_9350.t8 VSS 0.13043f $ **FLOATING
C4684 a_5003_9350.n0 VSS 0.31977f $ **FLOATING
C4685 a_5003_9350.t6 VSS 0.10111f $ **FLOATING
C4686 a_5003_9350.n1 VSS 0.38936f $ **FLOATING
C4687 a_5003_9350.t4 VSS 0.09879f $ **FLOATING
C4688 a_5003_9350.n2 VSS 0.33887f $ **FLOATING
C4689 a_5003_9350.t0 VSS 0.11343f $ **FLOATING
C4690 a_5003_9350.t5 VSS 0.09879f $ **FLOATING
C4691 a_5003_9350.n3 VSS 0.33887f $ **FLOATING
C4692 a_5003_9350.t1 VSS 0.11343f $ **FLOATING
C4693 a_5003_9350.t2 VSS 0.14893f $ **FLOATING
C4694 a_5003_9350.t7 VSS 0.13119f $ **FLOATING
C4695 a_5003_9350.n4 VSS 0.35457f $ **FLOATING
C4696 a_5003_9350.t3 VSS 0.14893f $ **FLOATING
C4697 a_5003_9350.n5 VSS 0.35457f $ **FLOATING
C4698 a_11523_9350.t9 VSS 0.1312f $ **FLOATING
C4699 a_11523_9350.t8 VSS 0.13044f $ **FLOATING
C4700 a_11523_9350.n0 VSS 0.31979f $ **FLOATING
C4701 a_11523_9350.t6 VSS 0.10112f $ **FLOATING
C4702 a_11523_9350.n1 VSS 0.38937f $ **FLOATING
C4703 a_11523_9350.t4 VSS 0.09879f $ **FLOATING
C4704 a_11523_9350.n2 VSS 0.33888f $ **FLOATING
C4705 a_11523_9350.t0 VSS 0.11343f $ **FLOATING
C4706 a_11523_9350.t5 VSS 0.09879f $ **FLOATING
C4707 a_11523_9350.n3 VSS 0.33888f $ **FLOATING
C4708 a_11523_9350.t1 VSS 0.11343f $ **FLOATING
C4709 a_11523_9350.t2 VSS 0.14894f $ **FLOATING
C4710 a_11523_9350.t7 VSS 0.1312f $ **FLOATING
C4711 a_11523_9350.n4 VSS 0.35458f $ **FLOATING
C4712 a_11523_9350.t3 VSS 0.14894f $ **FLOATING
C4713 a_11523_9350.n5 VSS 0.35458f $ **FLOATING
C4714 a_18043_9350.t9 VSS 0.13121f $ **FLOATING
C4715 a_18043_9350.t8 VSS 0.13045f $ **FLOATING
C4716 a_18043_9350.n0 VSS 0.31982f $ **FLOATING
C4717 a_18043_9350.t6 VSS 0.10113f $ **FLOATING
C4718 a_18043_9350.n1 VSS 0.38941f $ **FLOATING
C4719 a_18043_9350.t4 VSS 0.0988f $ **FLOATING
C4720 a_18043_9350.n2 VSS 0.33891f $ **FLOATING
C4721 a_18043_9350.t0 VSS 0.11344f $ **FLOATING
C4722 a_18043_9350.t5 VSS 0.0988f $ **FLOATING
C4723 a_18043_9350.n3 VSS 0.33891f $ **FLOATING
C4724 a_18043_9350.t1 VSS 0.11344f $ **FLOATING
C4725 a_18043_9350.t2 VSS 0.14895f $ **FLOATING
C4726 a_18043_9350.t7 VSS 0.13121f $ **FLOATING
C4727 a_18043_9350.n4 VSS 0.35461f $ **FLOATING
C4728 a_18043_9350.t3 VSS 0.14895f $ **FLOATING
C4729 a_18043_9350.n5 VSS 0.35461f $ **FLOATING
C4730 a_24563_9350.t9 VSS 0.13122f $ **FLOATING
C4731 a_24563_9350.t8 VSS 0.13046f $ **FLOATING
C4732 a_24563_9350.n0 VSS 0.31982f $ **FLOATING
C4733 a_24563_9350.t5 VSS 0.10113f $ **FLOATING
C4734 a_24563_9350.n1 VSS 0.38942f $ **FLOATING
C4735 a_24563_9350.t4 VSS 0.0988f $ **FLOATING
C4736 a_24563_9350.n2 VSS 0.33892f $ **FLOATING
C4737 a_24563_9350.t0 VSS 0.11344f $ **FLOATING
C4738 a_24563_9350.t6 VSS 0.0988f $ **FLOATING
C4739 a_24563_9350.n3 VSS 0.33892f $ **FLOATING
C4740 a_24563_9350.t1 VSS 0.11344f $ **FLOATING
C4741 a_24563_9350.t2 VSS 0.14895f $ **FLOATING
C4742 a_24563_9350.t7 VSS 0.13122f $ **FLOATING
C4743 a_24563_9350.n4 VSS 0.35462f $ **FLOATING
C4744 a_24563_9350.t3 VSS 0.14895f $ **FLOATING
C4745 a_24563_9350.n5 VSS 0.35462f $ **FLOATING
C4746 a_31083_9350.t9 VSS 0.13121f $ **FLOATING
C4747 a_31083_9350.t8 VSS 0.13045f $ **FLOATING
C4748 a_31083_9350.n0 VSS 0.3198f $ **FLOATING
C4749 a_31083_9350.t5 VSS 0.10112f $ **FLOATING
C4750 a_31083_9350.n1 VSS 0.38939f $ **FLOATING
C4751 a_31083_9350.t4 VSS 0.09879f $ **FLOATING
C4752 a_31083_9350.n2 VSS 0.3389f $ **FLOATING
C4753 a_31083_9350.t0 VSS 0.11343f $ **FLOATING
C4754 a_31083_9350.t6 VSS 0.09879f $ **FLOATING
C4755 a_31083_9350.n3 VSS 0.3389f $ **FLOATING
C4756 a_31083_9350.t1 VSS 0.11343f $ **FLOATING
C4757 a_31083_9350.t2 VSS 0.14894f $ **FLOATING
C4758 a_31083_9350.t7 VSS 0.13121f $ **FLOATING
C4759 a_31083_9350.n4 VSS 0.3546f $ **FLOATING
C4760 a_31083_9350.t3 VSS 0.14894f $ **FLOATING
C4761 a_31083_9350.n5 VSS 0.3546f $ **FLOATING
C4762 a_37603_9350.t9 VSS 0.13121f $ **FLOATING
C4763 a_37603_9350.t8 VSS 0.13045f $ **FLOATING
C4764 a_37603_9350.n0 VSS 0.31981f $ **FLOATING
C4765 a_37603_9350.t6 VSS 0.10112f $ **FLOATING
C4766 a_37603_9350.n1 VSS 0.3894f $ **FLOATING
C4767 a_37603_9350.t4 VSS 0.0988f $ **FLOATING
C4768 a_37603_9350.n2 VSS 0.3389f $ **FLOATING
C4769 a_37603_9350.t0 VSS 0.11344f $ **FLOATING
C4770 a_37603_9350.t5 VSS 0.0988f $ **FLOATING
C4771 a_37603_9350.n3 VSS 0.3389f $ **FLOATING
C4772 a_37603_9350.t1 VSS 0.11344f $ **FLOATING
C4773 a_37603_9350.t2 VSS 0.14895f $ **FLOATING
C4774 a_37603_9350.t7 VSS 0.13121f $ **FLOATING
C4775 a_37603_9350.n4 VSS 0.35461f $ **FLOATING
C4776 a_37603_9350.t3 VSS 0.14895f $ **FLOATING
C4777 a_37603_9350.n5 VSS 0.35461f $ **FLOATING
C4778 a_44123_9350.t9 VSS 0.13086f $ **FLOATING
C4779 a_44123_9350.t8 VSS 0.1301f $ **FLOATING
C4780 a_44123_9350.n0 VSS 0.31896f $ **FLOATING
C4781 a_44123_9350.t5 VSS 0.10086f $ **FLOATING
C4782 a_44123_9350.n1 VSS 0.38837f $ **FLOATING
C4783 a_44123_9350.t4 VSS 0.09853f $ **FLOATING
C4784 a_44123_9350.n2 VSS 0.338f $ **FLOATING
C4785 a_44123_9350.t0 VSS 0.11314f $ **FLOATING
C4786 a_44123_9350.t6 VSS 0.09853f $ **FLOATING
C4787 a_44123_9350.n3 VSS 0.338f $ **FLOATING
C4788 a_44123_9350.t1 VSS 0.11314f $ **FLOATING
C4789 a_44123_9350.t2 VSS 0.14855f $ **FLOATING
C4790 a_44123_9350.t7 VSS 0.13086f $ **FLOATING
C4791 a_44123_9350.n4 VSS 0.35366f $ **FLOATING
C4792 a_44123_9350.t3 VSS 0.14855f $ **FLOATING
C4793 a_44123_9350.n5 VSS 0.35366f $ **FLOATING
C4794 a_50643_9350.t9 VSS 0.13081f $ **FLOATING
C4795 a_50643_9350.t8 VSS 0.13005f $ **FLOATING
C4796 a_50643_9350.n0 VSS 0.31883f $ **FLOATING
C4797 a_50643_9350.t6 VSS 0.10081f $ **FLOATING
C4798 a_50643_9350.n1 VSS 0.3882f $ **FLOATING
C4799 a_50643_9350.t1 VSS 0.09849f $ **FLOATING
C4800 a_50643_9350.n2 VSS 0.33786f $ **FLOATING
C4801 a_50643_9350.t0 VSS 0.11309f $ **FLOATING
C4802 a_50643_9350.t2 VSS 0.09849f $ **FLOATING
C4803 a_50643_9350.n3 VSS 0.33786f $ **FLOATING
C4804 a_50643_9350.t3 VSS 0.11309f $ **FLOATING
C4805 a_50643_9350.t4 VSS 0.14849f $ **FLOATING
C4806 a_50643_9350.t7 VSS 0.13081f $ **FLOATING
C4807 a_50643_9350.n4 VSS 0.35352f $ **FLOATING
C4808 a_50643_9350.t5 VSS 0.14849f $ **FLOATING
C4809 a_50643_9350.n5 VSS 0.35352f $ **FLOATING
C4810 a_585_9394.t0 VSS 0.09078f $ **FLOATING
C4811 a_585_9394.t2 VSS 0.30482f $ **FLOATING
C4812 a_585_9394.t1 VSS 0.14234f $ **FLOATING
C4813 a_585_9394.n0 VSS 0.3789f $ **FLOATING
C4814 a_679_9394.t0 VSS 0.03794f $ **FLOATING
C4815 a_890_8998.t0 VSS 0.13441f $ **FLOATING
C4816 a_890_8998.t1 VSS 0.20714f $ **FLOATING
C4817 a_890_8998.n0 VSS 0.58086f $ **FLOATING
C4818 a_890_8998.t2 VSS 0.28366f $ **FLOATING
C4819 a_n2042_972.t0 VSS 0.1235f $ **FLOATING
C4820 a_n2042_972.n0 VSS 2.73524f $ **FLOATING
C4821 a_n2042_972.t10 VSS 0.46866f $ **FLOATING
C4822 a_n2042_972.n1 VSS 12.321f $ **FLOATING
C4823 a_n2042_972.t2 VSS 0.3569f $ **FLOATING
C4824 a_n2042_972.n2 VSS 4.46666f $ **FLOATING
C4825 a_n2042_972.t11 VSS 0.33176f $ **FLOATING
C4826 a_n2042_972.n3 VSS 5.0318f $ **FLOATING
C4827 a_n2042_972.t3 VSS 0.3569f $ **FLOATING
C4828 a_n2042_972.n4 VSS 4.46666f $ **FLOATING
C4829 a_n2042_972.t12 VSS 0.33176f $ **FLOATING
C4830 a_n2042_972.n5 VSS 5.0318f $ **FLOATING
C4831 a_n2042_972.t4 VSS 0.3569f $ **FLOATING
C4832 a_n2042_972.n6 VSS 4.46666f $ **FLOATING
C4833 a_n2042_972.t13 VSS 0.33176f $ **FLOATING
C4834 a_n2042_972.n7 VSS 5.0318f $ **FLOATING
C4835 a_n2042_972.t5 VSS 0.3569f $ **FLOATING
C4836 a_n2042_972.n8 VSS 4.46666f $ **FLOATING
C4837 a_n2042_972.t14 VSS 0.33176f $ **FLOATING
C4838 a_n2042_972.n9 VSS 5.0318f $ **FLOATING
C4839 a_n2042_972.t6 VSS 0.3569f $ **FLOATING
C4840 a_n2042_972.n10 VSS 4.46666f $ **FLOATING
C4841 a_n2042_972.t15 VSS 0.33176f $ **FLOATING
C4842 a_n2042_972.n11 VSS 5.0318f $ **FLOATING
C4843 a_n2042_972.t7 VSS 0.3569f $ **FLOATING
C4844 a_n2042_972.n12 VSS 4.46666f $ **FLOATING
C4845 a_n2042_972.t16 VSS 0.33176f $ **FLOATING
C4846 a_n2042_972.n13 VSS 5.0318f $ **FLOATING
C4847 a_n2042_972.t8 VSS 0.3569f $ **FLOATING
C4848 a_n2042_972.n14 VSS 4.46666f $ **FLOATING
C4849 a_n2042_972.t17 VSS 0.33176f $ **FLOATING
C4850 a_n2042_972.n15 VSS 11.9927f $ **FLOATING
C4851 a_n2042_972.t9 VSS 0.3569f $ **FLOATING
C4852 a_n2042_972.t1 VSS 0.18728f $ **FLOATING
C4853 a_1279_9314.t1 VSS 0.16199f $ **FLOATING
C4854 a_1279_9314.t3 VSS 0.18559f $ **FLOATING
C4855 a_1279_9314.t2 VSS 0.2542f $ **FLOATING
C4856 a_1279_9314.t0 VSS 0.25336f $ **FLOATING
C4857 a_1279_9314.n0 VSS 0.39498f $ **FLOATING
C4858 a_1279_9314.n1 VSS 0.36275f $ **FLOATING
C4859 a_1995_9239.t0 VSS 0.14826f $ **FLOATING
C4860 a_1995_9239.t2 VSS 0.13697f $ **FLOATING
C4861 a_1995_9239.t3 VSS 0.31243f $ **FLOATING
C4862 a_1995_9239.n0 VSS 0.43827f $ **FLOATING
C4863 a_1995_9239.n1 VSS 0.34325f $ **FLOATING
C4864 a_1995_9239.t1 VSS 0.14673f $ **FLOATING
C4865 a_1735_9016.t0 VSS 0.18251f $ **FLOATING
C4866 a_1735_9016.t1 VSS 0.18351f $ **FLOATING
C4867 a_1735_9016.n0 VSS 0.98668f $ **FLOATING
C4868 a_1735_9016.t2 VSS 0.1642f $ **FLOATING
C4869 a_1735_9016.n1 VSS 1.06964f $ **FLOATING
C4870 a_1735_9016.t3 VSS 0.17006f $ **FLOATING
C4871 a_2021_9334.t0 VSS 0.19143f $ **FLOATING
C4872 a_2021_9334.t4 VSS 0.24713f $ **FLOATING
C4873 a_2021_9334.n0 VSS 0.5076f $ **FLOATING
C4874 a_2021_9334.t2 VSS 0.26942f $ **FLOATING
C4875 a_2021_9334.t3 VSS 0.27167f $ **FLOATING
C4876 a_2021_9334.n1 VSS 0.81778f $ **FLOATING
C4877 a_2021_9334.t1 VSS 0.27572f $ **FLOATING
C4878 a_2021_9334.n2 VSS 0.49608f $ **FLOATING
C4879 a_2430_9273.t0 VSS 0.15491f $ **FLOATING
C4880 a_2430_9273.t3 VSS 0.60111f $ **FLOATING
C4881 a_2430_9273.n0 VSS 0.31834f $ **FLOATING
C4882 a_2430_9273.t1 VSS 0.2267f $ **FLOATING
C4883 a_2430_9273.n1 VSS 0.1803f $ **FLOATING
C4884 a_2430_9273.t2 VSS 0.25072f $ **FLOATING
C4885 a_2532_9360.t0 VSS 0.20064f $ **FLOATING
C4886 a_2532_9360.t3 VSS 0.28263f $ **FLOATING
C4887 a_2532_9360.n0 VSS 0.63451f $ **FLOATING
C4888 a_2532_9360.t1 VSS 0.30493f $ **FLOATING
C4889 a_2532_9360.t2 VSS 0.27266f $ **FLOATING
C4890 a_2532_9360.n1 VSS 0.34142f $ **FLOATING
C4891 a_1178_9017.t1 VSS 0.09033f $ **FLOATING
C4892 a_1178_9017.t0 VSS 0.09271f $ **FLOATING
C4893 a_1178_9017.t2 VSS 0.08433f $ **FLOATING
C4894 a_1178_9017.n0 VSS 0.26172f $ **FLOATING
C4895 a_3280_9093.t1 VSS 0.15513f $ **FLOATING
C4896 a_3280_9093.t2 VSS 0.78293f $ **FLOATING
C4897 a_3280_9093.n0 VSS 0.44013f $ **FLOATING
C4898 a_3280_9093.t0 VSS 0.23527f $ **FLOATING
C4899 a_3508_9233.t0 VSS 0.1094f $ **FLOATING
C4900 a_3508_9233.t2 VSS 0.21808f $ **FLOATING
C4901 a_3508_9233.t1 VSS 0.10861f $ **FLOATING
C4902 a_3508_9233.n0 VSS 0.47589f $ **FLOATING
C4903 a_4081_9294.t0 VSS 0.08718f $ **FLOATING
C4904 a_4081_9294.t2 VSS 0.28889f $ **FLOATING
C4905 a_4081_9294.t1 VSS 0.13908f $ **FLOATING
C4906 a_4081_9294.n0 VSS 0.3269f $ **FLOATING
C4907 a_7105_9394.t0 VSS 0.08965f $ **FLOATING
C4908 a_7105_9394.t2 VSS 0.30104f $ **FLOATING
C4909 a_7105_9394.t1 VSS 0.14058f $ **FLOATING
C4910 a_7105_9394.n0 VSS 0.3742f $ **FLOATING
C4911 a_2310_9029.t0 VSS 0.38794f $ **FLOATING
C4912 a_2310_9029.t1 VSS 0.4464f $ **FLOATING
C4913 a_3186_9093.t0 VSS 0.37163f $ **FLOATING
C4914 a_3186_9093.t1 VSS 0.37297f $ **FLOATING
C4915 a_5169_9090.t3 VSS 0.07497f $ **FLOATING
C4916 a_5169_9090.t6 VSS 0.07497f $ **FLOATING
C4917 a_5169_9090.n0 VSS 0.12649f $ **FLOATING
C4918 a_5169_9090.t2 VSS 0.07497f $ **FLOATING
C4919 a_5169_9090.t7 VSS 0.07497f $ **FLOATING
C4920 a_5169_9090.n1 VSS 0.16231f $ **FLOATING
C4921 a_5169_9090.t1 VSS 0.07497f $ **FLOATING
C4922 a_5169_9090.t5 VSS 0.07497f $ **FLOATING
C4923 a_5169_9090.n2 VSS 0.16231f $ **FLOATING
C4924 a_5169_9090.t0 VSS 0.07497f $ **FLOATING
C4925 a_5169_9090.t4 VSS 0.07497f $ **FLOATING
C4926 a_5169_9090.n3 VSS 0.12648f $ **FLOATING
C4927 a_7199_9394.t0 VSS 0.03797f $ **FLOATING
C4928 a_7410_8998.t0 VSS 0.13446f $ **FLOATING
C4929 a_7410_8998.t1 VSS 0.20721f $ **FLOATING
C4930 a_7410_8998.n0 VSS 0.58105f $ **FLOATING
C4931 a_7410_8998.t2 VSS 0.28375f $ **FLOATING
C4932 a_7799_9314.t0 VSS 0.16181f $ **FLOATING
C4933 a_7799_9314.t3 VSS 0.18538f $ **FLOATING
C4934 a_7799_9314.t1 VSS 0.25392f $ **FLOATING
C4935 a_7799_9314.t2 VSS 0.25308f $ **FLOATING
C4936 a_7799_9314.n0 VSS 0.39454f $ **FLOATING
C4937 a_7799_9314.n1 VSS 0.36235f $ **FLOATING
C4938 a_8515_9239.t0 VSS 0.14825f $ **FLOATING
C4939 a_8515_9239.t2 VSS 0.13696f $ **FLOATING
C4940 a_8515_9239.t3 VSS 0.31242f $ **FLOATING
C4941 a_8515_9239.n0 VSS 0.43824f $ **FLOATING
C4942 a_8515_9239.n1 VSS 0.34324f $ **FLOATING
C4943 a_8515_9239.t1 VSS 0.14672f $ **FLOATING
C4944 a_8255_9016.t0 VSS 0.18249f $ **FLOATING
C4945 a_8255_9016.t1 VSS 0.1835f $ **FLOATING
C4946 a_8255_9016.n0 VSS 0.9866f $ **FLOATING
C4947 a_8255_9016.t2 VSS 0.16418f $ **FLOATING
C4948 a_8255_9016.n1 VSS 1.06956f $ **FLOATING
C4949 a_8255_9016.t3 VSS 0.17004f $ **FLOATING
C4950 a_8541_9334.t0 VSS 0.19142f $ **FLOATING
C4951 a_8541_9334.t4 VSS 0.24711f $ **FLOATING
C4952 a_8541_9334.n0 VSS 0.50757f $ **FLOATING
C4953 a_8541_9334.t2 VSS 0.26941f $ **FLOATING
C4954 a_8541_9334.t3 VSS 0.27166f $ **FLOATING
C4955 a_8541_9334.n1 VSS 0.81773f $ **FLOATING
C4956 a_8541_9334.t1 VSS 0.2757f $ **FLOATING
C4957 a_8541_9334.n2 VSS 0.49604f $ **FLOATING
C4958 a_8950_9273.t0 VSS 0.15491f $ **FLOATING
C4959 a_8950_9273.t3 VSS 0.60109f $ **FLOATING
C4960 a_8950_9273.n0 VSS 0.31833f $ **FLOATING
C4961 a_8950_9273.t1 VSS 0.2267f $ **FLOATING
C4962 a_8950_9273.n1 VSS 0.1803f $ **FLOATING
C4963 a_8950_9273.t2 VSS 0.25071f $ **FLOATING
C4964 a_9052_9360.t0 VSS 0.20064f $ **FLOATING
C4965 a_9052_9360.t3 VSS 0.28263f $ **FLOATING
C4966 a_9052_9360.n0 VSS 0.63449f $ **FLOATING
C4967 a_9052_9360.t1 VSS 0.30493f $ **FLOATING
C4968 a_9052_9360.t2 VSS 0.27265f $ **FLOATING
C4969 a_9052_9360.n1 VSS 0.34142f $ **FLOATING
C4970 a_7698_9017.t1 VSS 0.08423f $ **FLOATING
C4971 a_7698_9017.n0 VSS 0.26141f $ **FLOATING
C4972 a_7698_9017.t0 VSS 0.09022f $ **FLOATING
C4973 a_7698_9017.t2 VSS 0.0926f $ **FLOATING
C4974 a_9800_9093.t1 VSS 0.15513f $ **FLOATING
C4975 a_9800_9093.t2 VSS 0.78293f $ **FLOATING
C4976 a_9800_9093.n0 VSS 0.44013f $ **FLOATING
C4977 a_9800_9093.t0 VSS 0.23527f $ **FLOATING
C4978 a_10028_9233.t0 VSS 0.1094f $ **FLOATING
C4979 a_10028_9233.t2 VSS 0.21808f $ **FLOATING
C4980 a_10028_9233.t1 VSS 0.10861f $ **FLOATING
C4981 a_10028_9233.n0 VSS 0.47589f $ **FLOATING
C4982 a_10601_9294.t0 VSS 0.08718f $ **FLOATING
C4983 a_10601_9294.t2 VSS 0.28889f $ **FLOATING
C4984 a_10601_9294.t1 VSS 0.13908f $ **FLOATING
C4985 a_10601_9294.n0 VSS 0.3269f $ **FLOATING
C4986 a_13625_9394.t0 VSS 0.08975f $ **FLOATING
C4987 a_13625_9394.t2 VSS 0.30136f $ **FLOATING
C4988 a_13625_9394.t1 VSS 0.14073f $ **FLOATING
C4989 a_13625_9394.n0 VSS 0.3746f $ **FLOATING
C4990 a_8830_9029.t0 VSS 0.44638f $ **FLOATING
C4991 a_8830_9029.t1 VSS 0.38792f $ **FLOATING
C4992 a_9706_9093.t0 VSS 0.37163f $ **FLOATING
C4993 a_9706_9093.t1 VSS 0.37297f $ **FLOATING
C4994 a_11689_9090.t3 VSS 0.07497f $ **FLOATING
C4995 a_11689_9090.t6 VSS 0.07497f $ **FLOATING
C4996 a_11689_9090.n0 VSS 0.12649f $ **FLOATING
C4997 a_11689_9090.t2 VSS 0.07497f $ **FLOATING
C4998 a_11689_9090.t7 VSS 0.07497f $ **FLOATING
C4999 a_11689_9090.n1 VSS 0.16231f $ **FLOATING
C5000 a_11689_9090.t1 VSS 0.07497f $ **FLOATING
C5001 a_11689_9090.t5 VSS 0.07497f $ **FLOATING
C5002 a_11689_9090.n2 VSS 0.16231f $ **FLOATING
C5003 a_11689_9090.t0 VSS 0.07497f $ **FLOATING
C5004 a_11689_9090.t4 VSS 0.07497f $ **FLOATING
C5005 a_11689_9090.n3 VSS 0.12649f $ **FLOATING
C5006 a_13719_9394.t0 VSS 0.03799f $ **FLOATING
C5007 a_13930_8998.t0 VSS 0.13454f $ **FLOATING
C5008 a_13930_8998.t1 VSS 0.20733f $ **FLOATING
C5009 a_13930_8998.n0 VSS 0.5814f $ **FLOATING
C5010 a_13930_8998.t2 VSS 0.28392f $ **FLOATING
C5011 a_14319_9314.t1 VSS 0.16163f $ **FLOATING
C5012 a_14319_9314.t3 VSS 0.18517f $ **FLOATING
C5013 a_14319_9314.t0 VSS 0.25363f $ **FLOATING
C5014 a_14319_9314.t2 VSS 0.25279f $ **FLOATING
C5015 a_14319_9314.n0 VSS 0.3941f $ **FLOATING
C5016 a_14319_9314.n1 VSS 0.36194f $ **FLOATING
C5017 a_15035_9239.t0 VSS 0.14671f $ **FLOATING
C5018 a_15035_9239.t1 VSS 0.14824f $ **FLOATING
C5019 a_15035_9239.t2 VSS 0.13695f $ **FLOATING
C5020 a_15035_9239.t3 VSS 0.3124f $ **FLOATING
C5021 a_15035_9239.n0 VSS 0.43822f $ **FLOATING
C5022 a_15035_9239.n1 VSS 0.34322f $ **FLOATING
C5023 a_14775_9016.t0 VSS 0.18248f $ **FLOATING
C5024 a_14775_9016.t1 VSS 0.18348f $ **FLOATING
C5025 a_14775_9016.n0 VSS 0.98653f $ **FLOATING
C5026 a_14775_9016.t3 VSS 0.16417f $ **FLOATING
C5027 a_14775_9016.n1 VSS 1.06948f $ **FLOATING
C5028 a_14775_9016.t2 VSS 0.17003f $ **FLOATING
C5029 a_15061_9334.t0 VSS 0.19141f $ **FLOATING
C5030 a_15061_9334.t4 VSS 0.2471f $ **FLOATING
C5031 a_15061_9334.n0 VSS 0.50754f $ **FLOATING
C5032 a_15061_9334.t3 VSS 0.26939f $ **FLOATING
C5033 a_15061_9334.t2 VSS 0.27164f $ **FLOATING
C5034 a_15061_9334.n1 VSS 0.81769f $ **FLOATING
C5035 a_15061_9334.t1 VSS 0.27569f $ **FLOATING
C5036 a_15061_9334.n2 VSS 0.49602f $ **FLOATING
C5037 a_15470_9273.t0 VSS 0.1549f $ **FLOATING
C5038 a_15470_9273.t3 VSS 0.60104f $ **FLOATING
C5039 a_15470_9273.n0 VSS 0.3183f $ **FLOATING
C5040 a_15470_9273.t1 VSS 0.22668f $ **FLOATING
C5041 a_15470_9273.n1 VSS 0.18028f $ **FLOATING
C5042 a_15470_9273.t2 VSS 0.25069f $ **FLOATING
C5043 a_15572_9360.t0 VSS 0.20063f $ **FLOATING
C5044 a_15572_9360.t3 VSS 0.28262f $ **FLOATING
C5045 a_15572_9360.n0 VSS 0.63448f $ **FLOATING
C5046 a_15572_9360.t1 VSS 0.30492f $ **FLOATING
C5047 a_15572_9360.t2 VSS 0.27265f $ **FLOATING
C5048 a_15572_9360.n1 VSS 0.34141f $ **FLOATING
C5049 a_14218_9017.t1 VSS 0.08404f $ **FLOATING
C5050 a_14218_9017.n0 VSS 0.26082f $ **FLOATING
C5051 a_14218_9017.t0 VSS 0.09001f $ **FLOATING
C5052 a_14218_9017.t2 VSS 0.09239f $ **FLOATING
C5053 a_16320_9093.t1 VSS 0.15513f $ **FLOATING
C5054 a_16320_9093.t2 VSS 0.78293f $ **FLOATING
C5055 a_16320_9093.n0 VSS 0.44013f $ **FLOATING
C5056 a_16320_9093.t0 VSS 0.23527f $ **FLOATING
C5057 a_16548_9233.t0 VSS 0.10861f $ **FLOATING
C5058 a_16548_9233.t1 VSS 0.1094f $ **FLOATING
C5059 a_16548_9233.n0 VSS 0.47589f $ **FLOATING
C5060 a_16548_9233.t2 VSS 0.21808f $ **FLOATING
C5061 a_17121_9294.t0 VSS 0.08718f $ **FLOATING
C5062 a_17121_9294.t2 VSS 0.28889f $ **FLOATING
C5063 a_17121_9294.t1 VSS 0.13908f $ **FLOATING
C5064 a_17121_9294.n0 VSS 0.3269f $ **FLOATING
C5065 a_20145_9394.t0 VSS 0.08964f $ **FLOATING
C5066 a_20145_9394.t2 VSS 0.30097f $ **FLOATING
C5067 a_20145_9394.t1 VSS 0.14055f $ **FLOATING
C5068 a_20145_9394.n0 VSS 0.37411f $ **FLOATING
C5069 a_15350_9029.t0 VSS 0.44637f $ **FLOATING
C5070 a_15350_9029.t1 VSS 0.38791f $ **FLOATING
C5071 a_16226_9093.t0 VSS 0.37163f $ **FLOATING
C5072 a_16226_9093.t1 VSS 0.37297f $ **FLOATING
C5073 a_18209_9090.t3 VSS 0.07497f $ **FLOATING
C5074 a_18209_9090.t6 VSS 0.07496f $ **FLOATING
C5075 a_18209_9090.n0 VSS 0.12648f $ **FLOATING
C5076 a_18209_9090.t2 VSS 0.07497f $ **FLOATING
C5077 a_18209_9090.t7 VSS 0.07496f $ **FLOATING
C5078 a_18209_9090.n1 VSS 0.1623f $ **FLOATING
C5079 a_18209_9090.t1 VSS 0.07497f $ **FLOATING
C5080 a_18209_9090.t5 VSS 0.07496f $ **FLOATING
C5081 a_18209_9090.n2 VSS 0.1623f $ **FLOATING
C5082 a_18209_9090.t0 VSS 0.07497f $ **FLOATING
C5083 a_18209_9090.t4 VSS 0.07497f $ **FLOATING
C5084 a_18209_9090.n3 VSS 0.12648f $ **FLOATING
C5085 a_20239_9394.t0 VSS 0.03796f $ **FLOATING
C5086 a_20450_8998.t0 VSS 0.13432f $ **FLOATING
C5087 a_20450_8998.t1 VSS 0.20699f $ **FLOATING
C5088 a_20450_8998.n0 VSS 0.58045f $ **FLOATING
C5089 a_20450_8998.t2 VSS 0.28346f $ **FLOATING
C5090 a_20839_9314.t0 VSS 0.1619f $ **FLOATING
C5091 a_20839_9314.t3 VSS 0.18548f $ **FLOATING
C5092 a_20839_9314.t1 VSS 0.25406f $ **FLOATING
C5093 a_20839_9314.t2 VSS 0.25322f $ **FLOATING
C5094 a_20839_9314.n0 VSS 0.39476f $ **FLOATING
C5095 a_20839_9314.n1 VSS 0.36255f $ **FLOATING
C5096 a_21555_9239.t0 VSS 0.14825f $ **FLOATING
C5097 a_21555_9239.t2 VSS 0.13696f $ **FLOATING
C5098 a_21555_9239.t3 VSS 0.31243f $ **FLOATING
C5099 a_21555_9239.n0 VSS 0.43826f $ **FLOATING
C5100 a_21555_9239.n1 VSS 0.34325f $ **FLOATING
C5101 a_21555_9239.t1 VSS 0.14672f $ **FLOATING
C5102 a_21295_9016.t0 VSS 0.1825f $ **FLOATING
C5103 a_21295_9016.t1 VSS 0.1835f $ **FLOATING
C5104 a_21295_9016.n0 VSS 0.98664f $ **FLOATING
C5105 a_21295_9016.t3 VSS 0.16419f $ **FLOATING
C5106 a_21295_9016.n1 VSS 1.0696f $ **FLOATING
C5107 a_21295_9016.t2 VSS 0.17005f $ **FLOATING
C5108 a_21581_9334.t0 VSS 0.19142f $ **FLOATING
C5109 a_21581_9334.t4 VSS 0.24712f $ **FLOATING
C5110 a_21581_9334.n0 VSS 0.50759f $ **FLOATING
C5111 a_21581_9334.t3 VSS 0.26941f $ **FLOATING
C5112 a_21581_9334.t2 VSS 0.27167f $ **FLOATING
C5113 a_21581_9334.n1 VSS 0.81776f $ **FLOATING
C5114 a_21581_9334.t1 VSS 0.27571f $ **FLOATING
C5115 a_21581_9334.n2 VSS 0.49606f $ **FLOATING
C5116 a_21990_9273.t0 VSS 0.15491f $ **FLOATING
C5117 a_21990_9273.t3 VSS 0.6011f $ **FLOATING
C5118 a_21990_9273.n0 VSS 0.31833f $ **FLOATING
C5119 a_21990_9273.t1 VSS 0.2267f $ **FLOATING
C5120 a_21990_9273.n1 VSS 0.1803f $ **FLOATING
C5121 a_21990_9273.t2 VSS 0.25072f $ **FLOATING
C5122 a_22092_9360.t0 VSS 0.20064f $ **FLOATING
C5123 a_22092_9360.t3 VSS 0.28263f $ **FLOATING
C5124 a_22092_9360.n0 VSS 0.6345f $ **FLOATING
C5125 a_22092_9360.t1 VSS 0.30493f $ **FLOATING
C5126 a_22092_9360.t2 VSS 0.27266f $ **FLOATING
C5127 a_22092_9360.n1 VSS 0.34142f $ **FLOATING
C5128 a_20738_9017.t1 VSS 0.08426f $ **FLOATING
C5129 a_20738_9017.n0 VSS 0.26149f $ **FLOATING
C5130 a_20738_9017.t0 VSS 0.09025f $ **FLOATING
C5131 a_20738_9017.t2 VSS 0.09263f $ **FLOATING
C5132 a_22840_9093.t1 VSS 0.15513f $ **FLOATING
C5133 a_22840_9093.t2 VSS 0.78293f $ **FLOATING
C5134 a_22840_9093.n0 VSS 0.44013f $ **FLOATING
C5135 a_22840_9093.t0 VSS 0.23527f $ **FLOATING
C5136 a_23068_9233.t0 VSS 0.10861f $ **FLOATING
C5137 a_23068_9233.t1 VSS 0.1094f $ **FLOATING
C5138 a_23068_9233.n0 VSS 0.47589f $ **FLOATING
C5139 a_23068_9233.t2 VSS 0.21808f $ **FLOATING
C5140 a_23641_9294.t0 VSS 0.08718f $ **FLOATING
C5141 a_23641_9294.t2 VSS 0.28889f $ **FLOATING
C5142 a_23641_9294.t1 VSS 0.13908f $ **FLOATING
C5143 a_23641_9294.n0 VSS 0.3269f $ **FLOATING
C5144 a_26665_9394.t0 VSS 0.08968f $ **FLOATING
C5145 a_26665_9394.t2 VSS 0.30111f $ **FLOATING
C5146 a_26665_9394.t1 VSS 0.14061f $ **FLOATING
C5147 a_26665_9394.n0 VSS 0.37428f $ **FLOATING
C5148 a_21870_9029.t0 VSS 0.44639f $ **FLOATING
C5149 a_21870_9029.t1 VSS 0.38793f $ **FLOATING
C5150 a_22746_9093.t0 VSS 0.37163f $ **FLOATING
C5151 a_22746_9093.t1 VSS 0.37297f $ **FLOATING
C5152 a_24729_9090.t3 VSS 0.07497f $ **FLOATING
C5153 a_24729_9090.t6 VSS 0.07497f $ **FLOATING
C5154 a_24729_9090.n0 VSS 0.12649f $ **FLOATING
C5155 a_24729_9090.t2 VSS 0.07497f $ **FLOATING
C5156 a_24729_9090.t7 VSS 0.07497f $ **FLOATING
C5157 a_24729_9090.n1 VSS 0.16231f $ **FLOATING
C5158 a_24729_9090.t1 VSS 0.07497f $ **FLOATING
C5159 a_24729_9090.t5 VSS 0.07497f $ **FLOATING
C5160 a_24729_9090.n2 VSS 0.16231f $ **FLOATING
C5161 a_24729_9090.t0 VSS 0.07497f $ **FLOATING
C5162 a_24729_9090.t4 VSS 0.07497f $ **FLOATING
C5163 a_24729_9090.n3 VSS 0.12649f $ **FLOATING
C5164 a_26759_9394.t0 VSS 0.03798f $ **FLOATING
C5165 a_26970_8998.t0 VSS 0.13446f $ **FLOATING
C5166 a_26970_8998.t1 VSS 0.2072f $ **FLOATING
C5167 a_26970_8998.n0 VSS 0.58104f $ **FLOATING
C5168 a_26970_8998.t2 VSS 0.28375f $ **FLOATING
C5169 a_27359_9314.t0 VSS 0.16172f $ **FLOATING
C5170 a_27359_9314.t3 VSS 0.18527f $ **FLOATING
C5171 a_27359_9314.t1 VSS 0.25378f $ **FLOATING
C5172 a_27359_9314.t2 VSS 0.25293f $ **FLOATING
C5173 a_27359_9314.n0 VSS 0.39432f $ **FLOATING
C5174 a_27359_9314.n1 VSS 0.36214f $ **FLOATING
C5175 a_28075_9239.t0 VSS 0.14671f $ **FLOATING
C5176 a_28075_9239.t1 VSS 0.14824f $ **FLOATING
C5177 a_28075_9239.t2 VSS 0.13696f $ **FLOATING
C5178 a_28075_9239.t3 VSS 0.31241f $ **FLOATING
C5179 a_28075_9239.n0 VSS 0.43823f $ **FLOATING
C5180 a_28075_9239.n1 VSS 0.34323f $ **FLOATING
C5181 a_27815_9016.t0 VSS 0.18249f $ **FLOATING
C5182 a_27815_9016.t1 VSS 0.18349f $ **FLOATING
C5183 a_27815_9016.n0 VSS 0.98657f $ **FLOATING
C5184 a_27815_9016.t2 VSS 0.16418f $ **FLOATING
C5185 a_27815_9016.n1 VSS 1.06952f $ **FLOATING
C5186 a_27815_9016.t3 VSS 0.17004f $ **FLOATING
C5187 a_28101_9334.t0 VSS 0.19141f $ **FLOATING
C5188 a_28101_9334.t4 VSS 0.2471f $ **FLOATING
C5189 a_28101_9334.n0 VSS 0.50756f $ **FLOATING
C5190 a_28101_9334.t2 VSS 0.2694f $ **FLOATING
C5191 a_28101_9334.t3 VSS 0.27165f $ **FLOATING
C5192 a_28101_9334.n1 VSS 0.81771f $ **FLOATING
C5193 a_28101_9334.t1 VSS 0.2757f $ **FLOATING
C5194 a_28101_9334.n2 VSS 0.49603f $ **FLOATING
C5195 a_28510_9273.t0 VSS 0.1549f $ **FLOATING
C5196 a_28510_9273.t3 VSS 0.60107f $ **FLOATING
C5197 a_28510_9273.n0 VSS 0.31831f $ **FLOATING
C5198 a_28510_9273.t1 VSS 0.22669f $ **FLOATING
C5199 a_28510_9273.n1 VSS 0.18029f $ **FLOATING
C5200 a_28510_9273.t2 VSS 0.2507f $ **FLOATING
C5201 a_28612_9360.t0 VSS 0.20064f $ **FLOATING
C5202 a_28612_9360.t3 VSS 0.28262f $ **FLOATING
C5203 a_28612_9360.n0 VSS 0.63449f $ **FLOATING
C5204 a_28612_9360.t1 VSS 0.30492f $ **FLOATING
C5205 a_28612_9360.t2 VSS 0.27265f $ **FLOATING
C5206 a_28612_9360.n1 VSS 0.34141f $ **FLOATING
C5207 a_27258_9017.t1 VSS 0.08411f $ **FLOATING
C5208 a_27258_9017.n0 VSS 0.26104f $ **FLOATING
C5209 a_27258_9017.t0 VSS 0.09009f $ **FLOATING
C5210 a_27258_9017.t2 VSS 0.09247f $ **FLOATING
C5211 a_29360_9093.t1 VSS 0.15513f $ **FLOATING
C5212 a_29360_9093.t2 VSS 0.78293f $ **FLOATING
C5213 a_29360_9093.n0 VSS 0.44013f $ **FLOATING
C5214 a_29360_9093.t0 VSS 0.23527f $ **FLOATING
C5215 a_29588_9233.t0 VSS 0.10861f $ **FLOATING
C5216 a_29588_9233.t1 VSS 0.1094f $ **FLOATING
C5217 a_29588_9233.n0 VSS 0.47589f $ **FLOATING
C5218 a_29588_9233.t2 VSS 0.21808f $ **FLOATING
C5219 a_30161_9294.t0 VSS 0.08718f $ **FLOATING
C5220 a_30161_9294.t2 VSS 0.28889f $ **FLOATING
C5221 a_30161_9294.t1 VSS 0.13908f $ **FLOATING
C5222 a_30161_9294.n0 VSS 0.3269f $ **FLOATING
C5223 a_33185_9394.t0 VSS 0.08957f $ **FLOATING
C5224 a_33185_9394.t2 VSS 0.30075f $ **FLOATING
C5225 a_33185_9394.t1 VSS 0.14044f $ **FLOATING
C5226 a_33185_9394.n0 VSS 0.37383f $ **FLOATING
C5227 a_28390_9029.t0 VSS 0.44638f $ **FLOATING
C5228 a_28390_9029.t1 VSS 0.38792f $ **FLOATING
C5229 a_29266_9093.t0 VSS 0.37163f $ **FLOATING
C5230 a_29266_9093.t1 VSS 0.37297f $ **FLOATING
C5231 a_31249_9090.t3 VSS 0.07496f $ **FLOATING
C5232 a_31249_9090.t6 VSS 0.07496f $ **FLOATING
C5233 a_31249_9090.n0 VSS 0.12648f $ **FLOATING
C5234 a_31249_9090.t2 VSS 0.07496f $ **FLOATING
C5235 a_31249_9090.t7 VSS 0.07496f $ **FLOATING
C5236 a_31249_9090.n1 VSS 0.1623f $ **FLOATING
C5237 a_31249_9090.t1 VSS 0.07496f $ **FLOATING
C5238 a_31249_9090.t5 VSS 0.07496f $ **FLOATING
C5239 a_31249_9090.n2 VSS 0.1623f $ **FLOATING
C5240 a_31249_9090.t0 VSS 0.07496f $ **FLOATING
C5241 a_31249_9090.t4 VSS 0.07496f $ **FLOATING
C5242 a_31249_9090.n3 VSS 0.12648f $ **FLOATING
C5243 a_33279_9394.t0 VSS 0.03791f $ **FLOATING
C5244 a_33490_8998.t0 VSS 0.13464f $ **FLOATING
C5245 a_33490_8998.t1 VSS 0.20749f $ **FLOATING
C5246 a_33490_8998.n0 VSS 0.58184f $ **FLOATING
C5247 a_33490_8998.t2 VSS 0.28414f $ **FLOATING
C5248 a_33879_9314.t0 VSS 0.1624f $ **FLOATING
C5249 a_33879_9314.t3 VSS 0.18606f $ **FLOATING
C5250 a_33879_9314.t1 VSS 0.25485f $ **FLOATING
C5251 a_33879_9314.t2 VSS 0.254f $ **FLOATING
C5252 a_33879_9314.n0 VSS 0.39598f $ **FLOATING
C5253 a_33879_9314.n1 VSS 0.36367f $ **FLOATING
C5254 a_34595_9239.t0 VSS 0.14674f $ **FLOATING
C5255 a_34595_9239.t1 VSS 0.14827f $ **FLOATING
C5256 a_34595_9239.t2 VSS 0.13698f $ **FLOATING
C5257 a_34595_9239.t3 VSS 0.31246f $ **FLOATING
C5258 a_34595_9239.n0 VSS 0.43831f $ **FLOATING
C5259 a_34595_9239.n1 VSS 0.34329f $ **FLOATING
C5260 a_34335_9016.t0 VSS 0.18253f $ **FLOATING
C5261 a_34335_9016.t1 VSS 0.18353f $ **FLOATING
C5262 a_34335_9016.n0 VSS 0.98679f $ **FLOATING
C5263 a_34335_9016.t3 VSS 0.16421f $ **FLOATING
C5264 a_34335_9016.n1 VSS 1.06976f $ **FLOATING
C5265 a_34335_9016.t2 VSS 0.17008f $ **FLOATING
C5266 a_34621_9334.t0 VSS 0.19145f $ **FLOATING
C5267 a_34621_9334.t4 VSS 0.24715f $ **FLOATING
C5268 a_34621_9334.n0 VSS 0.50765f $ **FLOATING
C5269 a_34621_9334.t3 VSS 0.26945f $ **FLOATING
C5270 a_34621_9334.t2 VSS 0.2717f $ **FLOATING
C5271 a_34621_9334.n1 VSS 0.81786f $ **FLOATING
C5272 a_34621_9334.t1 VSS 0.27575f $ **FLOATING
C5273 a_34621_9334.n2 VSS 0.49612f $ **FLOATING
C5274 a_35030_9273.t0 VSS 0.15492f $ **FLOATING
C5275 a_35030_9273.t3 VSS 0.60114f $ **FLOATING
C5276 a_35030_9273.n0 VSS 0.31835f $ **FLOATING
C5277 a_35030_9273.t1 VSS 0.22671f $ **FLOATING
C5278 a_35030_9273.n1 VSS 0.18031f $ **FLOATING
C5279 a_35030_9273.t2 VSS 0.25073f $ **FLOATING
C5280 a_35132_9360.t0 VSS 0.20065f $ **FLOATING
C5281 a_35132_9360.t3 VSS 0.28264f $ **FLOATING
C5282 a_35132_9360.n0 VSS 0.63453f $ **FLOATING
C5283 a_35132_9360.t1 VSS 0.30494f $ **FLOATING
C5284 a_35132_9360.t2 VSS 0.27267f $ **FLOATING
C5285 a_35132_9360.n1 VSS 0.34144f $ **FLOATING
C5286 a_33778_9017.t1 VSS 0.0847f $ **FLOATING
C5287 a_33778_9017.n0 VSS 0.26287f $ **FLOATING
C5288 a_33778_9017.t0 VSS 0.09072f $ **FLOATING
C5289 a_33778_9017.t2 VSS 0.09312f $ **FLOATING
C5290 a_35880_9093.t1 VSS 0.15513f $ **FLOATING
C5291 a_35880_9093.t2 VSS 0.78293f $ **FLOATING
C5292 a_35880_9093.n0 VSS 0.44013f $ **FLOATING
C5293 a_35880_9093.t0 VSS 0.23527f $ **FLOATING
C5294 a_36108_9233.t0 VSS 0.1094f $ **FLOATING
C5295 a_36108_9233.t2 VSS 0.21808f $ **FLOATING
C5296 a_36108_9233.t1 VSS 0.10861f $ **FLOATING
C5297 a_36108_9233.n0 VSS 0.47589f $ **FLOATING
C5298 a_36681_9294.t0 VSS 0.08718f $ **FLOATING
C5299 a_36681_9294.t2 VSS 0.28889f $ **FLOATING
C5300 a_36681_9294.t1 VSS 0.13908f $ **FLOATING
C5301 a_36681_9294.n0 VSS 0.3269f $ **FLOATING
C5302 a_39705_9394.t0 VSS 0.0896f $ **FLOATING
C5303 a_39705_9394.t2 VSS 0.30086f $ **FLOATING
C5304 a_39705_9394.t1 VSS 0.14049f $ **FLOATING
C5305 a_39705_9394.n0 VSS 0.37397f $ **FLOATING
C5306 a_34910_9029.t0 VSS 0.44642f $ **FLOATING
C5307 a_34910_9029.t1 VSS 0.38795f $ **FLOATING
C5308 a_35786_9093.t0 VSS 0.37163f $ **FLOATING
C5309 a_35786_9093.t1 VSS 0.37297f $ **FLOATING
C5310 a_37769_9090.t3 VSS 0.07496f $ **FLOATING
C5311 a_37769_9090.t6 VSS 0.07496f $ **FLOATING
C5312 a_37769_9090.n0 VSS 0.12648f $ **FLOATING
C5313 a_37769_9090.t2 VSS 0.07496f $ **FLOATING
C5314 a_37769_9090.t7 VSS 0.07496f $ **FLOATING
C5315 a_37769_9090.n1 VSS 0.1623f $ **FLOATING
C5316 a_37769_9090.t1 VSS 0.07496f $ **FLOATING
C5317 a_37769_9090.t5 VSS 0.07496f $ **FLOATING
C5318 a_37769_9090.n2 VSS 0.1623f $ **FLOATING
C5319 a_37769_9090.t0 VSS 0.07496f $ **FLOATING
C5320 a_37769_9090.t4 VSS 0.07496f $ **FLOATING
C5321 a_37769_9090.n3 VSS 0.12648f $ **FLOATING
C5322 a_39799_9394.t0 VSS 0.03794f $ **FLOATING
C5323 a_40010_8998.t0 VSS 0.13447f $ **FLOATING
C5324 a_40010_8998.t1 VSS 0.20722f $ **FLOATING
C5325 a_40010_8998.n0 VSS 0.58109f $ **FLOATING
C5326 a_40010_8998.t2 VSS 0.28377f $ **FLOATING
C5327 a_40399_9314.t1 VSS 0.16212f $ **FLOATING
C5328 a_40399_9314.t3 VSS 0.18573f $ **FLOATING
C5329 a_40399_9314.t0 VSS 0.2544f $ **FLOATING
C5330 a_40399_9314.t2 VSS 0.25356f $ **FLOATING
C5331 a_40399_9314.n0 VSS 0.39529f $ **FLOATING
C5332 a_40399_9314.n1 VSS 0.36304f $ **FLOATING
C5333 a_41115_9239.t0 VSS 0.14673f $ **FLOATING
C5334 a_41115_9239.t1 VSS 0.14826f $ **FLOATING
C5335 a_41115_9239.t2 VSS 0.13697f $ **FLOATING
C5336 a_41115_9239.t3 VSS 0.31244f $ **FLOATING
C5337 a_41115_9239.n0 VSS 0.43828f $ **FLOATING
C5338 a_41115_9239.n1 VSS 0.34327f $ **FLOATING
C5339 a_40855_9016.t0 VSS 0.18251f $ **FLOATING
C5340 a_40855_9016.t1 VSS 0.18352f $ **FLOATING
C5341 a_40855_9016.n0 VSS 0.98672f $ **FLOATING
C5342 a_40855_9016.t2 VSS 0.1642f $ **FLOATING
C5343 a_40855_9016.n1 VSS 1.06968f $ **FLOATING
C5344 a_40855_9016.t3 VSS 0.17006f $ **FLOATING
C5345 a_41141_9334.t0 VSS 0.19144f $ **FLOATING
C5346 a_41141_9334.t4 VSS 0.24713f $ **FLOATING
C5347 a_41141_9334.n0 VSS 0.50762f $ **FLOATING
C5348 a_41141_9334.t2 VSS 0.26943f $ **FLOATING
C5349 a_41141_9334.t3 VSS 0.27168f $ **FLOATING
C5350 a_41141_9334.n1 VSS 0.81781f $ **FLOATING
C5351 a_41141_9334.t1 VSS 0.27573f $ **FLOATING
C5352 a_41141_9334.n2 VSS 0.49609f $ **FLOATING
C5353 a_41550_9273.t0 VSS 0.15491f $ **FLOATING
C5354 a_41550_9273.t3 VSS 0.60112f $ **FLOATING
C5355 a_41550_9273.n0 VSS 0.31834f $ **FLOATING
C5356 a_41550_9273.t1 VSS 0.22671f $ **FLOATING
C5357 a_41550_9273.n1 VSS 0.1803f $ **FLOATING
C5358 a_41550_9273.t2 VSS 0.25072f $ **FLOATING
C5359 a_41652_9360.t0 VSS 0.20064f $ **FLOATING
C5360 a_41652_9360.t3 VSS 0.28264f $ **FLOATING
C5361 a_41652_9360.n0 VSS 0.63451f $ **FLOATING
C5362 a_41652_9360.t1 VSS 0.30494f $ **FLOATING
C5363 a_41652_9360.t2 VSS 0.27266f $ **FLOATING
C5364 a_41652_9360.n1 VSS 0.34143f $ **FLOATING
C5365 a_40298_9017.t1 VSS 0.08445f $ **FLOATING
C5366 a_40298_9017.n0 VSS 0.26207f $ **FLOATING
C5367 a_40298_9017.t0 VSS 0.09045f $ **FLOATING
C5368 a_40298_9017.t2 VSS 0.09284f $ **FLOATING
C5369 a_42400_9093.t1 VSS 0.15513f $ **FLOATING
C5370 a_42400_9093.t2 VSS 0.78293f $ **FLOATING
C5371 a_42400_9093.n0 VSS 0.44013f $ **FLOATING
C5372 a_42400_9093.t0 VSS 0.23527f $ **FLOATING
C5373 a_42628_9233.t0 VSS 0.1094f $ **FLOATING
C5374 a_42628_9233.t2 VSS 0.21808f $ **FLOATING
C5375 a_42628_9233.t1 VSS 0.10861f $ **FLOATING
C5376 a_42628_9233.n0 VSS 0.47589f $ **FLOATING
C5377 a_43201_9294.t0 VSS 0.08718f $ **FLOATING
C5378 a_43201_9294.t2 VSS 0.28889f $ **FLOATING
C5379 a_43201_9294.t1 VSS 0.13908f $ **FLOATING
C5380 a_43201_9294.n0 VSS 0.3269f $ **FLOATING
C5381 a_46225_9394.t0 VSS 0.07049f $ **FLOATING
C5382 a_46225_9394.t2 VSS 0.23668f $ **FLOATING
C5383 a_46225_9394.t1 VSS 0.11053f $ **FLOATING
C5384 a_46225_9394.n0 VSS 0.2942f $ **FLOATING
C5385 a_41430_9029.t0 VSS 0.4464f $ **FLOATING
C5386 a_41430_9029.t1 VSS 0.38794f $ **FLOATING
C5387 a_42306_9093.t0 VSS 0.37163f $ **FLOATING
C5388 a_42306_9093.t1 VSS 0.37297f $ **FLOATING
C5389 a_44289_9090.t3 VSS 0.0747f $ **FLOATING
C5390 a_44289_9090.t6 VSS 0.0747f $ **FLOATING
C5391 a_44289_9090.n0 VSS 0.12604f $ **FLOATING
C5392 a_44289_9090.t2 VSS 0.0747f $ **FLOATING
C5393 a_44289_9090.t7 VSS 0.0747f $ **FLOATING
C5394 a_44289_9090.n1 VSS 0.16173f $ **FLOATING
C5395 a_44289_9090.t1 VSS 0.0747f $ **FLOATING
C5396 a_44289_9090.t5 VSS 0.0747f $ **FLOATING
C5397 a_44289_9090.n2 VSS 0.16173f $ **FLOATING
C5398 a_44289_9090.t0 VSS 0.0747f $ **FLOATING
C5399 a_44289_9090.t4 VSS 0.0747f $ **FLOATING
C5400 a_44289_9090.n3 VSS 0.12604f $ **FLOATING
C5401 a_46319_9394.t0 VSS 0.02042f $ **FLOATING
C5402 a_46530_8998.t0 VSS 0.13323f $ **FLOATING
C5403 a_46530_8998.t1 VSS 0.20532f $ **FLOATING
C5404 a_46530_8998.n0 VSS 0.57576f $ **FLOATING
C5405 a_46530_8998.t2 VSS 0.28117f $ **FLOATING
C5406 a_46919_9314.t0 VSS 0.16211f $ **FLOATING
C5407 a_46919_9314.t3 VSS 0.18572f $ **FLOATING
C5408 a_46919_9314.t1 VSS 0.25438f $ **FLOATING
C5409 a_46919_9314.t2 VSS 0.25354f $ **FLOATING
C5410 a_46919_9314.n0 VSS 0.39526f $ **FLOATING
C5411 a_46919_9314.n1 VSS 0.36301f $ **FLOATING
C5412 a_47635_9239.t0 VSS 0.14673f $ **FLOATING
C5413 a_47635_9239.t1 VSS 0.14826f $ **FLOATING
C5414 a_47635_9239.t2 VSS 0.13697f $ **FLOATING
C5415 a_47635_9239.t3 VSS 0.31244f $ **FLOATING
C5416 a_47635_9239.n0 VSS 0.43828f $ **FLOATING
C5417 a_47635_9239.n1 VSS 0.34327f $ **FLOATING
C5418 a_47375_9016.t0 VSS 0.18251f $ **FLOATING
C5419 a_47375_9016.t1 VSS 0.18352f $ **FLOATING
C5420 a_47375_9016.n0 VSS 0.98672f $ **FLOATING
C5421 a_47375_9016.t3 VSS 0.1642f $ **FLOATING
C5422 a_47375_9016.n1 VSS 1.06968f $ **FLOATING
C5423 a_47375_9016.t2 VSS 0.17006f $ **FLOATING
C5424 a_47661_9334.t0 VSS 0.19144f $ **FLOATING
C5425 a_47661_9334.t4 VSS 0.24713f $ **FLOATING
C5426 a_47661_9334.n0 VSS 0.50762f $ **FLOATING
C5427 a_47661_9334.t3 VSS 0.26943f $ **FLOATING
C5428 a_47661_9334.t2 VSS 0.27168f $ **FLOATING
C5429 a_47661_9334.n1 VSS 0.81781f $ **FLOATING
C5430 a_47661_9334.t1 VSS 0.27573f $ **FLOATING
C5431 a_47661_9334.n2 VSS 0.49609f $ **FLOATING
C5432 a_48070_9273.t0 VSS 0.15491f $ **FLOATING
C5433 a_48070_9273.t3 VSS 0.60112f $ **FLOATING
C5434 a_48070_9273.n0 VSS 0.31834f $ **FLOATING
C5435 a_48070_9273.t1 VSS 0.22671f $ **FLOATING
C5436 a_48070_9273.n1 VSS 0.1803f $ **FLOATING
C5437 a_48070_9273.t2 VSS 0.25072f $ **FLOATING
C5438 a_48172_9360.t0 VSS 0.20064f $ **FLOATING
C5439 a_48172_9360.t3 VSS 0.28264f $ **FLOATING
C5440 a_48172_9360.n0 VSS 0.63451f $ **FLOATING
C5441 a_48172_9360.t1 VSS 0.30494f $ **FLOATING
C5442 a_48172_9360.t2 VSS 0.27266f $ **FLOATING
C5443 a_48172_9360.n1 VSS 0.34143f $ **FLOATING
C5444 a_46818_9017.t1 VSS 0.08429f $ **FLOATING
C5445 a_46818_9017.n0 VSS 0.26158f $ **FLOATING
C5446 a_46818_9017.t0 VSS 0.09028f $ **FLOATING
C5447 a_46818_9017.t2 VSS 0.09266f $ **FLOATING
C5448 a_48920_9093.t1 VSS 0.15513f $ **FLOATING
C5449 a_48920_9093.t2 VSS 0.78293f $ **FLOATING
C5450 a_48920_9093.n0 VSS 0.44013f $ **FLOATING
C5451 a_48920_9093.t0 VSS 0.23527f $ **FLOATING
C5452 a_49148_9233.t0 VSS 0.10861f $ **FLOATING
C5453 a_49148_9233.t1 VSS 0.1094f $ **FLOATING
C5454 a_49148_9233.n0 VSS 0.47589f $ **FLOATING
C5455 a_49148_9233.t2 VSS 0.21808f $ **FLOATING
C5456 a_49721_9294.t0 VSS 0.08718f $ **FLOATING
C5457 a_49721_9294.t2 VSS 0.28889f $ **FLOATING
C5458 a_49721_9294.t1 VSS 0.13908f $ **FLOATING
C5459 a_49721_9294.n0 VSS 0.3269f $ **FLOATING
C5460 a_47950_9029.t0 VSS 0.4464f $ **FLOATING
C5461 a_47950_9029.t1 VSS 0.38794f $ **FLOATING
C5462 a_48826_9093.t0 VSS 0.37163f $ **FLOATING
C5463 a_48826_9093.t1 VSS 0.37297f $ **FLOATING
C5464 a_50809_9090.t3 VSS 0.07465f $ **FLOATING
C5465 a_50809_9090.t6 VSS 0.07465f $ **FLOATING
C5466 a_50809_9090.n0 VSS 0.12595f $ **FLOATING
C5467 a_50809_9090.t2 VSS 0.07465f $ **FLOATING
C5468 a_50809_9090.t7 VSS 0.07465f $ **FLOATING
C5469 a_50809_9090.n1 VSS 0.16162f $ **FLOATING
C5470 a_50809_9090.t1 VSS 0.07465f $ **FLOATING
C5471 a_50809_9090.t5 VSS 0.07465f $ **FLOATING
C5472 a_50809_9090.n2 VSS 0.16162f $ **FLOATING
C5473 a_50809_9090.t0 VSS 0.07465f $ **FLOATING
C5474 a_50809_9090.t4 VSS 0.07465f $ **FLOATING
C5475 a_50809_9090.n3 VSS 0.12595f $ **FLOATING
C5476 a_3877_6494.t0 VSS 0.06039f $ **FLOATING
C5477 a_3877_6494.n0 VSS 0.63583f $ **FLOATING
C5478 a_3877_6494.t2 VSS 0.43776f $ **FLOATING
C5479 a_3877_6494.t1 VSS 0.09863f $ **FLOATING
C5480 a_10397_6494.t0 VSS 0.06039f $ **FLOATING
C5481 a_10397_6494.n0 VSS 0.63584f $ **FLOATING
C5482 a_10397_6494.t2 VSS 0.43777f $ **FLOATING
C5483 a_10397_6494.t1 VSS 0.09863f $ **FLOATING
C5484 a_4298_6514.t0 VSS 0.06067f $ **FLOATING
C5485 a_4298_6514.t1 VSS 0.09886f $ **FLOATING
C5486 a_4298_6514.n0 VSS 0.62315f $ **FLOATING
C5487 a_4298_6514.t2 VSS 0.26475f $ **FLOATING
C5488 a_16917_6494.t0 VSS 0.06039f $ **FLOATING
C5489 a_16917_6494.n0 VSS 0.63581f $ **FLOATING
C5490 a_16917_6494.t2 VSS 0.43775f $ **FLOATING
C5491 a_16917_6494.t1 VSS 0.09863f $ **FLOATING
C5492 a_10818_6514.t0 VSS 0.06067f $ **FLOATING
C5493 a_10818_6514.t1 VSS 0.09886f $ **FLOATING
C5494 a_10818_6514.n0 VSS 0.62315f $ **FLOATING
C5495 a_10818_6514.t2 VSS 0.26475f $ **FLOATING
C5496 a_23437_6494.t0 VSS 0.06039f $ **FLOATING
C5497 a_23437_6494.n0 VSS 0.63584f $ **FLOATING
C5498 a_23437_6494.t2 VSS 0.43777f $ **FLOATING
C5499 a_23437_6494.t1 VSS 0.09863f $ **FLOATING
C5500 a_17338_6514.t0 VSS 0.06067f $ **FLOATING
C5501 a_17338_6514.t1 VSS 0.09886f $ **FLOATING
C5502 a_17338_6514.n0 VSS 0.62316f $ **FLOATING
C5503 a_17338_6514.t2 VSS 0.26475f $ **FLOATING
C5504 a_29957_6494.t0 VSS 0.06038f $ **FLOATING
C5505 a_29957_6494.n0 VSS 0.63573f $ **FLOATING
C5506 a_29957_6494.t2 VSS 0.43769f $ **FLOATING
C5507 a_29957_6494.t1 VSS 0.09861f $ **FLOATING
C5508 a_23858_6514.t0 VSS 0.06067f $ **FLOATING
C5509 a_23858_6514.t1 VSS 0.09886f $ **FLOATING
C5510 a_23858_6514.n0 VSS 0.62316f $ **FLOATING
C5511 a_23858_6514.t2 VSS 0.26475f $ **FLOATING
C5512 a_36477_6494.t0 VSS 0.06038f $ **FLOATING
C5513 a_36477_6494.n0 VSS 0.63575f $ **FLOATING
C5514 a_36477_6494.t2 VSS 0.43771f $ **FLOATING
C5515 a_36477_6494.t1 VSS 0.09862f $ **FLOATING
C5516 a_30378_6514.t0 VSS 0.06067f $ **FLOATING
C5517 a_30378_6514.t1 VSS 0.09886f $ **FLOATING
C5518 a_30378_6514.n0 VSS 0.62316f $ **FLOATING
C5519 a_30378_6514.t2 VSS 0.26475f $ **FLOATING
C5520 a_42997_6494.t0 VSS 0.06037f $ **FLOATING
C5521 a_42997_6494.n0 VSS 0.63567f $ **FLOATING
C5522 a_42997_6494.t2 VSS 0.43765f $ **FLOATING
C5523 a_42997_6494.t1 VSS 0.09861f $ **FLOATING
C5524 a_36898_6514.t0 VSS 0.06067f $ **FLOATING
C5525 a_36898_6514.t1 VSS 0.09886f $ **FLOATING
C5526 a_36898_6514.n0 VSS 0.62315f $ **FLOATING
C5527 a_36898_6514.t2 VSS 0.26475f $ **FLOATING
C5528 a_49517_6494.t0 VSS 0.06037f $ **FLOATING
C5529 a_49517_6494.n0 VSS 0.63561f $ **FLOATING
C5530 a_49517_6494.t2 VSS 0.43761f $ **FLOATING
C5531 a_49517_6494.t1 VSS 0.0986f $ **FLOATING
C5532 a_43418_6514.t0 VSS 0.06066f $ **FLOATING
C5533 a_43418_6514.t1 VSS 0.09885f $ **FLOATING
C5534 a_43418_6514.n0 VSS 0.62309f $ **FLOATING
C5535 a_43418_6514.t2 VSS 0.26472f $ **FLOATING
C5536 a_49938_6514.t0 VSS 0.06067f $ **FLOATING
C5537 a_49938_6514.t1 VSS 0.09886f $ **FLOATING
C5538 a_49938_6514.n0 VSS 0.62315f $ **FLOATING
C5539 a_49938_6514.t2 VSS 0.26474f $ **FLOATING
C5540 a_5003_6550.t9 VSS 0.12816f $ **FLOATING
C5541 a_5003_6550.t8 VSS 0.12742f $ **FLOATING
C5542 a_5003_6550.n0 VSS 0.31237f $ **FLOATING
C5543 a_5003_6550.t6 VSS 0.09877f $ **FLOATING
C5544 a_5003_6550.n1 VSS 0.38034f $ **FLOATING
C5545 a_5003_6550.t4 VSS 0.0965f $ **FLOATING
C5546 a_5003_6550.n2 VSS 0.33102f $ **FLOATING
C5547 a_5003_6550.t0 VSS 0.1108f $ **FLOATING
C5548 a_5003_6550.t5 VSS 0.0965f $ **FLOATING
C5549 a_5003_6550.n3 VSS 0.33102f $ **FLOATING
C5550 a_5003_6550.t1 VSS 0.1108f $ **FLOATING
C5551 a_5003_6550.t2 VSS 0.14548f $ **FLOATING
C5552 a_5003_6550.t7 VSS 0.12816f $ **FLOATING
C5553 a_5003_6550.n4 VSS 0.34636f $ **FLOATING
C5554 a_5003_6550.t3 VSS 0.14548f $ **FLOATING
C5555 a_5003_6550.n5 VSS 0.34636f $ **FLOATING
C5556 a_11523_6550.t9 VSS 0.12816f $ **FLOATING
C5557 a_11523_6550.t8 VSS 0.12742f $ **FLOATING
C5558 a_11523_6550.n0 VSS 0.31239f $ **FLOATING
C5559 a_11523_6550.t6 VSS 0.09878f $ **FLOATING
C5560 a_11523_6550.n1 VSS 0.38036f $ **FLOATING
C5561 a_11523_6550.t4 VSS 0.0965f $ **FLOATING
C5562 a_11523_6550.n2 VSS 0.33104f $ **FLOATING
C5563 a_11523_6550.t0 VSS 0.1108f $ **FLOATING
C5564 a_11523_6550.t5 VSS 0.0965f $ **FLOATING
C5565 a_11523_6550.n3 VSS 0.33104f $ **FLOATING
C5566 a_11523_6550.t1 VSS 0.1108f $ **FLOATING
C5567 a_11523_6550.t2 VSS 0.14549f $ **FLOATING
C5568 a_11523_6550.t7 VSS 0.12816f $ **FLOATING
C5569 a_11523_6550.n4 VSS 0.34637f $ **FLOATING
C5570 a_11523_6550.t3 VSS 0.14549f $ **FLOATING
C5571 a_11523_6550.n5 VSS 0.34637f $ **FLOATING
C5572 a_18043_6550.t9 VSS 0.12816f $ **FLOATING
C5573 a_18043_6550.t8 VSS 0.12741f $ **FLOATING
C5574 a_18043_6550.n0 VSS 0.31237f $ **FLOATING
C5575 a_18043_6550.t6 VSS 0.09877f $ **FLOATING
C5576 a_18043_6550.n1 VSS 0.38034f $ **FLOATING
C5577 a_18043_6550.t4 VSS 0.0965f $ **FLOATING
C5578 a_18043_6550.n2 VSS 0.33102f $ **FLOATING
C5579 a_18043_6550.t0 VSS 0.1108f $ **FLOATING
C5580 a_18043_6550.t5 VSS 0.0965f $ **FLOATING
C5581 a_18043_6550.n3 VSS 0.33102f $ **FLOATING
C5582 a_18043_6550.t1 VSS 0.1108f $ **FLOATING
C5583 a_18043_6550.t2 VSS 0.14548f $ **FLOATING
C5584 a_18043_6550.t7 VSS 0.12816f $ **FLOATING
C5585 a_18043_6550.n4 VSS 0.34635f $ **FLOATING
C5586 a_18043_6550.t3 VSS 0.14548f $ **FLOATING
C5587 a_18043_6550.n5 VSS 0.34635f $ **FLOATING
C5588 a_24563_6550.t9 VSS 0.12816f $ **FLOATING
C5589 a_24563_6550.t8 VSS 0.12742f $ **FLOATING
C5590 a_24563_6550.n0 VSS 0.31238f $ **FLOATING
C5591 a_24563_6550.t6 VSS 0.09877f $ **FLOATING
C5592 a_24563_6550.n1 VSS 0.38035f $ **FLOATING
C5593 a_24563_6550.t4 VSS 0.0965f $ **FLOATING
C5594 a_24563_6550.n2 VSS 0.33103f $ **FLOATING
C5595 a_24563_6550.t0 VSS 0.1108f $ **FLOATING
C5596 a_24563_6550.t5 VSS 0.0965f $ **FLOATING
C5597 a_24563_6550.n3 VSS 0.33103f $ **FLOATING
C5598 a_24563_6550.t1 VSS 0.1108f $ **FLOATING
C5599 a_24563_6550.t2 VSS 0.14548f $ **FLOATING
C5600 a_24563_6550.t7 VSS 0.12816f $ **FLOATING
C5601 a_24563_6550.n4 VSS 0.34636f $ **FLOATING
C5602 a_24563_6550.t3 VSS 0.14548f $ **FLOATING
C5603 a_24563_6550.n5 VSS 0.34636f $ **FLOATING
C5604 a_31083_6550.t9 VSS 0.12815f $ **FLOATING
C5605 a_31083_6550.t8 VSS 0.12741f $ **FLOATING
C5606 a_31083_6550.n0 VSS 0.31236f $ **FLOATING
C5607 a_31083_6550.t6 VSS 0.09877f $ **FLOATING
C5608 a_31083_6550.n1 VSS 0.38033f $ **FLOATING
C5609 a_31083_6550.t4 VSS 0.09649f $ **FLOATING
C5610 a_31083_6550.n2 VSS 0.331f $ **FLOATING
C5611 a_31083_6550.t0 VSS 0.11079f $ **FLOATING
C5612 a_31083_6550.t5 VSS 0.09649f $ **FLOATING
C5613 a_31083_6550.n3 VSS 0.331f $ **FLOATING
C5614 a_31083_6550.t1 VSS 0.11079f $ **FLOATING
C5615 a_31083_6550.t2 VSS 0.14548f $ **FLOATING
C5616 a_31083_6550.t7 VSS 0.12815f $ **FLOATING
C5617 a_31083_6550.n4 VSS 0.34634f $ **FLOATING
C5618 a_31083_6550.t3 VSS 0.14548f $ **FLOATING
C5619 a_31083_6550.n5 VSS 0.34634f $ **FLOATING
C5620 a_37603_6550.t9 VSS 0.12815f $ **FLOATING
C5621 a_37603_6550.t8 VSS 0.12741f $ **FLOATING
C5622 a_37603_6550.n0 VSS 0.31236f $ **FLOATING
C5623 a_37603_6550.t6 VSS 0.09877f $ **FLOATING
C5624 a_37603_6550.n1 VSS 0.38033f $ **FLOATING
C5625 a_37603_6550.t5 VSS 0.0965f $ **FLOATING
C5626 a_37603_6550.n2 VSS 0.33101f $ **FLOATING
C5627 a_37603_6550.t0 VSS 0.11079f $ **FLOATING
C5628 a_37603_6550.t4 VSS 0.0965f $ **FLOATING
C5629 a_37603_6550.n3 VSS 0.33101f $ **FLOATING
C5630 a_37603_6550.t1 VSS 0.11079f $ **FLOATING
C5631 a_37603_6550.t2 VSS 0.14548f $ **FLOATING
C5632 a_37603_6550.t7 VSS 0.12815f $ **FLOATING
C5633 a_37603_6550.n4 VSS 0.34635f $ **FLOATING
C5634 a_37603_6550.t3 VSS 0.14548f $ **FLOATING
C5635 a_37603_6550.n5 VSS 0.34635f $ **FLOATING
C5636 a_44123_6550.t9 VSS 0.12781f $ **FLOATING
C5637 a_44123_6550.t8 VSS 0.12707f $ **FLOATING
C5638 a_44123_6550.n0 VSS 0.31153f $ **FLOATING
C5639 a_44123_6550.t6 VSS 0.09851f $ **FLOATING
C5640 a_44123_6550.n1 VSS 0.37932f $ **FLOATING
C5641 a_44123_6550.t4 VSS 0.09624f $ **FLOATING
C5642 a_44123_6550.n2 VSS 0.33013f $ **FLOATING
C5643 a_44123_6550.t0 VSS 0.1105f $ **FLOATING
C5644 a_44123_6550.t5 VSS 0.09624f $ **FLOATING
C5645 a_44123_6550.n3 VSS 0.33013f $ **FLOATING
C5646 a_44123_6550.t1 VSS 0.1105f $ **FLOATING
C5647 a_44123_6550.t2 VSS 0.14509f $ **FLOATING
C5648 a_44123_6550.t7 VSS 0.12781f $ **FLOATING
C5649 a_44123_6550.n4 VSS 0.34543f $ **FLOATING
C5650 a_44123_6550.t3 VSS 0.14509f $ **FLOATING
C5651 a_44123_6550.n5 VSS 0.34543f $ **FLOATING
C5652 a_50643_6550.t9 VSS 0.12775f $ **FLOATING
C5653 a_50643_6550.t8 VSS 0.12701f $ **FLOATING
C5654 a_50643_6550.n0 VSS 0.31138f $ **FLOATING
C5655 a_50643_6550.t6 VSS 0.09846f $ **FLOATING
C5656 a_50643_6550.n1 VSS 0.37913f $ **FLOATING
C5657 a_50643_6550.t5 VSS 0.09619f $ **FLOATING
C5658 a_50643_6550.n2 VSS 0.32997f $ **FLOATING
C5659 a_50643_6550.t0 VSS 0.11045f $ **FLOATING
C5660 a_50643_6550.t4 VSS 0.09619f $ **FLOATING
C5661 a_50643_6550.n3 VSS 0.32997f $ **FLOATING
C5662 a_50643_6550.t1 VSS 0.11045f $ **FLOATING
C5663 a_50643_6550.t2 VSS 0.14502f $ **FLOATING
C5664 a_50643_6550.t7 VSS 0.12775f $ **FLOATING
C5665 a_50643_6550.n4 VSS 0.34526f $ **FLOATING
C5666 a_50643_6550.t3 VSS 0.14502f $ **FLOATING
C5667 a_50643_6550.n5 VSS 0.34526f $ **FLOATING
C5668 a_585_6594.t0 VSS 0.09044f $ **FLOATING
C5669 a_585_6594.t2 VSS 0.30366f $ **FLOATING
C5670 a_585_6594.t1 VSS 0.1418f $ **FLOATING
C5671 a_585_6594.n0 VSS 0.37745f $ **FLOATING
C5672 a_679_6594.t0 VSS 0.03715f $ **FLOATING
C5673 a_890_6198.t0 VSS 0.13383f $ **FLOATING
C5674 a_890_6198.t1 VSS 0.20624f $ **FLOATING
C5675 a_890_6198.n0 VSS 0.57834f $ **FLOATING
C5676 a_890_6198.t2 VSS 0.28243f $ **FLOATING
C5677 a_n2646_2484.t0 VSS 0.12338f $ **FLOATING
C5678 a_n2646_2484.n0 VSS 0.22093f $ **FLOATING
C5679 a_n2646_2484.t2 VSS 0.13386f $ **FLOATING
C5680 a_n2646_2484.n1 VSS 3.06772f $ **FLOATING
C5681 a_n2646_2484.t11 VSS 0.46937f $ **FLOATING
C5682 a_n2646_2484.n2 VSS 12.3398f $ **FLOATING
C5683 a_n2646_2484.t3 VSS 0.35744f $ **FLOATING
C5684 a_n2646_2484.n3 VSS 4.47345f $ **FLOATING
C5685 a_n2646_2484.t12 VSS 0.33226f $ **FLOATING
C5686 a_n2646_2484.n4 VSS 5.03945f $ **FLOATING
C5687 a_n2646_2484.t4 VSS 0.35744f $ **FLOATING
C5688 a_n2646_2484.n5 VSS 4.47345f $ **FLOATING
C5689 a_n2646_2484.t13 VSS 0.33226f $ **FLOATING
C5690 a_n2646_2484.n6 VSS 5.03945f $ **FLOATING
C5691 a_n2646_2484.t5 VSS 0.35744f $ **FLOATING
C5692 a_n2646_2484.n7 VSS 4.47345f $ **FLOATING
C5693 a_n2646_2484.t14 VSS 0.33226f $ **FLOATING
C5694 a_n2646_2484.n8 VSS 5.03945f $ **FLOATING
C5695 a_n2646_2484.t6 VSS 0.35744f $ **FLOATING
C5696 a_n2646_2484.n9 VSS 4.47345f $ **FLOATING
C5697 a_n2646_2484.t15 VSS 0.33226f $ **FLOATING
C5698 a_n2646_2484.n10 VSS 5.03945f $ **FLOATING
C5699 a_n2646_2484.t7 VSS 0.35744f $ **FLOATING
C5700 a_n2646_2484.n11 VSS 4.47345f $ **FLOATING
C5701 a_n2646_2484.t16 VSS 0.33226f $ **FLOATING
C5702 a_n2646_2484.n12 VSS 5.03945f $ **FLOATING
C5703 a_n2646_2484.t8 VSS 0.35744f $ **FLOATING
C5704 a_n2646_2484.n13 VSS 4.47345f $ **FLOATING
C5705 a_n2646_2484.t17 VSS 0.33226f $ **FLOATING
C5706 a_n2646_2484.n14 VSS 5.03945f $ **FLOATING
C5707 a_n2646_2484.t9 VSS 0.35744f $ **FLOATING
C5708 a_n2646_2484.n15 VSS 4.47345f $ **FLOATING
C5709 a_n2646_2484.t18 VSS 0.33226f $ **FLOATING
C5710 a_n2646_2484.n16 VSS 8.38445f $ **FLOATING
C5711 a_n2646_2484.t10 VSS 0.35744f $ **FLOATING
C5712 a_n2646_2484.t1 VSS 0.1888f $ **FLOATING
C5713 a_1279_6514.t2 VSS 0.16148f $ **FLOATING
C5714 a_1279_6514.t3 VSS 0.18499f $ **FLOATING
C5715 a_1279_6514.t1 VSS 0.25339f $ **FLOATING
C5716 a_1279_6514.t0 VSS 0.25255f $ **FLOATING
C5717 a_1279_6514.n0 VSS 0.39372f $ **FLOATING
C5718 a_1279_6514.n1 VSS 0.3616f $ **FLOATING
C5719 a_1995_6439.t0 VSS 0.1463f $ **FLOATING
C5720 a_1995_6439.t1 VSS 0.14783f $ **FLOATING
C5721 a_1995_6439.t2 VSS 0.13657f $ **FLOATING
C5722 a_1995_6439.t3 VSS 0.31154f $ **FLOATING
C5723 a_1995_6439.n0 VSS 0.43701f $ **FLOATING
C5724 a_1995_6439.n1 VSS 0.34227f $ **FLOATING
C5725 a_1735_6216.t0 VSS 0.18203f $ **FLOATING
C5726 a_1735_6216.t1 VSS 0.18303f $ **FLOATING
C5727 a_1735_6216.n0 VSS 0.98409f $ **FLOATING
C5728 a_1735_6216.t2 VSS 0.16376f $ **FLOATING
C5729 a_1735_6216.n1 VSS 1.06683f $ **FLOATING
C5730 a_1735_6216.t3 VSS 0.16961f $ **FLOATING
C5731 a_2021_6534.t0 VSS 0.19099f $ **FLOATING
C5732 a_2021_6534.t4 VSS 0.24656f $ **FLOATING
C5733 a_2021_6534.n0 VSS 0.50644f $ **FLOATING
C5734 a_2021_6534.t2 VSS 0.2688f $ **FLOATING
C5735 a_2021_6534.t3 VSS 0.27105f $ **FLOATING
C5736 a_2021_6534.n1 VSS 0.81591f $ **FLOATING
C5737 a_2021_6534.t1 VSS 0.27509f $ **FLOATING
C5738 a_2021_6534.n2 VSS 0.49494f $ **FLOATING
C5739 a_2430_6473.t0 VSS 0.15438f $ **FLOATING
C5740 a_2430_6473.t3 VSS 0.59903f $ **FLOATING
C5741 a_2430_6473.n0 VSS 0.31723f $ **FLOATING
C5742 a_2430_6473.t1 VSS 0.22592f $ **FLOATING
C5743 a_2430_6473.n1 VSS 0.17968f $ **FLOATING
C5744 a_2430_6473.t2 VSS 0.24985f $ **FLOATING
C5745 a_2532_6560.t0 VSS 0.19992f $ **FLOATING
C5746 a_2532_6560.t3 VSS 0.28161f $ **FLOATING
C5747 a_2532_6560.n0 VSS 0.63221f $ **FLOATING
C5748 a_2532_6560.t1 VSS 0.30383f $ **FLOATING
C5749 a_2532_6560.t2 VSS 0.27167f $ **FLOATING
C5750 a_2532_6560.n1 VSS 0.34019f $ **FLOATING
C5751 a_1178_6217.t1 VSS 0.09015f $ **FLOATING
C5752 a_1178_6217.t0 VSS 0.09253f $ **FLOATING
C5753 a_1178_6217.t2 VSS 0.08417f $ **FLOATING
C5754 a_1178_6217.n0 VSS 0.26121f $ **FLOATING
C5755 a_3280_6293.t1 VSS 0.15436f $ **FLOATING
C5756 a_3280_6293.t2 VSS 0.77903f $ **FLOATING
C5757 a_3280_6293.n0 VSS 0.43794f $ **FLOATING
C5758 a_3280_6293.t0 VSS 0.2341f $ **FLOATING
C5759 a_3508_6433.t0 VSS 0.10822f $ **FLOATING
C5760 a_3508_6433.t1 VSS 0.10901f $ **FLOATING
C5761 a_3508_6433.n0 VSS 0.47419f $ **FLOATING
C5762 a_3508_6433.t2 VSS 0.2173f $ **FLOATING
C5763 a_4081_6494.t0 VSS 0.08657f $ **FLOATING
C5764 a_4081_6494.t2 VSS 0.28688f $ **FLOATING
C5765 a_4081_6494.t1 VSS 0.13811f $ **FLOATING
C5766 a_4081_6494.n0 VSS 0.32463f $ **FLOATING
C5767 a_7105_6594.t0 VSS 0.08911f $ **FLOATING
C5768 a_7105_6594.t2 VSS 0.29919f $ **FLOATING
C5769 a_7105_6594.t1 VSS 0.13972f $ **FLOATING
C5770 a_7105_6594.n0 VSS 0.3719f $ **FLOATING
C5771 a_2310_6229.t0 VSS 0.38743f $ **FLOATING
C5772 a_2310_6229.t1 VSS 0.44582f $ **FLOATING
C5773 a_3186_6293.t0 VSS 0.37124f $ **FLOATING
C5774 a_3186_6293.t1 VSS 0.37257f $ **FLOATING
C5775 a_5169_6290.t3 VSS 0.07442f $ **FLOATING
C5776 a_5169_6290.t6 VSS 0.07442f $ **FLOATING
C5777 a_5169_6290.n0 VSS 0.12557f $ **FLOATING
C5778 a_5169_6290.t2 VSS 0.07442f $ **FLOATING
C5779 a_5169_6290.t7 VSS 0.07442f $ **FLOATING
C5780 a_5169_6290.n1 VSS 0.16113f $ **FLOATING
C5781 a_5169_6290.t1 VSS 0.07442f $ **FLOATING
C5782 a_5169_6290.t5 VSS 0.07442f $ **FLOATING
C5783 a_5169_6290.n2 VSS 0.16113f $ **FLOATING
C5784 a_5169_6290.t0 VSS 0.07442f $ **FLOATING
C5785 a_5169_6290.t4 VSS 0.07442f $ **FLOATING
C5786 a_5169_6290.n3 VSS 0.12557f $ **FLOATING
C5787 a_7199_6594.t0 VSS 0.03717f $ **FLOATING
C5788 a_7410_6198.t0 VSS 0.13386f $ **FLOATING
C5789 a_7410_6198.t1 VSS 0.20629f $ **FLOATING
C5790 a_7410_6198.n0 VSS 0.57847f $ **FLOATING
C5791 a_7410_6198.t2 VSS 0.28249f $ **FLOATING
C5792 a_7799_6514.t0 VSS 0.16125f $ **FLOATING
C5793 a_7799_6514.t3 VSS 0.18474f $ **FLOATING
C5794 a_7799_6514.t1 VSS 0.25304f $ **FLOATING
C5795 a_7799_6514.t2 VSS 0.2522f $ **FLOATING
C5796 a_7799_6514.n0 VSS 0.39317f $ **FLOATING
C5797 a_7799_6514.n1 VSS 0.36109f $ **FLOATING
C5798 a_8515_6439.t0 VSS 0.14782f $ **FLOATING
C5799 a_8515_6439.t2 VSS 0.13656f $ **FLOATING
C5800 a_8515_6439.t3 VSS 0.31152f $ **FLOATING
C5801 a_8515_6439.n0 VSS 0.43698f $ **FLOATING
C5802 a_8515_6439.n1 VSS 0.34225f $ **FLOATING
C5803 a_8515_6439.t1 VSS 0.1463f $ **FLOATING
C5804 a_8255_6216.t0 VSS 0.18202f $ **FLOATING
C5805 a_8255_6216.t1 VSS 0.18302f $ **FLOATING
C5806 a_8255_6216.n0 VSS 0.98402f $ **FLOATING
C5807 a_8255_6216.t3 VSS 0.16375f $ **FLOATING
C5808 a_8255_6216.n1 VSS 1.06675f $ **FLOATING
C5809 a_8255_6216.t2 VSS 0.1696f $ **FLOATING
C5810 a_8541_6534.t0 VSS 0.19098f $ **FLOATING
C5811 a_8541_6534.t4 VSS 0.24655f $ **FLOATING
C5812 a_8541_6534.n0 VSS 0.50641f $ **FLOATING
C5813 a_8541_6534.t3 VSS 0.26879f $ **FLOATING
C5814 a_8541_6534.t2 VSS 0.27104f $ **FLOATING
C5815 a_8541_6534.n1 VSS 0.81586f $ **FLOATING
C5816 a_8541_6534.t1 VSS 0.27508f $ **FLOATING
C5817 a_8541_6534.n2 VSS 0.49491f $ **FLOATING
C5818 a_8950_6473.t0 VSS 0.15437f $ **FLOATING
C5819 a_8950_6473.t3 VSS 0.59901f $ **FLOATING
C5820 a_8950_6473.n0 VSS 0.31722f $ **FLOATING
C5821 a_8950_6473.t1 VSS 0.22591f $ **FLOATING
C5822 a_8950_6473.n1 VSS 0.17967f $ **FLOATING
C5823 a_8950_6473.t2 VSS 0.24984f $ **FLOATING
C5824 a_9052_6560.t0 VSS 0.19991f $ **FLOATING
C5825 a_9052_6560.t3 VSS 0.28161f $ **FLOATING
C5826 a_9052_6560.n0 VSS 0.6322f $ **FLOATING
C5827 a_9052_6560.t1 VSS 0.30382f $ **FLOATING
C5828 a_9052_6560.t2 VSS 0.27167f $ **FLOATING
C5829 a_9052_6560.n1 VSS 0.34018f $ **FLOATING
C5830 a_7698_6217.t1 VSS 0.08402f $ **FLOATING
C5831 a_7698_6217.n0 VSS 0.26076f $ **FLOATING
C5832 a_7698_6217.t0 VSS 0.09f $ **FLOATING
C5833 a_7698_6217.t2 VSS 0.09237f $ **FLOATING
C5834 a_9800_6293.t1 VSS 0.15436f $ **FLOATING
C5835 a_9800_6293.t2 VSS 0.77903f $ **FLOATING
C5836 a_9800_6293.n0 VSS 0.43794f $ **FLOATING
C5837 a_9800_6293.t0 VSS 0.2341f $ **FLOATING
C5838 a_10028_6433.t0 VSS 0.10901f $ **FLOATING
C5839 a_10028_6433.t2 VSS 0.2173f $ **FLOATING
C5840 a_10028_6433.t1 VSS 0.10822f $ **FLOATING
C5841 a_10028_6433.n0 VSS 0.47419f $ **FLOATING
C5842 a_10601_6494.t0 VSS 0.08657f $ **FLOATING
C5843 a_10601_6494.t2 VSS 0.28688f $ **FLOATING
C5844 a_10601_6494.t1 VSS 0.13811f $ **FLOATING
C5845 a_10601_6494.n0 VSS 0.32463f $ **FLOATING
C5846 a_13625_6594.t0 VSS 0.08923f $ **FLOATING
C5847 a_13625_6594.t2 VSS 0.2996f $ **FLOATING
C5848 a_13625_6594.t1 VSS 0.13991f $ **FLOATING
C5849 a_13625_6594.n0 VSS 0.37241f $ **FLOATING
C5850 a_8830_6229.t0 VSS 0.44581f $ **FLOATING
C5851 a_8830_6229.t1 VSS 0.38742f $ **FLOATING
C5852 a_9706_6293.t0 VSS 0.37124f $ **FLOATING
C5853 a_9706_6293.t1 VSS 0.37257f $ **FLOATING
C5854 a_11689_6290.t3 VSS 0.07443f $ **FLOATING
C5855 a_11689_6290.t6 VSS 0.07443f $ **FLOATING
C5856 a_11689_6290.n0 VSS 0.12558f $ **FLOATING
C5857 a_11689_6290.t2 VSS 0.07443f $ **FLOATING
C5858 a_11689_6290.t7 VSS 0.07443f $ **FLOATING
C5859 a_11689_6290.n1 VSS 0.16114f $ **FLOATING
C5860 a_11689_6290.t1 VSS 0.07443f $ **FLOATING
C5861 a_11689_6290.t5 VSS 0.07443f $ **FLOATING
C5862 a_11689_6290.n2 VSS 0.16114f $ **FLOATING
C5863 a_11689_6290.t0 VSS 0.07443f $ **FLOATING
C5864 a_11689_6290.t4 VSS 0.07443f $ **FLOATING
C5865 a_11689_6290.n3 VSS 0.12558f $ **FLOATING
C5866 a_13719_6594.t0 VSS 0.0372f $ **FLOATING
C5867 a_13930_6198.t0 VSS 0.13402f $ **FLOATING
C5868 a_13930_6198.t1 VSS 0.20653f $ **FLOATING
C5869 a_13930_6198.n0 VSS 0.57914f $ **FLOATING
C5870 a_13930_6198.t2 VSS 0.28282f $ **FLOATING
C5871 a_14319_6514.t1 VSS 0.16102f $ **FLOATING
C5872 a_14319_6514.t3 VSS 0.18448f $ **FLOATING
C5873 a_14319_6514.t0 VSS 0.25268f $ **FLOATING
C5874 a_14319_6514.t2 VSS 0.25184f $ **FLOATING
C5875 a_14319_6514.n0 VSS 0.39262f $ **FLOATING
C5876 a_14319_6514.n1 VSS 0.36058f $ **FLOATING
C5877 a_15035_6439.t0 VSS 0.14781f $ **FLOATING
C5878 a_15035_6439.t2 VSS 0.13656f $ **FLOATING
C5879 a_15035_6439.t3 VSS 0.3115f $ **FLOATING
C5880 a_15035_6439.n0 VSS 0.43696f $ **FLOATING
C5881 a_15035_6439.n1 VSS 0.34223f $ **FLOATING
C5882 a_15035_6439.t1 VSS 0.14629f $ **FLOATING
C5883 a_14775_6216.t0 VSS 0.182f $ **FLOATING
C5884 a_14775_6216.t1 VSS 0.183f $ **FLOATING
C5885 a_14775_6216.n0 VSS 0.98394f $ **FLOATING
C5886 a_14775_6216.t2 VSS 0.16374f $ **FLOATING
C5887 a_14775_6216.n1 VSS 1.06667f $ **FLOATING
C5888 a_14775_6216.t3 VSS 0.16959f $ **FLOATING
C5889 a_15061_6534.t0 VSS 0.19097f $ **FLOATING
C5890 a_15061_6534.t4 VSS 0.24653f $ **FLOATING
C5891 a_15061_6534.n0 VSS 0.50638f $ **FLOATING
C5892 a_15061_6534.t2 VSS 0.26877f $ **FLOATING
C5893 a_15061_6534.t3 VSS 0.27102f $ **FLOATING
C5894 a_15061_6534.n1 VSS 0.81582f $ **FLOATING
C5895 a_15061_6534.t1 VSS 0.27506f $ **FLOATING
C5896 a_15061_6534.n2 VSS 0.49488f $ **FLOATING
C5897 a_15470_6473.t0 VSS 0.15436f $ **FLOATING
C5898 a_15470_6473.t3 VSS 0.59896f $ **FLOATING
C5899 a_15470_6473.n0 VSS 0.3172f $ **FLOATING
C5900 a_15470_6473.t1 VSS 0.22589f $ **FLOATING
C5901 a_15470_6473.n1 VSS 0.17966f $ **FLOATING
C5902 a_15470_6473.t2 VSS 0.24982f $ **FLOATING
C5903 a_15572_6560.t0 VSS 0.19991f $ **FLOATING
C5904 a_15572_6560.t3 VSS 0.2816f $ **FLOATING
C5905 a_15572_6560.n0 VSS 0.63219f $ **FLOATING
C5906 a_15572_6560.t1 VSS 0.30382f $ **FLOATING
C5907 a_15572_6560.t2 VSS 0.27166f $ **FLOATING
C5908 a_15572_6560.n1 VSS 0.34018f $ **FLOATING
C5909 a_14218_6217.t1 VSS 0.08389f $ **FLOATING
C5910 a_14218_6217.n0 VSS 0.26036f $ **FLOATING
C5911 a_14218_6217.t0 VSS 0.08986f $ **FLOATING
C5912 a_14218_6217.t2 VSS 0.09223f $ **FLOATING
C5913 a_16320_6293.t1 VSS 0.15436f $ **FLOATING
C5914 a_16320_6293.t2 VSS 0.77903f $ **FLOATING
C5915 a_16320_6293.n0 VSS 0.43794f $ **FLOATING
C5916 a_16320_6293.t0 VSS 0.2341f $ **FLOATING
C5917 a_16548_6433.t0 VSS 0.10822f $ **FLOATING
C5918 a_16548_6433.t1 VSS 0.10901f $ **FLOATING
C5919 a_16548_6433.n0 VSS 0.47419f $ **FLOATING
C5920 a_16548_6433.t2 VSS 0.2173f $ **FLOATING
C5921 a_17121_6494.t0 VSS 0.08657f $ **FLOATING
C5922 a_17121_6494.t2 VSS 0.28688f $ **FLOATING
C5923 a_17121_6494.t1 VSS 0.13811f $ **FLOATING
C5924 a_17121_6494.n0 VSS 0.32463f $ **FLOATING
C5925 a_20145_6594.t0 VSS 0.08909f $ **FLOATING
C5926 a_20145_6594.t2 VSS 0.29913f $ **FLOATING
C5927 a_20145_6594.t1 VSS 0.13969f $ **FLOATING
C5928 a_20145_6594.n0 VSS 0.37182f $ **FLOATING
C5929 a_15350_6229.t0 VSS 0.44579f $ **FLOATING
C5930 a_15350_6229.t1 VSS 0.38741f $ **FLOATING
C5931 a_16226_6293.t0 VSS 0.37124f $ **FLOATING
C5932 a_16226_6293.t1 VSS 0.37257f $ **FLOATING
C5933 a_18209_6290.t3 VSS 0.07442f $ **FLOATING
C5934 a_18209_6290.t6 VSS 0.07442f $ **FLOATING
C5935 a_18209_6290.n0 VSS 0.12557f $ **FLOATING
C5936 a_18209_6290.t2 VSS 0.07442f $ **FLOATING
C5937 a_18209_6290.t7 VSS 0.07442f $ **FLOATING
C5938 a_18209_6290.n1 VSS 0.16113f $ **FLOATING
C5939 a_18209_6290.t1 VSS 0.07442f $ **FLOATING
C5940 a_18209_6290.t5 VSS 0.07442f $ **FLOATING
C5941 a_18209_6290.n2 VSS 0.16113f $ **FLOATING
C5942 a_18209_6290.t0 VSS 0.07442f $ **FLOATING
C5943 a_18209_6290.t4 VSS 0.07442f $ **FLOATING
C5944 a_18209_6290.n3 VSS 0.12557f $ **FLOATING
C5945 a_20239_6594.t0 VSS 0.03716f $ **FLOATING
C5946 a_20450_6198.t0 VSS 0.13382f $ **FLOATING
C5947 a_20450_6198.t1 VSS 0.20622f $ **FLOATING
C5948 a_20450_6198.n0 VSS 0.57828f $ **FLOATING
C5949 a_20450_6198.t2 VSS 0.2824f $ **FLOATING
C5950 a_20839_6514.t0 VSS 0.16136f $ **FLOATING
C5951 a_20839_6514.t3 VSS 0.18487f $ **FLOATING
C5952 a_20839_6514.t1 VSS 0.25321f $ **FLOATING
C5953 a_20839_6514.t2 VSS 0.25238f $ **FLOATING
C5954 a_20839_6514.n0 VSS 0.39345f $ **FLOATING
C5955 a_20839_6514.n1 VSS 0.36134f $ **FLOATING
C5956 a_21555_6439.t0 VSS 0.14783f $ **FLOATING
C5957 a_21555_6439.t2 VSS 0.13657f $ **FLOATING
C5958 a_21555_6439.t3 VSS 0.31153f $ **FLOATING
C5959 a_21555_6439.n0 VSS 0.43699f $ **FLOATING
C5960 a_21555_6439.n1 VSS 0.34226f $ **FLOATING
C5961 a_21555_6439.t1 VSS 0.1463f $ **FLOATING
C5962 a_21295_6216.t0 VSS 0.18202f $ **FLOATING
C5963 a_21295_6216.t1 VSS 0.18302f $ **FLOATING
C5964 a_21295_6216.n0 VSS 0.98405f $ **FLOATING
C5965 a_21295_6216.t2 VSS 0.16376f $ **FLOATING
C5966 a_21295_6216.n1 VSS 1.06679f $ **FLOATING
C5967 a_21295_6216.t3 VSS 0.1696f $ **FLOATING
C5968 a_21581_6534.t0 VSS 0.19099f $ **FLOATING
C5969 a_21581_6534.t4 VSS 0.24655f $ **FLOATING
C5970 a_21581_6534.n0 VSS 0.50643f $ **FLOATING
C5971 a_21581_6534.t2 VSS 0.2688f $ **FLOATING
C5972 a_21581_6534.t3 VSS 0.27104f $ **FLOATING
C5973 a_21581_6534.n1 VSS 0.81589f $ **FLOATING
C5974 a_21581_6534.t1 VSS 0.27508f $ **FLOATING
C5975 a_21581_6534.n2 VSS 0.49493f $ **FLOATING
C5976 a_21990_6473.t0 VSS 0.15437f $ **FLOATING
C5977 a_21990_6473.t3 VSS 0.59902f $ **FLOATING
C5978 a_21990_6473.n0 VSS 0.31723f $ **FLOATING
C5979 a_21990_6473.t1 VSS 0.22591f $ **FLOATING
C5980 a_21990_6473.n1 VSS 0.17967f $ **FLOATING
C5981 a_21990_6473.t2 VSS 0.24985f $ **FLOATING
C5982 a_22092_6560.t0 VSS 0.19991f $ **FLOATING
C5983 a_22092_6560.t3 VSS 0.28161f $ **FLOATING
C5984 a_22092_6560.n0 VSS 0.63221f $ **FLOATING
C5985 a_22092_6560.t1 VSS 0.30383f $ **FLOATING
C5986 a_22092_6560.t2 VSS 0.27167f $ **FLOATING
C5987 a_22092_6560.n1 VSS 0.34019f $ **FLOATING
C5988 a_20738_6217.t1 VSS 0.08409f $ **FLOATING
C5989 a_20738_6217.n0 VSS 0.26096f $ **FLOATING
C5990 a_20738_6217.t0 VSS 0.09007f $ **FLOATING
C5991 a_20738_6217.t2 VSS 0.09245f $ **FLOATING
C5992 a_22840_6293.t1 VSS 0.15436f $ **FLOATING
C5993 a_22840_6293.t2 VSS 0.77903f $ **FLOATING
C5994 a_22840_6293.n0 VSS 0.43794f $ **FLOATING
C5995 a_22840_6293.t0 VSS 0.2341f $ **FLOATING
C5996 a_23068_6433.t0 VSS 0.10822f $ **FLOATING
C5997 a_23068_6433.t1 VSS 0.10901f $ **FLOATING
C5998 a_23068_6433.n0 VSS 0.47419f $ **FLOATING
C5999 a_23068_6433.t2 VSS 0.2173f $ **FLOATING
C6000 a_23641_6494.t0 VSS 0.08657f $ **FLOATING
C6001 a_23641_6494.t2 VSS 0.28688f $ **FLOATING
C6002 a_23641_6494.t1 VSS 0.13811f $ **FLOATING
C6003 a_23641_6494.n0 VSS 0.32463f $ **FLOATING
C6004 a_26665_6594.t0 VSS 0.08913f $ **FLOATING
C6005 a_26665_6594.t2 VSS 0.29926f $ **FLOATING
C6006 a_26665_6594.t1 VSS 0.13975f $ **FLOATING
C6007 a_26665_6594.n0 VSS 0.37199f $ **FLOATING
C6008 a_21870_6229.t0 VSS 0.44581f $ **FLOATING
C6009 a_21870_6229.t1 VSS 0.38743f $ **FLOATING
C6010 a_22746_6293.t0 VSS 0.37124f $ **FLOATING
C6011 a_22746_6293.t1 VSS 0.37257f $ **FLOATING
C6012 a_24729_6290.t3 VSS 0.07443f $ **FLOATING
C6013 a_24729_6290.t6 VSS 0.07442f $ **FLOATING
C6014 a_24729_6290.n0 VSS 0.12557f $ **FLOATING
C6015 a_24729_6290.t2 VSS 0.07443f $ **FLOATING
C6016 a_24729_6290.t7 VSS 0.07442f $ **FLOATING
C6017 a_24729_6290.n1 VSS 0.16114f $ **FLOATING
C6018 a_24729_6290.t1 VSS 0.07443f $ **FLOATING
C6019 a_24729_6290.t5 VSS 0.07442f $ **FLOATING
C6020 a_24729_6290.n2 VSS 0.16114f $ **FLOATING
C6021 a_24729_6290.t0 VSS 0.07443f $ **FLOATING
C6022 a_24729_6290.t4 VSS 0.07443f $ **FLOATING
C6023 a_24729_6290.n3 VSS 0.12557f $ **FLOATING
C6024 a_26759_6594.t0 VSS 0.03718f $ **FLOATING
C6025 a_26970_6198.t0 VSS 0.13394f $ **FLOATING
C6026 a_26970_6198.t1 VSS 0.20641f $ **FLOATING
C6027 a_26970_6198.n0 VSS 0.57881f $ **FLOATING
C6028 a_26970_6198.t2 VSS 0.28266f $ **FLOATING
C6029 a_27359_6514.t1 VSS 0.16114f $ **FLOATING
C6030 a_27359_6514.t3 VSS 0.18461f $ **FLOATING
C6031 a_27359_6514.t0 VSS 0.25286f $ **FLOATING
C6032 a_27359_6514.t2 VSS 0.25202f $ **FLOATING
C6033 a_27359_6514.n0 VSS 0.3929f $ **FLOATING
C6034 a_27359_6514.n1 VSS 0.36084f $ **FLOATING
C6035 a_28075_6439.t0 VSS 0.14629f $ **FLOATING
C6036 a_28075_6439.t1 VSS 0.14782f $ **FLOATING
C6037 a_28075_6439.t2 VSS 0.13656f $ **FLOATING
C6038 a_28075_6439.t3 VSS 0.31151f $ **FLOATING
C6039 a_28075_6439.n0 VSS 0.43697f $ **FLOATING
C6040 a_28075_6439.n1 VSS 0.34224f $ **FLOATING
C6041 a_27815_6216.t0 VSS 0.18201f $ **FLOATING
C6042 a_27815_6216.t1 VSS 0.18301f $ **FLOATING
C6043 a_27815_6216.n0 VSS 0.98398f $ **FLOATING
C6044 a_27815_6216.t3 VSS 0.16375f $ **FLOATING
C6045 a_27815_6216.n1 VSS 1.06671f $ **FLOATING
C6046 a_27815_6216.t2 VSS 0.16959f $ **FLOATING
C6047 a_28101_6534.t0 VSS 0.19098f $ **FLOATING
C6048 a_28101_6534.t4 VSS 0.24654f $ **FLOATING
C6049 a_28101_6534.n0 VSS 0.5064f $ **FLOATING
C6050 a_28101_6534.t3 VSS 0.26878f $ **FLOATING
C6051 a_28101_6534.t2 VSS 0.27103f $ **FLOATING
C6052 a_28101_6534.n1 VSS 0.81584f $ **FLOATING
C6053 a_28101_6534.t1 VSS 0.27507f $ **FLOATING
C6054 a_28101_6534.n2 VSS 0.4949f $ **FLOATING
C6055 a_28510_6473.t0 VSS 0.15436f $ **FLOATING
C6056 a_28510_6473.t3 VSS 0.59898f $ **FLOATING
C6057 a_28510_6473.n0 VSS 0.31721f $ **FLOATING
C6058 a_28510_6473.t1 VSS 0.2259f $ **FLOATING
C6059 a_28510_6473.n1 VSS 0.17966f $ **FLOATING
C6060 a_28510_6473.t2 VSS 0.24983f $ **FLOATING
C6061 a_28612_6560.t0 VSS 0.19991f $ **FLOATING
C6062 a_28612_6560.t3 VSS 0.2816f $ **FLOATING
C6063 a_28612_6560.n0 VSS 0.63219f $ **FLOATING
C6064 a_28612_6560.t1 VSS 0.30382f $ **FLOATING
C6065 a_28612_6560.t2 VSS 0.27167f $ **FLOATING
C6066 a_28612_6560.n1 VSS 0.34018f $ **FLOATING
C6067 a_27258_6217.t1 VSS 0.08397f $ **FLOATING
C6068 a_27258_6217.n0 VSS 0.26059f $ **FLOATING
C6069 a_27258_6217.t0 VSS 0.08994f $ **FLOATING
C6070 a_27258_6217.t2 VSS 0.09232f $ **FLOATING
C6071 a_29360_6293.t1 VSS 0.15436f $ **FLOATING
C6072 a_29360_6293.t2 VSS 0.77903f $ **FLOATING
C6073 a_29360_6293.n0 VSS 0.43794f $ **FLOATING
C6074 a_29360_6293.t0 VSS 0.2341f $ **FLOATING
C6075 a_29588_6433.t0 VSS 0.10901f $ **FLOATING
C6076 a_29588_6433.t2 VSS 0.2173f $ **FLOATING
C6077 a_29588_6433.t1 VSS 0.10822f $ **FLOATING
C6078 a_29588_6433.n0 VSS 0.47419f $ **FLOATING
C6079 a_30161_6494.t0 VSS 0.08657f $ **FLOATING
C6080 a_30161_6494.t2 VSS 0.28688f $ **FLOATING
C6081 a_30161_6494.t1 VSS 0.13811f $ **FLOATING
C6082 a_30161_6494.n0 VSS 0.32463f $ **FLOATING
C6083 a_33185_6594.t0 VSS 0.08902f $ **FLOATING
C6084 a_33185_6594.t2 VSS 0.2989f $ **FLOATING
C6085 a_33185_6594.t1 VSS 0.13958f $ **FLOATING
C6086 a_33185_6594.n0 VSS 0.37154f $ **FLOATING
C6087 a_28390_6229.t0 VSS 0.4458f $ **FLOATING
C6088 a_28390_6229.t1 VSS 0.38742f $ **FLOATING
C6089 a_29266_6293.t0 VSS 0.37124f $ **FLOATING
C6090 a_29266_6293.t1 VSS 0.37257f $ **FLOATING
C6091 a_31249_6290.t3 VSS 0.07442f $ **FLOATING
C6092 a_31249_6290.t6 VSS 0.07442f $ **FLOATING
C6093 a_31249_6290.n0 VSS 0.12556f $ **FLOATING
C6094 a_31249_6290.t2 VSS 0.07442f $ **FLOATING
C6095 a_31249_6290.t7 VSS 0.07442f $ **FLOATING
C6096 a_31249_6290.n1 VSS 0.16112f $ **FLOATING
C6097 a_31249_6290.t1 VSS 0.07442f $ **FLOATING
C6098 a_31249_6290.t5 VSS 0.07442f $ **FLOATING
C6099 a_31249_6290.n2 VSS 0.16112f $ **FLOATING
C6100 a_31249_6290.t0 VSS 0.07442f $ **FLOATING
C6101 a_31249_6290.t4 VSS 0.07442f $ **FLOATING
C6102 a_31249_6290.n3 VSS 0.12556f $ **FLOATING
C6103 a_33279_6594.t0 VSS 0.03712f $ **FLOATING
C6104 a_33490_6198.t0 VSS 0.13421f $ **FLOATING
C6105 a_33490_6198.t1 VSS 0.20682f $ **FLOATING
C6106 a_33490_6198.n0 VSS 0.57996f $ **FLOATING
C6107 a_33490_6198.t2 VSS 0.28322f $ **FLOATING
C6108 a_33879_6514.t0 VSS 0.16198f $ **FLOATING
C6109 a_33879_6514.t3 VSS 0.18557f $ **FLOATING
C6110 a_33879_6514.t1 VSS 0.25418f $ **FLOATING
C6111 a_33879_6514.t2 VSS 0.25334f $ **FLOATING
C6112 a_33879_6514.n0 VSS 0.39495f $ **FLOATING
C6113 a_33879_6514.n1 VSS 0.36273f $ **FLOATING
C6114 a_34595_6439.t0 VSS 0.14784f $ **FLOATING
C6115 a_34595_6439.t2 VSS 0.13658f $ **FLOATING
C6116 a_34595_6439.t3 VSS 0.31156f $ **FLOATING
C6117 a_34595_6439.n0 VSS 0.43705f $ **FLOATING
C6118 a_34595_6439.n1 VSS 0.3423f $ **FLOATING
C6119 a_34595_6439.t1 VSS 0.14632f $ **FLOATING
C6120 a_34335_6216.t0 VSS 0.18205f $ **FLOATING
C6121 a_34335_6216.t1 VSS 0.18305f $ **FLOATING
C6122 a_34335_6216.n0 VSS 0.98421f $ **FLOATING
C6123 a_34335_6216.t3 VSS 0.16378f $ **FLOATING
C6124 a_34335_6216.n1 VSS 1.06696f $ **FLOATING
C6125 a_34335_6216.t2 VSS 0.16963f $ **FLOATING
C6126 a_34621_6534.t0 VSS 0.19101f $ **FLOATING
C6127 a_34621_6534.t4 VSS 0.24658f $ **FLOATING
C6128 a_34621_6534.n0 VSS 0.50649f $ **FLOATING
C6129 a_34621_6534.t3 VSS 0.26883f $ **FLOATING
C6130 a_34621_6534.t2 VSS 0.27108f $ **FLOATING
C6131 a_34621_6534.n1 VSS 0.81599f $ **FLOATING
C6132 a_34621_6534.t1 VSS 0.27512f $ **FLOATING
C6133 a_34621_6534.n2 VSS 0.49499f $ **FLOATING
C6134 a_35030_6473.t0 VSS 0.15438f $ **FLOATING
C6135 a_35030_6473.t3 VSS 0.59906f $ **FLOATING
C6136 a_35030_6473.n0 VSS 0.31725f $ **FLOATING
C6137 a_35030_6473.t1 VSS 0.22593f $ **FLOATING
C6138 a_35030_6473.n1 VSS 0.17969f $ **FLOATING
C6139 a_35030_6473.t2 VSS 0.24986f $ **FLOATING
C6140 a_35132_6560.t0 VSS 0.19992f $ **FLOATING
C6141 a_35132_6560.t3 VSS 0.28162f $ **FLOATING
C6142 a_35132_6560.n0 VSS 0.63224f $ **FLOATING
C6143 a_35132_6560.t1 VSS 0.30384f $ **FLOATING
C6144 a_35132_6560.t2 VSS 0.27168f $ **FLOATING
C6145 a_35132_6560.n1 VSS 0.3402f $ **FLOATING
C6146 a_33778_6217.t1 VSS 0.08456f $ **FLOATING
C6147 a_33778_6217.n0 VSS 0.26242f $ **FLOATING
C6148 a_33778_6217.t0 VSS 0.09057f $ **FLOATING
C6149 a_33778_6217.t2 VSS 0.09296f $ **FLOATING
C6150 a_35880_6293.t1 VSS 0.15436f $ **FLOATING
C6151 a_35880_6293.t2 VSS 0.77903f $ **FLOATING
C6152 a_35880_6293.n0 VSS 0.43794f $ **FLOATING
C6153 a_35880_6293.t0 VSS 0.2341f $ **FLOATING
C6154 a_36108_6433.t0 VSS 0.10822f $ **FLOATING
C6155 a_36108_6433.t1 VSS 0.10901f $ **FLOATING
C6156 a_36108_6433.n0 VSS 0.47419f $ **FLOATING
C6157 a_36108_6433.t2 VSS 0.2173f $ **FLOATING
C6158 a_36681_6494.t0 VSS 0.08657f $ **FLOATING
C6159 a_36681_6494.t2 VSS 0.28688f $ **FLOATING
C6160 a_36681_6494.t1 VSS 0.13811f $ **FLOATING
C6161 a_36681_6494.n0 VSS 0.32463f $ **FLOATING
C6162 a_39705_6594.t0 VSS 0.08905f $ **FLOATING
C6163 a_39705_6594.t2 VSS 0.29902f $ **FLOATING
C6164 a_39705_6594.t1 VSS 0.13963f $ **FLOATING
C6165 a_39705_6594.n0 VSS 0.37168f $ **FLOATING
C6166 a_34910_6229.t0 VSS 0.44584f $ **FLOATING
C6167 a_34910_6229.t1 VSS 0.38745f $ **FLOATING
C6168 a_35786_6293.t0 VSS 0.37124f $ **FLOATING
C6169 a_35786_6293.t1 VSS 0.37257f $ **FLOATING
C6170 a_37769_6290.t3 VSS 0.07442f $ **FLOATING
C6171 a_37769_6290.t6 VSS 0.07442f $ **FLOATING
C6172 a_37769_6290.n0 VSS 0.12557f $ **FLOATING
C6173 a_37769_6290.t2 VSS 0.07442f $ **FLOATING
C6174 a_37769_6290.t7 VSS 0.07442f $ **FLOATING
C6175 a_37769_6290.n1 VSS 0.16113f $ **FLOATING
C6176 a_37769_6290.t1 VSS 0.07442f $ **FLOATING
C6177 a_37769_6290.t5 VSS 0.07442f $ **FLOATING
C6178 a_37769_6290.n2 VSS 0.16113f $ **FLOATING
C6179 a_37769_6290.t0 VSS 0.07442f $ **FLOATING
C6180 a_37769_6290.t4 VSS 0.07442f $ **FLOATING
C6181 a_37769_6290.n3 VSS 0.12557f $ **FLOATING
C6182 a_39799_6594.t0 VSS 0.03714f $ **FLOATING
C6183 a_40010_6198.t0 VSS 0.13399f $ **FLOATING
C6184 a_40010_6198.t1 VSS 0.20648f $ **FLOATING
C6185 a_40010_6198.n0 VSS 0.57902f $ **FLOATING
C6186 a_40010_6198.t2 VSS 0.28276f $ **FLOATING
C6187 a_40399_6514.t0 VSS 0.16162f $ **FLOATING
C6188 a_40399_6514.t3 VSS 0.18516f $ **FLOATING
C6189 a_40399_6514.t1 VSS 0.25362f $ **FLOATING
C6190 a_40399_6514.t2 VSS 0.25278f $ **FLOATING
C6191 a_40399_6514.n0 VSS 0.39408f $ **FLOATING
C6192 a_40399_6514.n1 VSS 0.36193f $ **FLOATING
C6193 a_41115_6439.t0 VSS 0.14631f $ **FLOATING
C6194 a_41115_6439.t1 VSS 0.14783f $ **FLOATING
C6195 a_41115_6439.t2 VSS 0.13658f $ **FLOATING
C6196 a_41115_6439.t3 VSS 0.31154f $ **FLOATING
C6197 a_41115_6439.n0 VSS 0.43702f $ **FLOATING
C6198 a_41115_6439.n1 VSS 0.34228f $ **FLOATING
C6199 a_40855_6216.t0 VSS 0.18204f $ **FLOATING
C6200 a_40855_6216.t1 VSS 0.18304f $ **FLOATING
C6201 a_40855_6216.n0 VSS 0.98413f $ **FLOATING
C6202 a_40855_6216.t3 VSS 0.16377f $ **FLOATING
C6203 a_40855_6216.n1 VSS 1.06687f $ **FLOATING
C6204 a_40855_6216.t2 VSS 0.16962f $ **FLOATING
C6205 a_41141_6534.t0 VSS 0.191f $ **FLOATING
C6206 a_41141_6534.t4 VSS 0.24657f $ **FLOATING
C6207 a_41141_6534.n0 VSS 0.50646f $ **FLOATING
C6208 a_41141_6534.t3 VSS 0.26881f $ **FLOATING
C6209 a_41141_6534.t2 VSS 0.27106f $ **FLOATING
C6210 a_41141_6534.n1 VSS 0.81594f $ **FLOATING
C6211 a_41141_6534.t1 VSS 0.2751f $ **FLOATING
C6212 a_41141_6534.n2 VSS 0.49496f $ **FLOATING
C6213 a_41550_6473.t0 VSS 0.15438f $ **FLOATING
C6214 a_41550_6473.t3 VSS 0.59904f $ **FLOATING
C6215 a_41550_6473.n0 VSS 0.31724f $ **FLOATING
C6216 a_41550_6473.t1 VSS 0.22592f $ **FLOATING
C6217 a_41550_6473.n1 VSS 0.17968f $ **FLOATING
C6218 a_41550_6473.t2 VSS 0.24985f $ **FLOATING
C6219 a_41652_6560.t0 VSS 0.19992f $ **FLOATING
C6220 a_41652_6560.t3 VSS 0.28161f $ **FLOATING
C6221 a_41652_6560.n0 VSS 0.63222f $ **FLOATING
C6222 a_41652_6560.t1 VSS 0.30383f $ **FLOATING
C6223 a_41652_6560.t2 VSS 0.27168f $ **FLOATING
C6224 a_41652_6560.n1 VSS 0.3402f $ **FLOATING
C6225 a_40298_6217.t1 VSS 0.08429f $ **FLOATING
C6226 a_40298_6217.n0 VSS 0.2616f $ **FLOATING
C6227 a_40298_6217.t0 VSS 0.09028f $ **FLOATING
C6228 a_40298_6217.t2 VSS 0.09267f $ **FLOATING
C6229 a_42400_6293.t1 VSS 0.15436f $ **FLOATING
C6230 a_42400_6293.t2 VSS 0.77903f $ **FLOATING
C6231 a_42400_6293.n0 VSS 0.43794f $ **FLOATING
C6232 a_42400_6293.t0 VSS 0.2341f $ **FLOATING
C6233 a_42628_6433.t0 VSS 0.10822f $ **FLOATING
C6234 a_42628_6433.t1 VSS 0.10901f $ **FLOATING
C6235 a_42628_6433.n0 VSS 0.47419f $ **FLOATING
C6236 a_42628_6433.t2 VSS 0.2173f $ **FLOATING
C6237 a_43201_6494.t0 VSS 0.08657f $ **FLOATING
C6238 a_43201_6494.t2 VSS 0.28688f $ **FLOATING
C6239 a_43201_6494.t1 VSS 0.13811f $ **FLOATING
C6240 a_43201_6494.n0 VSS 0.32463f $ **FLOATING
C6241 a_46225_6594.t0 VSS 0.06994f $ **FLOATING
C6242 a_46225_6594.t2 VSS 0.23484f $ **FLOATING
C6243 a_46225_6594.t1 VSS 0.10966f $ **FLOATING
C6244 a_46225_6594.n0 VSS 0.29191f $ **FLOATING
C6245 a_41430_6229.t0 VSS 0.44583f $ **FLOATING
C6246 a_41430_6229.t1 VSS 0.38744f $ **FLOATING
C6247 a_42306_6293.t0 VSS 0.37124f $ **FLOATING
C6248 a_42306_6293.t1 VSS 0.37257f $ **FLOATING
C6249 a_44289_6290.t3 VSS 0.07416f $ **FLOATING
C6250 a_44289_6290.t6 VSS 0.07416f $ **FLOATING
C6251 a_44289_6290.n0 VSS 0.12512f $ **FLOATING
C6252 a_44289_6290.t2 VSS 0.07416f $ **FLOATING
C6253 a_44289_6290.t7 VSS 0.07416f $ **FLOATING
C6254 a_44289_6290.n1 VSS 0.16056f $ **FLOATING
C6255 a_44289_6290.t1 VSS 0.07416f $ **FLOATING
C6256 a_44289_6290.t5 VSS 0.07416f $ **FLOATING
C6257 a_44289_6290.n2 VSS 0.16056f $ **FLOATING
C6258 a_44289_6290.t0 VSS 0.07416f $ **FLOATING
C6259 a_44289_6290.t4 VSS 0.07416f $ **FLOATING
C6260 a_44289_6290.n3 VSS 0.12512f $ **FLOATING
C6261 a_46530_6198.t0 VSS 0.13277f $ **FLOATING
C6262 a_46530_6198.t1 VSS 0.20461f $ **FLOATING
C6263 a_46530_6198.n0 VSS 0.57377f $ **FLOATING
C6264 a_46530_6198.t2 VSS 0.2802f $ **FLOATING
C6265 a_46919_6514.t1 VSS 0.16161f $ **FLOATING
C6266 a_46919_6514.t3 VSS 0.18515f $ **FLOATING
C6267 a_46919_6514.t0 VSS 0.2536f $ **FLOATING
C6268 a_46919_6514.t2 VSS 0.25276f $ **FLOATING
C6269 a_46919_6514.n0 VSS 0.39405f $ **FLOATING
C6270 a_46919_6514.n1 VSS 0.36189f $ **FLOATING
C6271 a_47635_6439.t0 VSS 0.14783f $ **FLOATING
C6272 a_47635_6439.t2 VSS 0.13658f $ **FLOATING
C6273 a_47635_6439.t3 VSS 0.31154f $ **FLOATING
C6274 a_47635_6439.n0 VSS 0.43702f $ **FLOATING
C6275 a_47635_6439.n1 VSS 0.34228f $ **FLOATING
C6276 a_47635_6439.t1 VSS 0.14631f $ **FLOATING
C6277 a_47375_6216.t0 VSS 0.18204f $ **FLOATING
C6278 a_47375_6216.t1 VSS 0.18304f $ **FLOATING
C6279 a_47375_6216.n0 VSS 0.98413f $ **FLOATING
C6280 a_47375_6216.t3 VSS 0.16377f $ **FLOATING
C6281 a_47375_6216.n1 VSS 1.06687f $ **FLOATING
C6282 a_47375_6216.t2 VSS 0.16962f $ **FLOATING
C6283 a_47661_6534.t0 VSS 0.191f $ **FLOATING
C6284 a_47661_6534.t4 VSS 0.24657f $ **FLOATING
C6285 a_47661_6534.n0 VSS 0.50646f $ **FLOATING
C6286 a_47661_6534.t3 VSS 0.26881f $ **FLOATING
C6287 a_47661_6534.t2 VSS 0.27106f $ **FLOATING
C6288 a_47661_6534.n1 VSS 0.81594f $ **FLOATING
C6289 a_47661_6534.t1 VSS 0.2751f $ **FLOATING
C6290 a_47661_6534.n2 VSS 0.49496f $ **FLOATING
C6291 a_48070_6473.t0 VSS 0.15438f $ **FLOATING
C6292 a_48070_6473.t3 VSS 0.59904f $ **FLOATING
C6293 a_48070_6473.n0 VSS 0.31724f $ **FLOATING
C6294 a_48070_6473.t1 VSS 0.22592f $ **FLOATING
C6295 a_48070_6473.n1 VSS 0.17968f $ **FLOATING
C6296 a_48070_6473.t2 VSS 0.24985f $ **FLOATING
C6297 a_48172_6560.t0 VSS 0.19992f $ **FLOATING
C6298 a_48172_6560.t3 VSS 0.28161f $ **FLOATING
C6299 a_48172_6560.n0 VSS 0.63222f $ **FLOATING
C6300 a_48172_6560.t1 VSS 0.30383f $ **FLOATING
C6301 a_48172_6560.t2 VSS 0.27168f $ **FLOATING
C6302 a_48172_6560.n1 VSS 0.3402f $ **FLOATING
C6303 a_46818_6217.t1 VSS 0.08413f $ **FLOATING
C6304 a_46818_6217.n0 VSS 0.2611f $ **FLOATING
C6305 a_46818_6217.t0 VSS 0.09011f $ **FLOATING
C6306 a_46818_6217.t2 VSS 0.0925f $ **FLOATING
C6307 a_48920_6293.t1 VSS 0.15436f $ **FLOATING
C6308 a_48920_6293.t2 VSS 0.77903f $ **FLOATING
C6309 a_48920_6293.n0 VSS 0.43794f $ **FLOATING
C6310 a_48920_6293.t0 VSS 0.2341f $ **FLOATING
C6311 a_49148_6433.t0 VSS 0.10822f $ **FLOATING
C6312 a_49148_6433.t1 VSS 0.10901f $ **FLOATING
C6313 a_49148_6433.n0 VSS 0.47419f $ **FLOATING
C6314 a_49148_6433.t2 VSS 0.2173f $ **FLOATING
C6315 a_49721_6494.t0 VSS 0.08657f $ **FLOATING
C6316 a_49721_6494.t2 VSS 0.28688f $ **FLOATING
C6317 a_49721_6494.t1 VSS 0.13811f $ **FLOATING
C6318 a_49721_6494.n0 VSS 0.32463f $ **FLOATING
C6319 a_47950_6229.t0 VSS 0.44583f $ **FLOATING
C6320 a_47950_6229.t1 VSS 0.38744f $ **FLOATING
C6321 a_48826_6293.t0 VSS 0.37124f $ **FLOATING
C6322 a_48826_6293.t1 VSS 0.37257f $ **FLOATING
C6323 a_50809_6290.t3 VSS 0.07411f $ **FLOATING
C6324 a_50809_6290.t6 VSS 0.07411f $ **FLOATING
C6325 a_50809_6290.n0 VSS 0.12504f $ **FLOATING
C6326 a_50809_6290.t2 VSS 0.07411f $ **FLOATING
C6327 a_50809_6290.t7 VSS 0.07411f $ **FLOATING
C6328 a_50809_6290.n1 VSS 0.16045f $ **FLOATING
C6329 a_50809_6290.t1 VSS 0.07411f $ **FLOATING
C6330 a_50809_6290.t5 VSS 0.07411f $ **FLOATING
C6331 a_50809_6290.n2 VSS 0.16045f $ **FLOATING
C6332 a_50809_6290.t0 VSS 0.07411f $ **FLOATING
C6333 a_50809_6290.t4 VSS 0.07411f $ **FLOATING
C6334 a_50809_6290.n3 VSS 0.12503f $ **FLOATING
C6335 a_n2946_4060.t0 VSS 0.12194f $ **FLOATING
C6336 a_n2946_4060.t2 VSS 0.40803f $ **FLOATING
C6337 a_n2946_4060.n0 VSS 0.46197f $ **FLOATING
C6338 a_n2946_4060.t1 VSS 0.17745f $ **FLOATING
C6339 a_n2648_4040.t0 VSS 0.14408f $ **FLOATING
C6340 a_n2648_4040.n0 VSS 0.60995f $ **FLOATING
C6341 a_n2648_4040.t2 VSS 0.29784f $ **FLOATING
C6342 a_n2648_4040.t1 VSS 0.22276f $ **FLOATING
C6343 a_n2342_4060.t1 VSS 0.11595f $ **FLOATING
C6344 a_n2342_4060.t2 VSS 0.38799f $ **FLOATING
C6345 a_n2342_4060.n0 VSS 0.43929f $ **FLOATING
C6346 a_n2342_4060.t0 VSS 0.16873f $ **FLOATING
C6347 a_3877_3694.t0 VSS 0.06998f $ **FLOATING
C6348 a_3877_3694.n0 VSS 0.73682f $ **FLOATING
C6349 a_3877_3694.t2 VSS 0.50729f $ **FLOATING
C6350 a_3877_3694.t1 VSS 0.11429f $ **FLOATING
C6351 a_10397_3694.t0 VSS 0.06998f $ **FLOATING
C6352 a_10397_3694.n0 VSS 0.73683f $ **FLOATING
C6353 a_10397_3694.t2 VSS 0.5073f $ **FLOATING
C6354 a_10397_3694.t1 VSS 0.1143f $ **FLOATING
C6355 a_4298_3714.t0 VSS 0.06223f $ **FLOATING
C6356 a_4298_3714.t1 VSS 0.1014f $ **FLOATING
C6357 a_4298_3714.n0 VSS 0.63914f $ **FLOATING
C6358 a_4298_3714.t2 VSS 0.27154f $ **FLOATING
C6359 a_16917_3694.t0 VSS 0.06988f $ **FLOATING
C6360 a_16917_3694.n0 VSS 0.73576f $ **FLOATING
C6361 a_16917_3694.t2 VSS 0.50657f $ **FLOATING
C6362 a_16917_3694.t1 VSS 0.11413f $ **FLOATING
C6363 a_10818_3714.t0 VSS 0.06223f $ **FLOATING
C6364 a_10818_3714.t1 VSS 0.1014f $ **FLOATING
C6365 a_10818_3714.n0 VSS 0.63914f $ **FLOATING
C6366 a_10818_3714.t2 VSS 0.27154f $ **FLOATING
C6367 a_23437_3694.t0 VSS 0.06988f $ **FLOATING
C6368 a_23437_3694.n0 VSS 0.73578f $ **FLOATING
C6369 a_23437_3694.t2 VSS 0.50658f $ **FLOATING
C6370 a_23437_3694.t1 VSS 0.11413f $ **FLOATING
C6371 a_17338_3714.t0 VSS 0.0622f $ **FLOATING
C6372 a_17338_3714.t1 VSS 0.10135f $ **FLOATING
C6373 a_17338_3714.n0 VSS 0.63887f $ **FLOATING
C6374 a_17338_3714.t2 VSS 0.27142f $ **FLOATING
C6375 a_29957_3694.t0 VSS 0.06987f $ **FLOATING
C6376 a_29957_3694.n0 VSS 0.73569f $ **FLOATING
C6377 a_29957_3694.t2 VSS 0.50651f $ **FLOATING
C6378 a_29957_3694.t1 VSS 0.11412f $ **FLOATING
C6379 a_23858_3714.t0 VSS 0.0622f $ **FLOATING
C6380 a_23858_3714.t1 VSS 0.10135f $ **FLOATING
C6381 a_23858_3714.n0 VSS 0.63887f $ **FLOATING
C6382 a_23858_3714.t2 VSS 0.27142f $ **FLOATING
C6383 a_36477_3694.t0 VSS 0.06987f $ **FLOATING
C6384 a_36477_3694.n0 VSS 0.73571f $ **FLOATING
C6385 a_36477_3694.t2 VSS 0.50653f $ **FLOATING
C6386 a_36477_3694.t1 VSS 0.11412f $ **FLOATING
C6387 a_30378_3714.t0 VSS 0.0622f $ **FLOATING
C6388 a_30378_3714.t1 VSS 0.10135f $ **FLOATING
C6389 a_30378_3714.n0 VSS 0.63887f $ **FLOATING
C6390 a_30378_3714.t2 VSS 0.27142f $ **FLOATING
C6391 a_42997_3694.t0 VSS 0.06991f $ **FLOATING
C6392 a_42997_3694.n0 VSS 0.73615f $ **FLOATING
C6393 a_42997_3694.t2 VSS 0.50683f $ **FLOATING
C6394 a_42997_3694.t1 VSS 0.11419f $ **FLOATING
C6395 a_36898_3714.t0 VSS 0.0622f $ **FLOATING
C6396 a_36898_3714.t1 VSS 0.10135f $ **FLOATING
C6397 a_36898_3714.n0 VSS 0.63887f $ **FLOATING
C6398 a_36898_3714.t2 VSS 0.27142f $ **FLOATING
C6399 a_49517_3694.t0 VSS 0.06986f $ **FLOATING
C6400 a_49517_3694.n0 VSS 0.73555f $ **FLOATING
C6401 a_49517_3694.t2 VSS 0.50642f $ **FLOATING
C6402 a_49517_3694.t1 VSS 0.1141f $ **FLOATING
C6403 a_43418_3714.t0 VSS 0.06221f $ **FLOATING
C6404 a_43418_3714.t1 VSS 0.10136f $ **FLOATING
C6405 a_43418_3714.n0 VSS 0.63894f $ **FLOATING
C6406 a_43418_3714.t2 VSS 0.27145f $ **FLOATING
C6407 a_49938_3714.t0 VSS 0.0622f $ **FLOATING
C6408 a_49938_3714.t1 VSS 0.10135f $ **FLOATING
C6409 a_49938_3714.n0 VSS 0.63886f $ **FLOATING
C6410 a_49938_3714.t2 VSS 0.27142f $ **FLOATING
C6411 a_5003_3750.t9 VSS 0.13119f $ **FLOATING
C6412 a_5003_3750.t8 VSS 0.13043f $ **FLOATING
C6413 a_5003_3750.n0 VSS 0.31977f $ **FLOATING
C6414 a_5003_3750.t6 VSS 0.10111f $ **FLOATING
C6415 a_5003_3750.n1 VSS 0.38936f $ **FLOATING
C6416 a_5003_3750.t4 VSS 0.09879f $ **FLOATING
C6417 a_5003_3750.n2 VSS 0.33887f $ **FLOATING
C6418 a_5003_3750.t0 VSS 0.11343f $ **FLOATING
C6419 a_5003_3750.t5 VSS 0.09879f $ **FLOATING
C6420 a_5003_3750.n3 VSS 0.33887f $ **FLOATING
C6421 a_5003_3750.t1 VSS 0.11343f $ **FLOATING
C6422 a_5003_3750.t2 VSS 0.14893f $ **FLOATING
C6423 a_5003_3750.t7 VSS 0.13119f $ **FLOATING
C6424 a_5003_3750.n4 VSS 0.35457f $ **FLOATING
C6425 a_5003_3750.t3 VSS 0.14893f $ **FLOATING
C6426 a_5003_3750.n5 VSS 0.35457f $ **FLOATING
C6427 a_11523_3750.t9 VSS 0.1312f $ **FLOATING
C6428 a_11523_3750.t8 VSS 0.13044f $ **FLOATING
C6429 a_11523_3750.n0 VSS 0.31979f $ **FLOATING
C6430 a_11523_3750.t6 VSS 0.10112f $ **FLOATING
C6431 a_11523_3750.n1 VSS 0.38937f $ **FLOATING
C6432 a_11523_3750.t4 VSS 0.09879f $ **FLOATING
C6433 a_11523_3750.n2 VSS 0.33888f $ **FLOATING
C6434 a_11523_3750.t0 VSS 0.11343f $ **FLOATING
C6435 a_11523_3750.t5 VSS 0.09879f $ **FLOATING
C6436 a_11523_3750.n3 VSS 0.33888f $ **FLOATING
C6437 a_11523_3750.t1 VSS 0.11343f $ **FLOATING
C6438 a_11523_3750.t2 VSS 0.14894f $ **FLOATING
C6439 a_11523_3750.t7 VSS 0.1312f $ **FLOATING
C6440 a_11523_3750.n4 VSS 0.35458f $ **FLOATING
C6441 a_11523_3750.t3 VSS 0.14894f $ **FLOATING
C6442 a_11523_3750.n5 VSS 0.35458f $ **FLOATING
C6443 a_18043_3750.t9 VSS 0.13121f $ **FLOATING
C6444 a_18043_3750.t8 VSS 0.13045f $ **FLOATING
C6445 a_18043_3750.n0 VSS 0.31982f $ **FLOATING
C6446 a_18043_3750.t6 VSS 0.10113f $ **FLOATING
C6447 a_18043_3750.n1 VSS 0.38941f $ **FLOATING
C6448 a_18043_3750.t4 VSS 0.0988f $ **FLOATING
C6449 a_18043_3750.n2 VSS 0.33891f $ **FLOATING
C6450 a_18043_3750.t0 VSS 0.11344f $ **FLOATING
C6451 a_18043_3750.t5 VSS 0.0988f $ **FLOATING
C6452 a_18043_3750.n3 VSS 0.33891f $ **FLOATING
C6453 a_18043_3750.t1 VSS 0.11344f $ **FLOATING
C6454 a_18043_3750.t2 VSS 0.14895f $ **FLOATING
C6455 a_18043_3750.t7 VSS 0.13121f $ **FLOATING
C6456 a_18043_3750.n4 VSS 0.35461f $ **FLOATING
C6457 a_18043_3750.t3 VSS 0.14895f $ **FLOATING
C6458 a_18043_3750.n5 VSS 0.35461f $ **FLOATING
C6459 a_24563_3750.t9 VSS 0.13122f $ **FLOATING
C6460 a_24563_3750.t8 VSS 0.13046f $ **FLOATING
C6461 a_24563_3750.n0 VSS 0.31982f $ **FLOATING
C6462 a_24563_3750.t6 VSS 0.10113f $ **FLOATING
C6463 a_24563_3750.n1 VSS 0.38942f $ **FLOATING
C6464 a_24563_3750.t4 VSS 0.0988f $ **FLOATING
C6465 a_24563_3750.n2 VSS 0.33892f $ **FLOATING
C6466 a_24563_3750.t0 VSS 0.11344f $ **FLOATING
C6467 a_24563_3750.t5 VSS 0.0988f $ **FLOATING
C6468 a_24563_3750.n3 VSS 0.33892f $ **FLOATING
C6469 a_24563_3750.t1 VSS 0.11344f $ **FLOATING
C6470 a_24563_3750.t2 VSS 0.14895f $ **FLOATING
C6471 a_24563_3750.t7 VSS 0.13122f $ **FLOATING
C6472 a_24563_3750.n4 VSS 0.35462f $ **FLOATING
C6473 a_24563_3750.t3 VSS 0.14895f $ **FLOATING
C6474 a_24563_3750.n5 VSS 0.35462f $ **FLOATING
C6475 a_31083_3750.t9 VSS 0.13121f $ **FLOATING
C6476 a_31083_3750.t8 VSS 0.13045f $ **FLOATING
C6477 a_31083_3750.n0 VSS 0.3198f $ **FLOATING
C6478 a_31083_3750.t6 VSS 0.10112f $ **FLOATING
C6479 a_31083_3750.n1 VSS 0.38939f $ **FLOATING
C6480 a_31083_3750.t4 VSS 0.09879f $ **FLOATING
C6481 a_31083_3750.n2 VSS 0.3389f $ **FLOATING
C6482 a_31083_3750.t0 VSS 0.11343f $ **FLOATING
C6483 a_31083_3750.t5 VSS 0.09879f $ **FLOATING
C6484 a_31083_3750.n3 VSS 0.3389f $ **FLOATING
C6485 a_31083_3750.t1 VSS 0.11343f $ **FLOATING
C6486 a_31083_3750.t2 VSS 0.14894f $ **FLOATING
C6487 a_31083_3750.t7 VSS 0.13121f $ **FLOATING
C6488 a_31083_3750.n4 VSS 0.3546f $ **FLOATING
C6489 a_31083_3750.t3 VSS 0.14894f $ **FLOATING
C6490 a_31083_3750.n5 VSS 0.3546f $ **FLOATING
C6491 a_37603_3750.t9 VSS 0.13121f $ **FLOATING
C6492 a_37603_3750.t8 VSS 0.13045f $ **FLOATING
C6493 a_37603_3750.n0 VSS 0.31981f $ **FLOATING
C6494 a_37603_3750.t6 VSS 0.10112f $ **FLOATING
C6495 a_37603_3750.n1 VSS 0.3894f $ **FLOATING
C6496 a_37603_3750.t5 VSS 0.0988f $ **FLOATING
C6497 a_37603_3750.n2 VSS 0.3389f $ **FLOATING
C6498 a_37603_3750.t0 VSS 0.11344f $ **FLOATING
C6499 a_37603_3750.t4 VSS 0.0988f $ **FLOATING
C6500 a_37603_3750.n3 VSS 0.3389f $ **FLOATING
C6501 a_37603_3750.t1 VSS 0.11344f $ **FLOATING
C6502 a_37603_3750.t2 VSS 0.14895f $ **FLOATING
C6503 a_37603_3750.t7 VSS 0.13121f $ **FLOATING
C6504 a_37603_3750.n4 VSS 0.35461f $ **FLOATING
C6505 a_37603_3750.t3 VSS 0.14895f $ **FLOATING
C6506 a_37603_3750.n5 VSS 0.35461f $ **FLOATING
C6507 a_44123_3750.t9 VSS 0.13086f $ **FLOATING
C6508 a_44123_3750.t8 VSS 0.1301f $ **FLOATING
C6509 a_44123_3750.n0 VSS 0.31896f $ **FLOATING
C6510 a_44123_3750.t6 VSS 0.10086f $ **FLOATING
C6511 a_44123_3750.n1 VSS 0.38837f $ **FLOATING
C6512 a_44123_3750.t4 VSS 0.09853f $ **FLOATING
C6513 a_44123_3750.n2 VSS 0.338f $ **FLOATING
C6514 a_44123_3750.t0 VSS 0.11314f $ **FLOATING
C6515 a_44123_3750.t5 VSS 0.09853f $ **FLOATING
C6516 a_44123_3750.n3 VSS 0.338f $ **FLOATING
C6517 a_44123_3750.t1 VSS 0.11314f $ **FLOATING
C6518 a_44123_3750.t2 VSS 0.14855f $ **FLOATING
C6519 a_44123_3750.t7 VSS 0.13086f $ **FLOATING
C6520 a_44123_3750.n4 VSS 0.35366f $ **FLOATING
C6521 a_44123_3750.t3 VSS 0.14855f $ **FLOATING
C6522 a_44123_3750.n5 VSS 0.35366f $ **FLOATING
C6523 a_50643_3750.t9 VSS 0.13081f $ **FLOATING
C6524 a_50643_3750.t8 VSS 0.13005f $ **FLOATING
C6525 a_50643_3750.n0 VSS 0.31883f $ **FLOATING
C6526 a_50643_3750.t6 VSS 0.10081f $ **FLOATING
C6527 a_50643_3750.n1 VSS 0.3882f $ **FLOATING
C6528 a_50643_3750.t4 VSS 0.09849f $ **FLOATING
C6529 a_50643_3750.n2 VSS 0.33786f $ **FLOATING
C6530 a_50643_3750.t0 VSS 0.11309f $ **FLOATING
C6531 a_50643_3750.t5 VSS 0.09849f $ **FLOATING
C6532 a_50643_3750.n3 VSS 0.33786f $ **FLOATING
C6533 a_50643_3750.t1 VSS 0.11309f $ **FLOATING
C6534 a_50643_3750.t2 VSS 0.14849f $ **FLOATING
C6535 a_50643_3750.t7 VSS 0.13081f $ **FLOATING
C6536 a_50643_3750.n4 VSS 0.35352f $ **FLOATING
C6537 a_50643_3750.t3 VSS 0.14849f $ **FLOATING
C6538 a_50643_3750.n5 VSS 0.35352f $ **FLOATING
C6539 a_n2852_4060.t0 VSS 0.02268f $ **FLOATING
C6540 a_585_3794.t0 VSS 0.09127f $ **FLOATING
C6541 a_585_3794.t2 VSS 0.30646f $ **FLOATING
C6542 a_585_3794.t1 VSS 0.14311f $ **FLOATING
C6543 a_585_3794.n0 VSS 0.38094f $ **FLOATING
C6544 a_n2946_3612.t1 VSS 0.12061f $ **FLOATING
C6545 a_n2946_3612.t2 VSS 0.40357f $ **FLOATING
C6546 a_n2946_3612.n0 VSS 0.45692f $ **FLOATING
C6547 a_n2946_3612.t0 VSS 0.1755f $ **FLOATING
C6548 a_679_3794.t0 VSS 0.03794f $ **FLOATING
C6549 a_n2852_3612.t0 VSS 0.02227f $ **FLOATING
C6550 a_890_3398.t0 VSS 0.13442f $ **FLOATING
C6551 a_890_3398.t1 VSS 0.20715f $ **FLOATING
C6552 a_890_3398.n0 VSS 0.5809f $ **FLOATING
C6553 a_890_3398.t2 VSS 0.28368f $ **FLOATING
C6554 a_n2042_2484.t0 VSS 0.11905f $ **FLOATING
C6555 a_n2042_2484.n0 VSS 0.79782f $ **FLOATING
C6556 a_n2042_2484.t10 VSS 0.4533f $ **FLOATING
C6557 a_n2042_2484.n1 VSS 11.9174f $ **FLOATING
C6558 a_n2042_2484.t2 VSS 0.34521f $ **FLOATING
C6559 a_n2042_2484.n2 VSS 4.32032f $ **FLOATING
C6560 a_n2042_2484.t11 VSS 0.32089f $ **FLOATING
C6561 a_n2042_2484.n3 VSS 4.86696f $ **FLOATING
C6562 a_n2042_2484.t3 VSS 0.34521f $ **FLOATING
C6563 a_n2042_2484.n4 VSS 4.32032f $ **FLOATING
C6564 a_n2042_2484.t12 VSS 0.32089f $ **FLOATING
C6565 a_n2042_2484.n5 VSS 4.86696f $ **FLOATING
C6566 a_n2042_2484.t4 VSS 0.34521f $ **FLOATING
C6567 a_n2042_2484.n6 VSS 4.32032f $ **FLOATING
C6568 a_n2042_2484.t13 VSS 0.32089f $ **FLOATING
C6569 a_n2042_2484.n7 VSS 4.86696f $ **FLOATING
C6570 a_n2042_2484.t5 VSS 0.34521f $ **FLOATING
C6571 a_n2042_2484.n8 VSS 4.32032f $ **FLOATING
C6572 a_n2042_2484.t14 VSS 0.32089f $ **FLOATING
C6573 a_n2042_2484.n9 VSS 4.86696f $ **FLOATING
C6574 a_n2042_2484.t6 VSS 0.34521f $ **FLOATING
C6575 a_n2042_2484.n10 VSS 4.32032f $ **FLOATING
C6576 a_n2042_2484.t15 VSS 0.32089f $ **FLOATING
C6577 a_n2042_2484.n11 VSS 4.86696f $ **FLOATING
C6578 a_n2042_2484.t7 VSS 0.34521f $ **FLOATING
C6579 a_n2042_2484.n12 VSS 4.32032f $ **FLOATING
C6580 a_n2042_2484.t16 VSS 0.32089f $ **FLOATING
C6581 a_n2042_2484.n13 VSS 4.86696f $ **FLOATING
C6582 a_n2042_2484.t8 VSS 0.34521f $ **FLOATING
C6583 a_n2042_2484.n14 VSS 4.32032f $ **FLOATING
C6584 a_n2042_2484.t17 VSS 0.32089f $ **FLOATING
C6585 a_n2042_2484.n15 VSS 6.39452f $ **FLOATING
C6586 a_n2042_2484.t9 VSS 0.34521f $ **FLOATING
C6587 a_n2042_2484.t1 VSS 0.18202f $ **FLOATING
C6588 a_1279_3714.t1 VSS 0.16199f $ **FLOATING
C6589 a_1279_3714.t3 VSS 0.18559f $ **FLOATING
C6590 a_1279_3714.t2 VSS 0.2542f $ **FLOATING
C6591 a_1279_3714.t0 VSS 0.25336f $ **FLOATING
C6592 a_1279_3714.n0 VSS 0.39498f $ **FLOATING
C6593 a_1279_3714.n1 VSS 0.36275f $ **FLOATING
C6594 a_1995_3639.t0 VSS 0.14673f $ **FLOATING
C6595 a_1995_3639.t1 VSS 0.14826f $ **FLOATING
C6596 a_1995_3639.t2 VSS 0.13697f $ **FLOATING
C6597 a_1995_3639.t3 VSS 0.31243f $ **FLOATING
C6598 a_1995_3639.n0 VSS 0.43827f $ **FLOATING
C6599 a_1995_3639.n1 VSS 0.34325f $ **FLOATING
C6600 a_1735_3416.t0 VSS 0.18251f $ **FLOATING
C6601 a_1735_3416.t1 VSS 0.18351f $ **FLOATING
C6602 a_1735_3416.n0 VSS 0.98668f $ **FLOATING
C6603 a_1735_3416.t3 VSS 0.1642f $ **FLOATING
C6604 a_1735_3416.n1 VSS 1.06964f $ **FLOATING
C6605 a_1735_3416.t2 VSS 0.17006f $ **FLOATING
C6606 a_2021_3734.t0 VSS 0.19143f $ **FLOATING
C6607 a_2021_3734.t4 VSS 0.24713f $ **FLOATING
C6608 a_2021_3734.n0 VSS 0.5076f $ **FLOATING
C6609 a_2021_3734.t3 VSS 0.26942f $ **FLOATING
C6610 a_2021_3734.t2 VSS 0.27167f $ **FLOATING
C6611 a_2021_3734.n1 VSS 0.81778f $ **FLOATING
C6612 a_2021_3734.t1 VSS 0.27572f $ **FLOATING
C6613 a_2021_3734.n2 VSS 0.49608f $ **FLOATING
C6614 a_2430_3673.t0 VSS 0.15491f $ **FLOATING
C6615 a_2430_3673.t3 VSS 0.60111f $ **FLOATING
C6616 a_2430_3673.n0 VSS 0.31834f $ **FLOATING
C6617 a_2430_3673.t1 VSS 0.2267f $ **FLOATING
C6618 a_2430_3673.n1 VSS 0.1803f $ **FLOATING
C6619 a_2430_3673.t2 VSS 0.25072f $ **FLOATING
C6620 a_2532_3760.t0 VSS 0.20064f $ **FLOATING
C6621 a_2532_3760.t3 VSS 0.28263f $ **FLOATING
C6622 a_2532_3760.n0 VSS 0.63451f $ **FLOATING
C6623 a_2532_3760.t1 VSS 0.30493f $ **FLOATING
C6624 a_2532_3760.t2 VSS 0.27266f $ **FLOATING
C6625 a_2532_3760.n1 VSS 0.34142f $ **FLOATING
C6626 a_1178_3417.t1 VSS 0.09033f $ **FLOATING
C6627 a_1178_3417.t0 VSS 0.09271f $ **FLOATING
C6628 a_1178_3417.t2 VSS 0.08433f $ **FLOATING
C6629 a_1178_3417.n0 VSS 0.26172f $ **FLOATING
C6630 a_3280_3493.t1 VSS 0.15513f $ **FLOATING
C6631 a_3280_3493.t2 VSS 0.78293f $ **FLOATING
C6632 a_3280_3493.n0 VSS 0.44013f $ **FLOATING
C6633 a_3280_3493.t0 VSS 0.23527f $ **FLOATING
C6634 a_3508_3633.t0 VSS 0.10861f $ **FLOATING
C6635 a_3508_3633.t1 VSS 0.1094f $ **FLOATING
C6636 a_3508_3633.n0 VSS 0.47589f $ **FLOATING
C6637 a_3508_3633.t2 VSS 0.21808f $ **FLOATING
C6638 a_4081_3694.t0 VSS 0.08718f $ **FLOATING
C6639 a_4081_3694.t2 VSS 0.28889f $ **FLOATING
C6640 a_4081_3694.t1 VSS 0.13908f $ **FLOATING
C6641 a_4081_3694.n0 VSS 0.3269f $ **FLOATING
C6642 a_7105_3794.t0 VSS 0.08965f $ **FLOATING
C6643 a_7105_3794.t2 VSS 0.30104f $ **FLOATING
C6644 a_7105_3794.t1 VSS 0.14058f $ **FLOATING
C6645 a_7105_3794.n0 VSS 0.3742f $ **FLOATING
C6646 a_2310_3429.t0 VSS 0.4464f $ **FLOATING
C6647 a_2310_3429.t1 VSS 0.38794f $ **FLOATING
C6648 a_3186_3493.t0 VSS 0.37163f $ **FLOATING
C6649 a_3186_3493.t1 VSS 0.37297f $ **FLOATING
C6650 a_5169_3490.t3 VSS 0.07497f $ **FLOATING
C6651 a_5169_3490.t6 VSS 0.07497f $ **FLOATING
C6652 a_5169_3490.n0 VSS 0.12649f $ **FLOATING
C6653 a_5169_3490.t2 VSS 0.07497f $ **FLOATING
C6654 a_5169_3490.t7 VSS 0.07497f $ **FLOATING
C6655 a_5169_3490.n1 VSS 0.16231f $ **FLOATING
C6656 a_5169_3490.t1 VSS 0.07497f $ **FLOATING
C6657 a_5169_3490.t5 VSS 0.07497f $ **FLOATING
C6658 a_5169_3490.n2 VSS 0.16231f $ **FLOATING
C6659 a_5169_3490.t0 VSS 0.07497f $ **FLOATING
C6660 a_5169_3490.t4 VSS 0.07497f $ **FLOATING
C6661 a_5169_3490.n3 VSS 0.12648f $ **FLOATING
C6662 a_7199_3794.t0 VSS 0.03797f $ **FLOATING
C6663 a_7410_3398.t0 VSS 0.13437f $ **FLOATING
C6664 a_7410_3398.t1 VSS 0.20707f $ **FLOATING
C6665 a_7410_3398.n0 VSS 0.58066f $ **FLOATING
C6666 a_7410_3398.t2 VSS 0.28357f $ **FLOATING
C6667 a_7799_3714.t0 VSS 0.16181f $ **FLOATING
C6668 a_7799_3714.t3 VSS 0.18538f $ **FLOATING
C6669 a_7799_3714.t1 VSS 0.25392f $ **FLOATING
C6670 a_7799_3714.t2 VSS 0.25308f $ **FLOATING
C6671 a_7799_3714.n0 VSS 0.39454f $ **FLOATING
C6672 a_7799_3714.n1 VSS 0.36235f $ **FLOATING
C6673 a_8515_3639.t0 VSS 0.14672f $ **FLOATING
C6674 a_8515_3639.t1 VSS 0.14825f $ **FLOATING
C6675 a_8515_3639.t2 VSS 0.13696f $ **FLOATING
C6676 a_8515_3639.t3 VSS 0.31242f $ **FLOATING
C6677 a_8515_3639.n0 VSS 0.43824f $ **FLOATING
C6678 a_8515_3639.n1 VSS 0.34324f $ **FLOATING
C6679 a_8255_3416.t0 VSS 0.18249f $ **FLOATING
C6680 a_8255_3416.t1 VSS 0.1835f $ **FLOATING
C6681 a_8255_3416.n0 VSS 0.9866f $ **FLOATING
C6682 a_8255_3416.t2 VSS 0.16418f $ **FLOATING
C6683 a_8255_3416.n1 VSS 1.06956f $ **FLOATING
C6684 a_8255_3416.t3 VSS 0.17004f $ **FLOATING
C6685 a_8541_3734.t0 VSS 0.19142f $ **FLOATING
C6686 a_8541_3734.t4 VSS 0.24711f $ **FLOATING
C6687 a_8541_3734.n0 VSS 0.50757f $ **FLOATING
C6688 a_8541_3734.t2 VSS 0.26941f $ **FLOATING
C6689 a_8541_3734.t3 VSS 0.27166f $ **FLOATING
C6690 a_8541_3734.n1 VSS 0.81773f $ **FLOATING
C6691 a_8541_3734.t1 VSS 0.2757f $ **FLOATING
C6692 a_8541_3734.n2 VSS 0.49604f $ **FLOATING
C6693 a_8950_3673.t0 VSS 0.15491f $ **FLOATING
C6694 a_8950_3673.t3 VSS 0.60109f $ **FLOATING
C6695 a_8950_3673.n0 VSS 0.31833f $ **FLOATING
C6696 a_8950_3673.t1 VSS 0.2267f $ **FLOATING
C6697 a_8950_3673.n1 VSS 0.1803f $ **FLOATING
C6698 a_8950_3673.t2 VSS 0.25071f $ **FLOATING
C6699 a_9052_3760.t0 VSS 0.20064f $ **FLOATING
C6700 a_9052_3760.t3 VSS 0.28263f $ **FLOATING
C6701 a_9052_3760.n0 VSS 0.63449f $ **FLOATING
C6702 a_9052_3760.t1 VSS 0.30493f $ **FLOATING
C6703 a_9052_3760.t2 VSS 0.27265f $ **FLOATING
C6704 a_9052_3760.n1 VSS 0.34142f $ **FLOATING
C6705 a_7698_3417.t1 VSS 0.08422f $ **FLOATING
C6706 a_7698_3417.n0 VSS 0.26138f $ **FLOATING
C6707 a_7698_3417.t0 VSS 0.09021f $ **FLOATING
C6708 a_7698_3417.t2 VSS 0.09259f $ **FLOATING
C6709 a_9800_3493.t1 VSS 0.15513f $ **FLOATING
C6710 a_9800_3493.t2 VSS 0.78293f $ **FLOATING
C6711 a_9800_3493.n0 VSS 0.44013f $ **FLOATING
C6712 a_9800_3493.t0 VSS 0.23527f $ **FLOATING
C6713 a_10028_3633.t0 VSS 0.10861f $ **FLOATING
C6714 a_10028_3633.t1 VSS 0.1094f $ **FLOATING
C6715 a_10028_3633.n0 VSS 0.47589f $ **FLOATING
C6716 a_10028_3633.t2 VSS 0.21808f $ **FLOATING
C6717 a_10601_3694.t0 VSS 0.08718f $ **FLOATING
C6718 a_10601_3694.t2 VSS 0.28889f $ **FLOATING
C6719 a_10601_3694.t1 VSS 0.13908f $ **FLOATING
C6720 a_10601_3694.n0 VSS 0.3269f $ **FLOATING
C6721 a_13625_3794.t0 VSS 0.08975f $ **FLOATING
C6722 a_13625_3794.t2 VSS 0.30136f $ **FLOATING
C6723 a_13625_3794.t1 VSS 0.14073f $ **FLOATING
C6724 a_13625_3794.n0 VSS 0.3746f $ **FLOATING
C6725 a_8830_3429.t0 VSS 0.44638f $ **FLOATING
C6726 a_8830_3429.t1 VSS 0.38792f $ **FLOATING
C6727 a_9706_3493.t0 VSS 0.37163f $ **FLOATING
C6728 a_9706_3493.t1 VSS 0.37297f $ **FLOATING
C6729 a_11689_3490.t3 VSS 0.07497f $ **FLOATING
C6730 a_11689_3490.t6 VSS 0.07497f $ **FLOATING
C6731 a_11689_3490.n0 VSS 0.12649f $ **FLOATING
C6732 a_11689_3490.t2 VSS 0.07497f $ **FLOATING
C6733 a_11689_3490.t7 VSS 0.07497f $ **FLOATING
C6734 a_11689_3490.n1 VSS 0.16231f $ **FLOATING
C6735 a_11689_3490.t1 VSS 0.07497f $ **FLOATING
C6736 a_11689_3490.t5 VSS 0.07497f $ **FLOATING
C6737 a_11689_3490.n2 VSS 0.16231f $ **FLOATING
C6738 a_11689_3490.t0 VSS 0.07497f $ **FLOATING
C6739 a_11689_3490.t4 VSS 0.07497f $ **FLOATING
C6740 a_11689_3490.n3 VSS 0.12649f $ **FLOATING
C6741 a_13719_3794.t0 VSS 0.03799f $ **FLOATING
C6742 a_13930_3398.t0 VSS 0.13454f $ **FLOATING
C6743 a_13930_3398.t1 VSS 0.20733f $ **FLOATING
C6744 a_13930_3398.n0 VSS 0.5814f $ **FLOATING
C6745 a_13930_3398.t2 VSS 0.28392f $ **FLOATING
C6746 a_14319_3714.t0 VSS 0.16163f $ **FLOATING
C6747 a_14319_3714.t3 VSS 0.18517f $ **FLOATING
C6748 a_14319_3714.t1 VSS 0.25363f $ **FLOATING
C6749 a_14319_3714.t2 VSS 0.25279f $ **FLOATING
C6750 a_14319_3714.n0 VSS 0.3941f $ **FLOATING
C6751 a_14319_3714.n1 VSS 0.36194f $ **FLOATING
C6752 a_15035_3639.t0 VSS 0.14671f $ **FLOATING
C6753 a_15035_3639.t1 VSS 0.14824f $ **FLOATING
C6754 a_15035_3639.t2 VSS 0.13695f $ **FLOATING
C6755 a_15035_3639.t3 VSS 0.3124f $ **FLOATING
C6756 a_15035_3639.n0 VSS 0.43822f $ **FLOATING
C6757 a_15035_3639.n1 VSS 0.34322f $ **FLOATING
C6758 a_14775_3416.t0 VSS 0.18348f $ **FLOATING
C6759 a_14775_3416.t2 VSS 0.16417f $ **FLOATING
C6760 a_14775_3416.n0 VSS 1.06948f $ **FLOATING
C6761 a_14775_3416.t3 VSS 0.17003f $ **FLOATING
C6762 a_14775_3416.t1 VSS 0.18248f $ **FLOATING
C6763 a_14775_3416.n1 VSS 0.98653f $ **FLOATING
C6764 a_15061_3734.t0 VSS 0.19141f $ **FLOATING
C6765 a_15061_3734.t4 VSS 0.2471f $ **FLOATING
C6766 a_15061_3734.n0 VSS 0.50754f $ **FLOATING
C6767 a_15061_3734.t2 VSS 0.26939f $ **FLOATING
C6768 a_15061_3734.t3 VSS 0.27164f $ **FLOATING
C6769 a_15061_3734.n1 VSS 0.81769f $ **FLOATING
C6770 a_15061_3734.t1 VSS 0.27569f $ **FLOATING
C6771 a_15061_3734.n2 VSS 0.49602f $ **FLOATING
C6772 a_15470_3673.t0 VSS 0.1549f $ **FLOATING
C6773 a_15470_3673.t3 VSS 0.60104f $ **FLOATING
C6774 a_15470_3673.n0 VSS 0.3183f $ **FLOATING
C6775 a_15470_3673.t1 VSS 0.22668f $ **FLOATING
C6776 a_15470_3673.n1 VSS 0.18028f $ **FLOATING
C6777 a_15470_3673.t2 VSS 0.25069f $ **FLOATING
C6778 a_15572_3760.t0 VSS 0.20063f $ **FLOATING
C6779 a_15572_3760.t3 VSS 0.28262f $ **FLOATING
C6780 a_15572_3760.n0 VSS 0.63448f $ **FLOATING
C6781 a_15572_3760.t1 VSS 0.30492f $ **FLOATING
C6782 a_15572_3760.t2 VSS 0.27265f $ **FLOATING
C6783 a_15572_3760.n1 VSS 0.34141f $ **FLOATING
C6784 a_14218_3417.t1 VSS 0.08405f $ **FLOATING
C6785 a_14218_3417.n0 VSS 0.26084f $ **FLOATING
C6786 a_14218_3417.t0 VSS 0.09002f $ **FLOATING
C6787 a_14218_3417.t2 VSS 0.0924f $ **FLOATING
C6788 a_16320_3493.t1 VSS 0.15513f $ **FLOATING
C6789 a_16320_3493.t2 VSS 0.78293f $ **FLOATING
C6790 a_16320_3493.n0 VSS 0.44013f $ **FLOATING
C6791 a_16320_3493.t0 VSS 0.23527f $ **FLOATING
C6792 a_16548_3633.t0 VSS 0.10861f $ **FLOATING
C6793 a_16548_3633.t1 VSS 0.1094f $ **FLOATING
C6794 a_16548_3633.n0 VSS 0.47589f $ **FLOATING
C6795 a_16548_3633.t2 VSS 0.21808f $ **FLOATING
C6796 a_17121_3694.t0 VSS 0.08718f $ **FLOATING
C6797 a_17121_3694.t2 VSS 0.28889f $ **FLOATING
C6798 a_17121_3694.t1 VSS 0.13908f $ **FLOATING
C6799 a_17121_3694.n0 VSS 0.3269f $ **FLOATING
C6800 a_20145_3794.t0 VSS 0.08964f $ **FLOATING
C6801 a_20145_3794.t2 VSS 0.30097f $ **FLOATING
C6802 a_20145_3794.t1 VSS 0.14055f $ **FLOATING
C6803 a_20145_3794.n0 VSS 0.37411f $ **FLOATING
C6804 a_15350_3429.t0 VSS 0.44637f $ **FLOATING
C6805 a_15350_3429.t1 VSS 0.38791f $ **FLOATING
C6806 a_16226_3493.t0 VSS 0.37163f $ **FLOATING
C6807 a_16226_3493.t1 VSS 0.37297f $ **FLOATING
C6808 a_18209_3490.t3 VSS 0.07497f $ **FLOATING
C6809 a_18209_3490.t6 VSS 0.07496f $ **FLOATING
C6810 a_18209_3490.n0 VSS 0.12648f $ **FLOATING
C6811 a_18209_3490.t2 VSS 0.07497f $ **FLOATING
C6812 a_18209_3490.t7 VSS 0.07496f $ **FLOATING
C6813 a_18209_3490.n1 VSS 0.1623f $ **FLOATING
C6814 a_18209_3490.t1 VSS 0.07497f $ **FLOATING
C6815 a_18209_3490.t5 VSS 0.07496f $ **FLOATING
C6816 a_18209_3490.n2 VSS 0.1623f $ **FLOATING
C6817 a_18209_3490.t0 VSS 0.07497f $ **FLOATING
C6818 a_18209_3490.t4 VSS 0.07497f $ **FLOATING
C6819 a_18209_3490.n3 VSS 0.12648f $ **FLOATING
C6820 a_20239_3794.t0 VSS 0.03796f $ **FLOATING
C6821 a_20450_3398.t0 VSS 0.13432f $ **FLOATING
C6822 a_20450_3398.t1 VSS 0.20699f $ **FLOATING
C6823 a_20450_3398.n0 VSS 0.58045f $ **FLOATING
C6824 a_20450_3398.t2 VSS 0.28346f $ **FLOATING
C6825 a_20839_3714.t0 VSS 0.1619f $ **FLOATING
C6826 a_20839_3714.t3 VSS 0.18548f $ **FLOATING
C6827 a_20839_3714.t1 VSS 0.25406f $ **FLOATING
C6828 a_20839_3714.t2 VSS 0.25322f $ **FLOATING
C6829 a_20839_3714.n0 VSS 0.39476f $ **FLOATING
C6830 a_20839_3714.n1 VSS 0.36255f $ **FLOATING
C6831 a_21555_3639.t0 VSS 0.14672f $ **FLOATING
C6832 a_21555_3639.t1 VSS 0.14825f $ **FLOATING
C6833 a_21555_3639.t2 VSS 0.13696f $ **FLOATING
C6834 a_21555_3639.t3 VSS 0.31243f $ **FLOATING
C6835 a_21555_3639.n0 VSS 0.43826f $ **FLOATING
C6836 a_21555_3639.n1 VSS 0.34325f $ **FLOATING
C6837 a_21295_3416.t0 VSS 0.1825f $ **FLOATING
C6838 a_21295_3416.t1 VSS 0.1835f $ **FLOATING
C6839 a_21295_3416.n0 VSS 0.98664f $ **FLOATING
C6840 a_21295_3416.t2 VSS 0.16419f $ **FLOATING
C6841 a_21295_3416.n1 VSS 1.0696f $ **FLOATING
C6842 a_21295_3416.t3 VSS 0.17005f $ **FLOATING
C6843 a_21581_3734.t0 VSS 0.19142f $ **FLOATING
C6844 a_21581_3734.t4 VSS 0.24712f $ **FLOATING
C6845 a_21581_3734.n0 VSS 0.50759f $ **FLOATING
C6846 a_21581_3734.t2 VSS 0.26941f $ **FLOATING
C6847 a_21581_3734.t3 VSS 0.27167f $ **FLOATING
C6848 a_21581_3734.n1 VSS 0.81776f $ **FLOATING
C6849 a_21581_3734.t1 VSS 0.27571f $ **FLOATING
C6850 a_21581_3734.n2 VSS 0.49606f $ **FLOATING
C6851 a_21990_3673.t0 VSS 0.15491f $ **FLOATING
C6852 a_21990_3673.t3 VSS 0.6011f $ **FLOATING
C6853 a_21990_3673.n0 VSS 0.31833f $ **FLOATING
C6854 a_21990_3673.t1 VSS 0.2267f $ **FLOATING
C6855 a_21990_3673.n1 VSS 0.1803f $ **FLOATING
C6856 a_21990_3673.t2 VSS 0.25072f $ **FLOATING
C6857 a_22092_3760.t0 VSS 0.20064f $ **FLOATING
C6858 a_22092_3760.t3 VSS 0.28263f $ **FLOATING
C6859 a_22092_3760.n0 VSS 0.6345f $ **FLOATING
C6860 a_22092_3760.t1 VSS 0.30493f $ **FLOATING
C6861 a_22092_3760.t2 VSS 0.27266f $ **FLOATING
C6862 a_22092_3760.n1 VSS 0.34142f $ **FLOATING
C6863 a_20738_3417.t1 VSS 0.08426f $ **FLOATING
C6864 a_20738_3417.n0 VSS 0.26149f $ **FLOATING
C6865 a_20738_3417.t0 VSS 0.09025f $ **FLOATING
C6866 a_20738_3417.t2 VSS 0.09263f $ **FLOATING
C6867 a_22840_3493.t1 VSS 0.15513f $ **FLOATING
C6868 a_22840_3493.t2 VSS 0.78293f $ **FLOATING
C6869 a_22840_3493.n0 VSS 0.44013f $ **FLOATING
C6870 a_22840_3493.t0 VSS 0.23527f $ **FLOATING
C6871 a_23068_3633.t0 VSS 0.1094f $ **FLOATING
C6872 a_23068_3633.t2 VSS 0.21808f $ **FLOATING
C6873 a_23068_3633.t1 VSS 0.10861f $ **FLOATING
C6874 a_23068_3633.n0 VSS 0.47589f $ **FLOATING
C6875 a_23641_3694.t0 VSS 0.08718f $ **FLOATING
C6876 a_23641_3694.t2 VSS 0.28889f $ **FLOATING
C6877 a_23641_3694.t1 VSS 0.13908f $ **FLOATING
C6878 a_23641_3694.n0 VSS 0.3269f $ **FLOATING
C6879 a_26665_3794.t0 VSS 0.08968f $ **FLOATING
C6880 a_26665_3794.t2 VSS 0.30111f $ **FLOATING
C6881 a_26665_3794.t1 VSS 0.14061f $ **FLOATING
C6882 a_26665_3794.n0 VSS 0.37428f $ **FLOATING
C6883 a_21870_3429.t0 VSS 0.44639f $ **FLOATING
C6884 a_21870_3429.t1 VSS 0.38793f $ **FLOATING
C6885 a_22746_3493.t0 VSS 0.37163f $ **FLOATING
C6886 a_22746_3493.t1 VSS 0.37297f $ **FLOATING
C6887 a_24729_3490.t3 VSS 0.07497f $ **FLOATING
C6888 a_24729_3490.t6 VSS 0.07497f $ **FLOATING
C6889 a_24729_3490.n0 VSS 0.12649f $ **FLOATING
C6890 a_24729_3490.t2 VSS 0.07497f $ **FLOATING
C6891 a_24729_3490.t7 VSS 0.07497f $ **FLOATING
C6892 a_24729_3490.n1 VSS 0.16231f $ **FLOATING
C6893 a_24729_3490.t1 VSS 0.07497f $ **FLOATING
C6894 a_24729_3490.t5 VSS 0.07497f $ **FLOATING
C6895 a_24729_3490.n2 VSS 0.16231f $ **FLOATING
C6896 a_24729_3490.t0 VSS 0.07497f $ **FLOATING
C6897 a_24729_3490.t4 VSS 0.07497f $ **FLOATING
C6898 a_24729_3490.n3 VSS 0.12649f $ **FLOATING
C6899 a_26759_3794.t0 VSS 0.03798f $ **FLOATING
C6900 a_26970_3398.t0 VSS 0.13446f $ **FLOATING
C6901 a_26970_3398.t1 VSS 0.2072f $ **FLOATING
C6902 a_26970_3398.n0 VSS 0.58104f $ **FLOATING
C6903 a_26970_3398.t2 VSS 0.28375f $ **FLOATING
C6904 a_27359_3714.t1 VSS 0.16172f $ **FLOATING
C6905 a_27359_3714.t3 VSS 0.18527f $ **FLOATING
C6906 a_27359_3714.t0 VSS 0.25378f $ **FLOATING
C6907 a_27359_3714.t2 VSS 0.25293f $ **FLOATING
C6908 a_27359_3714.n0 VSS 0.39432f $ **FLOATING
C6909 a_27359_3714.n1 VSS 0.36214f $ **FLOATING
C6910 a_28075_3639.t0 VSS 0.14824f $ **FLOATING
C6911 a_28075_3639.t2 VSS 0.13696f $ **FLOATING
C6912 a_28075_3639.t3 VSS 0.31241f $ **FLOATING
C6913 a_28075_3639.n0 VSS 0.43823f $ **FLOATING
C6914 a_28075_3639.n1 VSS 0.34323f $ **FLOATING
C6915 a_28075_3639.t1 VSS 0.14671f $ **FLOATING
C6916 a_27815_3416.t0 VSS 0.18249f $ **FLOATING
C6917 a_27815_3416.t1 VSS 0.18349f $ **FLOATING
C6918 a_27815_3416.n0 VSS 0.98657f $ **FLOATING
C6919 a_27815_3416.t2 VSS 0.16418f $ **FLOATING
C6920 a_27815_3416.n1 VSS 1.06952f $ **FLOATING
C6921 a_27815_3416.t3 VSS 0.17004f $ **FLOATING
C6922 a_28101_3734.t0 VSS 0.19141f $ **FLOATING
C6923 a_28101_3734.t4 VSS 0.2471f $ **FLOATING
C6924 a_28101_3734.n0 VSS 0.50756f $ **FLOATING
C6925 a_28101_3734.t2 VSS 0.2694f $ **FLOATING
C6926 a_28101_3734.t3 VSS 0.27165f $ **FLOATING
C6927 a_28101_3734.n1 VSS 0.81771f $ **FLOATING
C6928 a_28101_3734.t1 VSS 0.2757f $ **FLOATING
C6929 a_28101_3734.n2 VSS 0.49603f $ **FLOATING
C6930 a_28510_3673.t0 VSS 0.1549f $ **FLOATING
C6931 a_28510_3673.t3 VSS 0.60107f $ **FLOATING
C6932 a_28510_3673.n0 VSS 0.31831f $ **FLOATING
C6933 a_28510_3673.t1 VSS 0.22669f $ **FLOATING
C6934 a_28510_3673.n1 VSS 0.18029f $ **FLOATING
C6935 a_28510_3673.t2 VSS 0.2507f $ **FLOATING
C6936 a_28612_3760.t0 VSS 0.20064f $ **FLOATING
C6937 a_28612_3760.t3 VSS 0.28262f $ **FLOATING
C6938 a_28612_3760.n0 VSS 0.63449f $ **FLOATING
C6939 a_28612_3760.t1 VSS 0.30492f $ **FLOATING
C6940 a_28612_3760.t2 VSS 0.27265f $ **FLOATING
C6941 a_28612_3760.n1 VSS 0.34141f $ **FLOATING
C6942 a_27258_3417.t1 VSS 0.08412f $ **FLOATING
C6943 a_27258_3417.n0 VSS 0.26106f $ **FLOATING
C6944 a_27258_3417.t0 VSS 0.0901f $ **FLOATING
C6945 a_27258_3417.t2 VSS 0.09248f $ **FLOATING
C6946 a_29360_3493.t1 VSS 0.15513f $ **FLOATING
C6947 a_29360_3493.t2 VSS 0.78293f $ **FLOATING
C6948 a_29360_3493.n0 VSS 0.44013f $ **FLOATING
C6949 a_29360_3493.t0 VSS 0.23527f $ **FLOATING
C6950 a_29588_3633.t0 VSS 0.10861f $ **FLOATING
C6951 a_29588_3633.t1 VSS 0.1094f $ **FLOATING
C6952 a_29588_3633.n0 VSS 0.47589f $ **FLOATING
C6953 a_29588_3633.t2 VSS 0.21808f $ **FLOATING
C6954 a_30161_3694.t0 VSS 0.08718f $ **FLOATING
C6955 a_30161_3694.t2 VSS 0.28889f $ **FLOATING
C6956 a_30161_3694.t1 VSS 0.13908f $ **FLOATING
C6957 a_30161_3694.n0 VSS 0.3269f $ **FLOATING
C6958 a_33185_3794.t0 VSS 0.08957f $ **FLOATING
C6959 a_33185_3794.t2 VSS 0.30075f $ **FLOATING
C6960 a_33185_3794.t1 VSS 0.14044f $ **FLOATING
C6961 a_33185_3794.n0 VSS 0.37383f $ **FLOATING
C6962 a_28390_3429.t0 VSS 0.44638f $ **FLOATING
C6963 a_28390_3429.t1 VSS 0.38792f $ **FLOATING
C6964 a_29266_3493.t0 VSS 0.37163f $ **FLOATING
C6965 a_29266_3493.t1 VSS 0.37297f $ **FLOATING
C6966 a_31249_3490.t3 VSS 0.07496f $ **FLOATING
C6967 a_31249_3490.t6 VSS 0.07496f $ **FLOATING
C6968 a_31249_3490.n0 VSS 0.12648f $ **FLOATING
C6969 a_31249_3490.t2 VSS 0.07496f $ **FLOATING
C6970 a_31249_3490.t7 VSS 0.07496f $ **FLOATING
C6971 a_31249_3490.n1 VSS 0.1623f $ **FLOATING
C6972 a_31249_3490.t1 VSS 0.07496f $ **FLOATING
C6973 a_31249_3490.t5 VSS 0.07496f $ **FLOATING
C6974 a_31249_3490.n2 VSS 0.1623f $ **FLOATING
C6975 a_31249_3490.t0 VSS 0.07496f $ **FLOATING
C6976 a_31249_3490.t4 VSS 0.07496f $ **FLOATING
C6977 a_31249_3490.n3 VSS 0.12648f $ **FLOATING
C6978 a_33279_3794.t0 VSS 0.03791f $ **FLOATING
C6979 a_33490_3398.t0 VSS 0.13464f $ **FLOATING
C6980 a_33490_3398.t1 VSS 0.20749f $ **FLOATING
C6981 a_33490_3398.n0 VSS 0.58184f $ **FLOATING
C6982 a_33490_3398.t2 VSS 0.28414f $ **FLOATING
C6983 a_33879_3714.t0 VSS 0.16244f $ **FLOATING
C6984 a_33879_3714.t3 VSS 0.1861f $ **FLOATING
C6985 a_33879_3714.t1 VSS 0.25491f $ **FLOATING
C6986 a_33879_3714.t2 VSS 0.25406f $ **FLOATING
C6987 a_33879_3714.n0 VSS 0.39608f $ **FLOATING
C6988 a_33879_3714.n1 VSS 0.36376f $ **FLOATING
C6989 a_34595_3639.t0 VSS 0.14674f $ **FLOATING
C6990 a_34595_3639.t1 VSS 0.14827f $ **FLOATING
C6991 a_34595_3639.t2 VSS 0.13698f $ **FLOATING
C6992 a_34595_3639.t3 VSS 0.31246f $ **FLOATING
C6993 a_34595_3639.n0 VSS 0.43831f $ **FLOATING
C6994 a_34595_3639.n1 VSS 0.34329f $ **FLOATING
C6995 a_34335_3416.t0 VSS 0.18253f $ **FLOATING
C6996 a_34335_3416.t1 VSS 0.18353f $ **FLOATING
C6997 a_34335_3416.n0 VSS 0.98679f $ **FLOATING
C6998 a_34335_3416.t2 VSS 0.16421f $ **FLOATING
C6999 a_34335_3416.n1 VSS 1.06976f $ **FLOATING
C7000 a_34335_3416.t3 VSS 0.17008f $ **FLOATING
C7001 a_34621_3734.t0 VSS 0.19145f $ **FLOATING
C7002 a_34621_3734.t4 VSS 0.24715f $ **FLOATING
C7003 a_34621_3734.n0 VSS 0.50765f $ **FLOATING
C7004 a_34621_3734.t2 VSS 0.26945f $ **FLOATING
C7005 a_34621_3734.t3 VSS 0.2717f $ **FLOATING
C7006 a_34621_3734.n1 VSS 0.81786f $ **FLOATING
C7007 a_34621_3734.t1 VSS 0.27575f $ **FLOATING
C7008 a_34621_3734.n2 VSS 0.49612f $ **FLOATING
C7009 a_35030_3673.t0 VSS 0.15492f $ **FLOATING
C7010 a_35030_3673.t3 VSS 0.60114f $ **FLOATING
C7011 a_35030_3673.n0 VSS 0.31835f $ **FLOATING
C7012 a_35030_3673.t1 VSS 0.22671f $ **FLOATING
C7013 a_35030_3673.n1 VSS 0.18031f $ **FLOATING
C7014 a_35030_3673.t2 VSS 0.25073f $ **FLOATING
C7015 a_35132_3760.t0 VSS 0.20065f $ **FLOATING
C7016 a_35132_3760.t3 VSS 0.28264f $ **FLOATING
C7017 a_35132_3760.n0 VSS 0.63453f $ **FLOATING
C7018 a_35132_3760.t1 VSS 0.30494f $ **FLOATING
C7019 a_35132_3760.t2 VSS 0.27267f $ **FLOATING
C7020 a_35132_3760.n1 VSS 0.34144f $ **FLOATING
C7021 a_33778_3417.t1 VSS 0.08471f $ **FLOATING
C7022 a_33778_3417.n0 VSS 0.26288f $ **FLOATING
C7023 a_33778_3417.t0 VSS 0.09073f $ **FLOATING
C7024 a_33778_3417.t2 VSS 0.09313f $ **FLOATING
C7025 a_35880_3493.t1 VSS 0.15513f $ **FLOATING
C7026 a_35880_3493.t2 VSS 0.78293f $ **FLOATING
C7027 a_35880_3493.n0 VSS 0.44013f $ **FLOATING
C7028 a_35880_3493.t0 VSS 0.23527f $ **FLOATING
C7029 a_36108_3633.t0 VSS 0.10861f $ **FLOATING
C7030 a_36108_3633.t1 VSS 0.1094f $ **FLOATING
C7031 a_36108_3633.n0 VSS 0.47589f $ **FLOATING
C7032 a_36108_3633.t2 VSS 0.21808f $ **FLOATING
C7033 a_36681_3694.t0 VSS 0.08718f $ **FLOATING
C7034 a_36681_3694.t2 VSS 0.28889f $ **FLOATING
C7035 a_36681_3694.t1 VSS 0.13908f $ **FLOATING
C7036 a_36681_3694.n0 VSS 0.3269f $ **FLOATING
C7037 a_39705_3794.t0 VSS 0.0896f $ **FLOATING
C7038 a_39705_3794.t2 VSS 0.30086f $ **FLOATING
C7039 a_39705_3794.t1 VSS 0.14049f $ **FLOATING
C7040 a_39705_3794.n0 VSS 0.37397f $ **FLOATING
C7041 a_34910_3429.t0 VSS 0.44642f $ **FLOATING
C7042 a_34910_3429.t1 VSS 0.38795f $ **FLOATING
C7043 a_35786_3493.t0 VSS 0.37163f $ **FLOATING
C7044 a_35786_3493.t1 VSS 0.37297f $ **FLOATING
C7045 a_37769_3490.t3 VSS 0.07496f $ **FLOATING
C7046 a_37769_3490.t6 VSS 0.07496f $ **FLOATING
C7047 a_37769_3490.n0 VSS 0.12648f $ **FLOATING
C7048 a_37769_3490.t2 VSS 0.07496f $ **FLOATING
C7049 a_37769_3490.t7 VSS 0.07496f $ **FLOATING
C7050 a_37769_3490.n1 VSS 0.1623f $ **FLOATING
C7051 a_37769_3490.t1 VSS 0.07496f $ **FLOATING
C7052 a_37769_3490.t5 VSS 0.07496f $ **FLOATING
C7053 a_37769_3490.n2 VSS 0.1623f $ **FLOATING
C7054 a_37769_3490.t0 VSS 0.07496f $ **FLOATING
C7055 a_37769_3490.t4 VSS 0.07496f $ **FLOATING
C7056 a_37769_3490.n3 VSS 0.12648f $ **FLOATING
C7057 a_39799_3794.t0 VSS 0.03794f $ **FLOATING
C7058 a_40010_3398.t0 VSS 0.13449f $ **FLOATING
C7059 a_40010_3398.t1 VSS 0.20725f $ **FLOATING
C7060 a_40010_3398.n0 VSS 0.58118f $ **FLOATING
C7061 a_40010_3398.t2 VSS 0.28382f $ **FLOATING
C7062 a_40399_3714.t0 VSS 0.16212f $ **FLOATING
C7063 a_40399_3714.t3 VSS 0.18573f $ **FLOATING
C7064 a_40399_3714.t1 VSS 0.2544f $ **FLOATING
C7065 a_40399_3714.t2 VSS 0.25356f $ **FLOATING
C7066 a_40399_3714.n0 VSS 0.39529f $ **FLOATING
C7067 a_40399_3714.n1 VSS 0.36304f $ **FLOATING
C7068 a_41115_3639.t0 VSS 0.14673f $ **FLOATING
C7069 a_41115_3639.t1 VSS 0.14826f $ **FLOATING
C7070 a_41115_3639.t2 VSS 0.13697f $ **FLOATING
C7071 a_41115_3639.t3 VSS 0.31244f $ **FLOATING
C7072 a_41115_3639.n0 VSS 0.43828f $ **FLOATING
C7073 a_41115_3639.n1 VSS 0.34327f $ **FLOATING
C7074 a_40855_3416.t0 VSS 0.18251f $ **FLOATING
C7075 a_40855_3416.t1 VSS 0.18352f $ **FLOATING
C7076 a_40855_3416.n0 VSS 0.98672f $ **FLOATING
C7077 a_40855_3416.t2 VSS 0.1642f $ **FLOATING
C7078 a_40855_3416.n1 VSS 1.06968f $ **FLOATING
C7079 a_40855_3416.t3 VSS 0.17006f $ **FLOATING
C7080 a_41141_3734.t0 VSS 0.19144f $ **FLOATING
C7081 a_41141_3734.t4 VSS 0.24713f $ **FLOATING
C7082 a_41141_3734.n0 VSS 0.50762f $ **FLOATING
C7083 a_41141_3734.t2 VSS 0.26943f $ **FLOATING
C7084 a_41141_3734.t3 VSS 0.27168f $ **FLOATING
C7085 a_41141_3734.n1 VSS 0.81781f $ **FLOATING
C7086 a_41141_3734.t1 VSS 0.27573f $ **FLOATING
C7087 a_41141_3734.n2 VSS 0.49609f $ **FLOATING
C7088 a_41550_3673.t0 VSS 0.15491f $ **FLOATING
C7089 a_41550_3673.t3 VSS 0.60112f $ **FLOATING
C7090 a_41550_3673.n0 VSS 0.31834f $ **FLOATING
C7091 a_41550_3673.t1 VSS 0.22671f $ **FLOATING
C7092 a_41550_3673.n1 VSS 0.1803f $ **FLOATING
C7093 a_41550_3673.t2 VSS 0.25072f $ **FLOATING
C7094 a_41652_3760.t0 VSS 0.20064f $ **FLOATING
C7095 a_41652_3760.t3 VSS 0.28264f $ **FLOATING
C7096 a_41652_3760.n0 VSS 0.63451f $ **FLOATING
C7097 a_41652_3760.t1 VSS 0.30494f $ **FLOATING
C7098 a_41652_3760.t2 VSS 0.27266f $ **FLOATING
C7099 a_41652_3760.n1 VSS 0.34143f $ **FLOATING
C7100 a_40298_3417.t1 VSS 0.08445f $ **FLOATING
C7101 a_40298_3417.n0 VSS 0.26207f $ **FLOATING
C7102 a_40298_3417.t0 VSS 0.09045f $ **FLOATING
C7103 a_40298_3417.t2 VSS 0.09284f $ **FLOATING
C7104 a_42400_3493.t1 VSS 0.15513f $ **FLOATING
C7105 a_42400_3493.t2 VSS 0.78293f $ **FLOATING
C7106 a_42400_3493.n0 VSS 0.44013f $ **FLOATING
C7107 a_42400_3493.t0 VSS 0.23527f $ **FLOATING
C7108 a_42628_3633.t0 VSS 0.10861f $ **FLOATING
C7109 a_42628_3633.t1 VSS 0.1094f $ **FLOATING
C7110 a_42628_3633.n0 VSS 0.47589f $ **FLOATING
C7111 a_42628_3633.t2 VSS 0.21808f $ **FLOATING
C7112 a_43201_3694.t0 VSS 0.08718f $ **FLOATING
C7113 a_43201_3694.t2 VSS 0.28889f $ **FLOATING
C7114 a_43201_3694.t1 VSS 0.13908f $ **FLOATING
C7115 a_43201_3694.n0 VSS 0.3269f $ **FLOATING
C7116 a_46225_3794.t0 VSS 0.07049f $ **FLOATING
C7117 a_46225_3794.t2 VSS 0.23668f $ **FLOATING
C7118 a_46225_3794.t1 VSS 0.11053f $ **FLOATING
C7119 a_46225_3794.n0 VSS 0.2942f $ **FLOATING
C7120 a_41430_3429.t0 VSS 0.4464f $ **FLOATING
C7121 a_41430_3429.t1 VSS 0.38794f $ **FLOATING
C7122 a_42306_3493.t0 VSS 0.37163f $ **FLOATING
C7123 a_42306_3493.t1 VSS 0.37297f $ **FLOATING
C7124 a_44289_3490.t3 VSS 0.0747f $ **FLOATING
C7125 a_44289_3490.t6 VSS 0.0747f $ **FLOATING
C7126 a_44289_3490.n0 VSS 0.12604f $ **FLOATING
C7127 a_44289_3490.t2 VSS 0.0747f $ **FLOATING
C7128 a_44289_3490.t7 VSS 0.0747f $ **FLOATING
C7129 a_44289_3490.n1 VSS 0.16173f $ **FLOATING
C7130 a_44289_3490.t1 VSS 0.0747f $ **FLOATING
C7131 a_44289_3490.t5 VSS 0.0747f $ **FLOATING
C7132 a_44289_3490.n2 VSS 0.16173f $ **FLOATING
C7133 a_44289_3490.t0 VSS 0.0747f $ **FLOATING
C7134 a_44289_3490.t4 VSS 0.0747f $ **FLOATING
C7135 a_44289_3490.n3 VSS 0.12604f $ **FLOATING
C7136 a_46319_3794.t0 VSS 0.02042f $ **FLOATING
C7137 a_46530_3398.t0 VSS 0.1332f $ **FLOATING
C7138 a_46530_3398.t1 VSS 0.20527f $ **FLOATING
C7139 a_46530_3398.n0 VSS 0.57563f $ **FLOATING
C7140 a_46530_3398.t2 VSS 0.28111f $ **FLOATING
C7141 a_46919_3714.t0 VSS 0.16211f $ **FLOATING
C7142 a_46919_3714.t3 VSS 0.18572f $ **FLOATING
C7143 a_46919_3714.t1 VSS 0.25438f $ **FLOATING
C7144 a_46919_3714.t2 VSS 0.25354f $ **FLOATING
C7145 a_46919_3714.n0 VSS 0.39526f $ **FLOATING
C7146 a_46919_3714.n1 VSS 0.36301f $ **FLOATING
C7147 a_47635_3639.t0 VSS 0.14673f $ **FLOATING
C7148 a_47635_3639.t1 VSS 0.14826f $ **FLOATING
C7149 a_47635_3639.t2 VSS 0.13697f $ **FLOATING
C7150 a_47635_3639.t3 VSS 0.31244f $ **FLOATING
C7151 a_47635_3639.n0 VSS 0.43828f $ **FLOATING
C7152 a_47635_3639.n1 VSS 0.34327f $ **FLOATING
C7153 a_47375_3416.t0 VSS 0.18251f $ **FLOATING
C7154 a_47375_3416.t1 VSS 0.18352f $ **FLOATING
C7155 a_47375_3416.n0 VSS 0.98672f $ **FLOATING
C7156 a_47375_3416.t2 VSS 0.1642f $ **FLOATING
C7157 a_47375_3416.n1 VSS 1.06968f $ **FLOATING
C7158 a_47375_3416.t3 VSS 0.17006f $ **FLOATING
C7159 a_47661_3734.t0 VSS 0.19144f $ **FLOATING
C7160 a_47661_3734.t4 VSS 0.24713f $ **FLOATING
C7161 a_47661_3734.n0 VSS 0.50762f $ **FLOATING
C7162 a_47661_3734.t2 VSS 0.26943f $ **FLOATING
C7163 a_47661_3734.t3 VSS 0.27168f $ **FLOATING
C7164 a_47661_3734.n1 VSS 0.81781f $ **FLOATING
C7165 a_47661_3734.t1 VSS 0.27573f $ **FLOATING
C7166 a_47661_3734.n2 VSS 0.49609f $ **FLOATING
C7167 a_48070_3673.t0 VSS 0.15491f $ **FLOATING
C7168 a_48070_3673.t3 VSS 0.60112f $ **FLOATING
C7169 a_48070_3673.n0 VSS 0.31834f $ **FLOATING
C7170 a_48070_3673.t1 VSS 0.22671f $ **FLOATING
C7171 a_48070_3673.n1 VSS 0.1803f $ **FLOATING
C7172 a_48070_3673.t2 VSS 0.25072f $ **FLOATING
C7173 a_48172_3760.t0 VSS 0.20064f $ **FLOATING
C7174 a_48172_3760.t3 VSS 0.28264f $ **FLOATING
C7175 a_48172_3760.n0 VSS 0.63451f $ **FLOATING
C7176 a_48172_3760.t1 VSS 0.30494f $ **FLOATING
C7177 a_48172_3760.t2 VSS 0.27266f $ **FLOATING
C7178 a_48172_3760.n1 VSS 0.34143f $ **FLOATING
C7179 a_46818_3417.t1 VSS 0.08429f $ **FLOATING
C7180 a_46818_3417.n0 VSS 0.26157f $ **FLOATING
C7181 a_46818_3417.t0 VSS 0.09028f $ **FLOATING
C7182 a_46818_3417.t2 VSS 0.09266f $ **FLOATING
C7183 a_48920_3493.t1 VSS 0.15513f $ **FLOATING
C7184 a_48920_3493.t2 VSS 0.78293f $ **FLOATING
C7185 a_48920_3493.n0 VSS 0.44013f $ **FLOATING
C7186 a_48920_3493.t0 VSS 0.23527f $ **FLOATING
C7187 a_49148_3633.t0 VSS 0.10861f $ **FLOATING
C7188 a_49148_3633.t1 VSS 0.1094f $ **FLOATING
C7189 a_49148_3633.n0 VSS 0.47589f $ **FLOATING
C7190 a_49148_3633.t2 VSS 0.21808f $ **FLOATING
C7191 a_49721_3694.t0 VSS 0.08718f $ **FLOATING
C7192 a_49721_3694.t2 VSS 0.28889f $ **FLOATING
C7193 a_49721_3694.t1 VSS 0.13908f $ **FLOATING
C7194 a_49721_3694.n0 VSS 0.3269f $ **FLOATING
C7195 a_47950_3429.t0 VSS 0.4464f $ **FLOATING
C7196 a_47950_3429.t1 VSS 0.38794f $ **FLOATING
C7197 a_48826_3493.t0 VSS 0.37163f $ **FLOATING
C7198 a_48826_3493.t1 VSS 0.37297f $ **FLOATING
C7199 a_50809_3490.t3 VSS 0.07465f $ **FLOATING
C7200 a_50809_3490.t6 VSS 0.07465f $ **FLOATING
C7201 a_50809_3490.n0 VSS 0.12595f $ **FLOATING
C7202 a_50809_3490.t2 VSS 0.07465f $ **FLOATING
C7203 a_50809_3490.t7 VSS 0.07465f $ **FLOATING
C7204 a_50809_3490.n1 VSS 0.16162f $ **FLOATING
C7205 a_50809_3490.t1 VSS 0.07465f $ **FLOATING
C7206 a_50809_3490.t5 VSS 0.07465f $ **FLOATING
C7207 a_50809_3490.n2 VSS 0.16162f $ **FLOATING
C7208 a_50809_3490.t0 VSS 0.07465f $ **FLOATING
C7209 a_50809_3490.t4 VSS 0.07465f $ **FLOATING
C7210 a_50809_3490.n3 VSS 0.12595f $ **FLOATING
C7211 a_n2951_2880.t0 VSS 0.10064f $ **FLOATING
C7212 a_n2951_2880.t2 VSS 0.33794f $ **FLOATING
C7213 a_n2951_2880.t1 VSS 0.15781f $ **FLOATING
C7214 a_n2951_2880.n0 VSS 0.42007f $ **FLOATING
C7215 a_n2347_2880.t0 VSS 0.10282f $ **FLOATING
C7216 a_n2347_2880.t2 VSS 0.34524f $ **FLOATING
C7217 a_n2347_2880.t1 VSS 0.16122f $ **FLOATING
C7218 a_n2347_2880.n0 VSS 0.42914f $ **FLOATING
C7219 a_n2857_2880.t0 VSS 0.03797f $ **FLOATING
C7220 a_n2253_2880.t0 VSS 0.02678f $ **FLOATING
C7221 a_n2951_1728.t0 VSS 0.10026f $ **FLOATING
C7222 a_n2951_1728.t2 VSS 0.33666f $ **FLOATING
C7223 a_n2951_1728.t1 VSS 0.15721f $ **FLOATING
C7224 a_n2951_1728.n0 VSS 0.41848f $ **FLOATING
C7225 a_n2646_1728.t0 VSS 0.16158f $ **FLOATING
C7226 a_n2646_1728.n0 VSS 0.54829f $ **FLOATING
C7227 a_n2646_1728.t2 VSS 0.28252f $ **FLOATING
C7228 a_n2646_1728.t1 VSS 0.24797f $ **FLOATING
C7229 a_n2342_2100.t1 VSS 0.11649f $ **FLOATING
C7230 a_n2342_2100.t2 VSS 0.38978f $ **FLOATING
C7231 a_n2342_2100.n0 VSS 0.44131f $ **FLOATING
C7232 a_n2342_2100.t0 VSS 0.16951f $ **FLOATING
C7233 a_n2857_1728.t0 VSS 0.03647f $ **FLOATING
C7234 a_3877_894.t0 VSS 0.0603f $ **FLOATING
C7235 a_3877_894.n0 VSS 0.63496f $ **FLOATING
C7236 a_3877_894.t2 VSS 0.43716f $ **FLOATING
C7237 a_3877_894.t1 VSS 0.09849f $ **FLOATING
C7238 a_10397_894.t0 VSS 0.06031f $ **FLOATING
C7239 a_10397_894.n0 VSS 0.63497f $ **FLOATING
C7240 a_10397_894.t2 VSS 0.43717f $ **FLOATING
C7241 a_10397_894.t1 VSS 0.0985f $ **FLOATING
C7242 a_4298_914.t0 VSS 0.06056f $ **FLOATING
C7243 a_4298_914.t1 VSS 0.09869f $ **FLOATING
C7244 a_4298_914.n0 VSS 0.62206f $ **FLOATING
C7245 a_4298_914.t2 VSS 0.26428f $ **FLOATING
C7246 a_16917_894.t0 VSS 0.0603f $ **FLOATING
C7247 a_16917_894.n0 VSS 0.63494f $ **FLOATING
C7248 a_16917_894.t2 VSS 0.43715f $ **FLOATING
C7249 a_16917_894.t1 VSS 0.09849f $ **FLOATING
C7250 a_10818_914.t0 VSS 0.06056f $ **FLOATING
C7251 a_10818_914.t1 VSS 0.09869f $ **FLOATING
C7252 a_10818_914.n0 VSS 0.62206f $ **FLOATING
C7253 a_10818_914.t2 VSS 0.26428f $ **FLOATING
C7254 a_23437_894.t0 VSS 0.06031f $ **FLOATING
C7255 a_23437_894.n0 VSS 0.63497f $ **FLOATING
C7256 a_23437_894.t2 VSS 0.43717f $ **FLOATING
C7257 a_23437_894.t1 VSS 0.0985f $ **FLOATING
C7258 a_17338_914.t0 VSS 0.06056f $ **FLOATING
C7259 a_17338_914.t1 VSS 0.09869f $ **FLOATING
C7260 a_17338_914.n0 VSS 0.62206f $ **FLOATING
C7261 a_17338_914.t2 VSS 0.26428f $ **FLOATING
C7262 a_29957_894.t0 VSS 0.0603f $ **FLOATING
C7263 a_29957_894.n0 VSS 0.63486f $ **FLOATING
C7264 a_29957_894.t2 VSS 0.43709f $ **FLOATING
C7265 a_29957_894.t1 VSS 0.09848f $ **FLOATING
C7266 a_23858_914.t0 VSS 0.06056f $ **FLOATING
C7267 a_23858_914.t1 VSS 0.09869f $ **FLOATING
C7268 a_23858_914.n0 VSS 0.62206f $ **FLOATING
C7269 a_23858_914.t2 VSS 0.26428f $ **FLOATING
C7270 a_36477_894.t0 VSS 0.0603f $ **FLOATING
C7271 a_36477_894.n0 VSS 0.63488f $ **FLOATING
C7272 a_36477_894.t2 VSS 0.43711f $ **FLOATING
C7273 a_36477_894.t1 VSS 0.09848f $ **FLOATING
C7274 a_30378_914.t0 VSS 0.06056f $ **FLOATING
C7275 a_30378_914.t1 VSS 0.09869f $ **FLOATING
C7276 a_30378_914.n0 VSS 0.62206f $ **FLOATING
C7277 a_30378_914.t2 VSS 0.26428f $ **FLOATING
C7278 a_42997_894.t0 VSS 0.06029f $ **FLOATING
C7279 a_42997_894.n0 VSS 0.6348f $ **FLOATING
C7280 a_42997_894.t2 VSS 0.43705f $ **FLOATING
C7281 a_42997_894.t1 VSS 0.09847f $ **FLOATING
C7282 a_36898_914.t0 VSS 0.06056f $ **FLOATING
C7283 a_36898_914.t1 VSS 0.09869f $ **FLOATING
C7284 a_36898_914.n0 VSS 0.62206f $ **FLOATING
C7285 a_36898_914.t2 VSS 0.26428f $ **FLOATING
C7286 a_49517_894.t0 VSS 0.06028f $ **FLOATING
C7287 a_49517_894.n0 VSS 0.63474f $ **FLOATING
C7288 a_49517_894.t2 VSS 0.43701f $ **FLOATING
C7289 a_49517_894.t1 VSS 0.09846f $ **FLOATING
C7290 a_43418_914.t0 VSS 0.06056f $ **FLOATING
C7291 a_43418_914.t1 VSS 0.09868f $ **FLOATING
C7292 a_43418_914.n0 VSS 0.62199f $ **FLOATING
C7293 a_43418_914.t2 VSS 0.26425f $ **FLOATING
C7294 a_49938_914.t0 VSS 0.06056f $ **FLOATING
C7295 a_49938_914.t1 VSS 0.09869f $ **FLOATING
C7296 a_49938_914.n0 VSS 0.62205f $ **FLOATING
C7297 a_49938_914.t2 VSS 0.26428f $ **FLOATING
C7298 a_n2946_1036.t0 VSS 0.12219f $ **FLOATING
C7299 a_n2946_1036.t2 VSS 0.40887f $ **FLOATING
C7300 a_n2946_1036.n0 VSS 0.46292f $ **FLOATING
C7301 a_n2946_1036.t1 VSS 0.17781f $ **FLOATING
C7302 a_n2648_1016.t0 VSS 0.14702f $ **FLOATING
C7303 a_n2648_1016.t1 VSS 0.22637f $ **FLOATING
C7304 a_n2648_1016.n0 VSS 0.62454f $ **FLOATING
C7305 a_n2648_1016.t2 VSS 0.27235f $ **FLOATING
C7306 a_n2347_1368.t0 VSS 0.09462f $ **FLOATING
C7307 a_n2347_1368.t2 VSS 0.31772f $ **FLOATING
C7308 a_n2347_1368.t1 VSS 0.14837f $ **FLOATING
C7309 a_n2347_1368.n0 VSS 0.39494f $ **FLOATING
C7310 a_n2253_1368.t0 VSS 0.03018f $ **FLOATING
C7311 a_n2852_1036.t0 VSS 0.02049f $ **FLOATING
C7312 a_5003_950.t9 VSS 0.12814f $ **FLOATING
C7313 a_5003_950.t8 VSS 0.1274f $ **FLOATING
C7314 a_5003_950.n0 VSS 0.31234f $ **FLOATING
C7315 a_5003_950.t6 VSS 0.09876f $ **FLOATING
C7316 a_5003_950.n1 VSS 0.38031f $ **FLOATING
C7317 a_5003_950.t4 VSS 0.09649f $ **FLOATING
C7318 a_5003_950.n2 VSS 0.33099f $ **FLOATING
C7319 a_5003_950.t0 VSS 0.11079f $ **FLOATING
C7320 a_5003_950.t5 VSS 0.09649f $ **FLOATING
C7321 a_5003_950.n3 VSS 0.33099f $ **FLOATING
C7322 a_5003_950.t1 VSS 0.11079f $ **FLOATING
C7323 a_5003_950.t2 VSS 0.14547f $ **FLOATING
C7324 a_5003_950.t7 VSS 0.12814f $ **FLOATING
C7325 a_5003_950.n4 VSS 0.34632f $ **FLOATING
C7326 a_5003_950.t3 VSS 0.14547f $ **FLOATING
C7327 a_5003_950.n5 VSS 0.34632f $ **FLOATING
C7328 a_11523_950.t9 VSS 0.12815f $ **FLOATING
C7329 a_11523_950.t8 VSS 0.12741f $ **FLOATING
C7330 a_11523_950.n0 VSS 0.31235f $ **FLOATING
C7331 a_11523_950.t6 VSS 0.09877f $ **FLOATING
C7332 a_11523_950.n1 VSS 0.38032f $ **FLOATING
C7333 a_11523_950.t4 VSS 0.09649f $ **FLOATING
C7334 a_11523_950.n2 VSS 0.331f $ **FLOATING
C7335 a_11523_950.t0 VSS 0.11079f $ **FLOATING
C7336 a_11523_950.t5 VSS 0.09649f $ **FLOATING
C7337 a_11523_950.n3 VSS 0.331f $ **FLOATING
C7338 a_11523_950.t1 VSS 0.11079f $ **FLOATING
C7339 a_11523_950.t2 VSS 0.14547f $ **FLOATING
C7340 a_11523_950.t7 VSS 0.12815f $ **FLOATING
C7341 a_11523_950.n4 VSS 0.34634f $ **FLOATING
C7342 a_11523_950.t3 VSS 0.14547f $ **FLOATING
C7343 a_11523_950.n5 VSS 0.34634f $ **FLOATING
C7344 a_18043_950.t9 VSS 0.12814f $ **FLOATING
C7345 a_18043_950.t8 VSS 0.1274f $ **FLOATING
C7346 a_18043_950.n0 VSS 0.31233f $ **FLOATING
C7347 a_18043_950.t6 VSS 0.09876f $ **FLOATING
C7348 a_18043_950.n1 VSS 0.3803f $ **FLOATING
C7349 a_18043_950.t4 VSS 0.09649f $ **FLOATING
C7350 a_18043_950.n2 VSS 0.33098f $ **FLOATING
C7351 a_18043_950.t0 VSS 0.11079f $ **FLOATING
C7352 a_18043_950.t5 VSS 0.09649f $ **FLOATING
C7353 a_18043_950.n3 VSS 0.33098f $ **FLOATING
C7354 a_18043_950.t1 VSS 0.11079f $ **FLOATING
C7355 a_18043_950.t2 VSS 0.14547f $ **FLOATING
C7356 a_18043_950.t7 VSS 0.12814f $ **FLOATING
C7357 a_18043_950.n4 VSS 0.34632f $ **FLOATING
C7358 a_18043_950.t3 VSS 0.14547f $ **FLOATING
C7359 a_18043_950.n5 VSS 0.34632f $ **FLOATING
C7360 a_24563_950.t9 VSS 0.12815f $ **FLOATING
C7361 a_24563_950.t8 VSS 0.1274f $ **FLOATING
C7362 a_24563_950.n0 VSS 0.31235f $ **FLOATING
C7363 a_24563_950.t6 VSS 0.09876f $ **FLOATING
C7364 a_24563_950.n1 VSS 0.38031f $ **FLOATING
C7365 a_24563_950.t4 VSS 0.09649f $ **FLOATING
C7366 a_24563_950.n2 VSS 0.33099f $ **FLOATING
C7367 a_24563_950.t0 VSS 0.11079f $ **FLOATING
C7368 a_24563_950.t5 VSS 0.09649f $ **FLOATING
C7369 a_24563_950.n3 VSS 0.33099f $ **FLOATING
C7370 a_24563_950.t1 VSS 0.11079f $ **FLOATING
C7371 a_24563_950.t2 VSS 0.14547f $ **FLOATING
C7372 a_24563_950.t7 VSS 0.12815f $ **FLOATING
C7373 a_24563_950.n4 VSS 0.34633f $ **FLOATING
C7374 a_24563_950.t3 VSS 0.14547f $ **FLOATING
C7375 a_24563_950.n5 VSS 0.34633f $ **FLOATING
C7376 a_31083_950.t9 VSS 0.12814f $ **FLOATING
C7377 a_31083_950.t8 VSS 0.1274f $ **FLOATING
C7378 a_31083_950.n0 VSS 0.31232f $ **FLOATING
C7379 a_31083_950.t6 VSS 0.09876f $ **FLOATING
C7380 a_31083_950.n1 VSS 0.38029f $ **FLOATING
C7381 a_31083_950.t4 VSS 0.09648f $ **FLOATING
C7382 a_31083_950.n2 VSS 0.33097f $ **FLOATING
C7383 a_31083_950.t0 VSS 0.11078f $ **FLOATING
C7384 a_31083_950.t5 VSS 0.09648f $ **FLOATING
C7385 a_31083_950.n3 VSS 0.33097f $ **FLOATING
C7386 a_31083_950.t1 VSS 0.11078f $ **FLOATING
C7387 a_31083_950.t2 VSS 0.14546f $ **FLOATING
C7388 a_31083_950.t7 VSS 0.12814f $ **FLOATING
C7389 a_31083_950.n4 VSS 0.34631f $ **FLOATING
C7390 a_31083_950.t3 VSS 0.14546f $ **FLOATING
C7391 a_31083_950.n5 VSS 0.34631f $ **FLOATING
C7392 a_37603_950.t9 VSS 0.12814f $ **FLOATING
C7393 a_37603_950.t8 VSS 0.1274f $ **FLOATING
C7394 a_37603_950.n0 VSS 0.31233f $ **FLOATING
C7395 a_37603_950.t6 VSS 0.09876f $ **FLOATING
C7396 a_37603_950.n1 VSS 0.38029f $ **FLOATING
C7397 a_37603_950.t4 VSS 0.09649f $ **FLOATING
C7398 a_37603_950.n2 VSS 0.33098f $ **FLOATING
C7399 a_37603_950.t0 VSS 0.11078f $ **FLOATING
C7400 a_37603_950.t5 VSS 0.09649f $ **FLOATING
C7401 a_37603_950.n3 VSS 0.33098f $ **FLOATING
C7402 a_37603_950.t1 VSS 0.11078f $ **FLOATING
C7403 a_37603_950.t2 VSS 0.14546f $ **FLOATING
C7404 a_37603_950.t7 VSS 0.12814f $ **FLOATING
C7405 a_37603_950.n4 VSS 0.34631f $ **FLOATING
C7406 a_37603_950.t3 VSS 0.14546f $ **FLOATING
C7407 a_37603_950.n5 VSS 0.34631f $ **FLOATING
C7408 a_44123_950.t9 VSS 0.1278f $ **FLOATING
C7409 a_44123_950.t8 VSS 0.12706f $ **FLOATING
C7410 a_44123_950.n0 VSS 0.3115f $ **FLOATING
C7411 a_44123_950.t6 VSS 0.0985f $ **FLOATING
C7412 a_44123_950.n1 VSS 0.37929f $ **FLOATING
C7413 a_44123_950.t4 VSS 0.09623f $ **FLOATING
C7414 a_44123_950.n2 VSS 0.3301f $ **FLOATING
C7415 a_44123_950.t0 VSS 0.11049f $ **FLOATING
C7416 a_44123_950.t5 VSS 0.09623f $ **FLOATING
C7417 a_44123_950.n3 VSS 0.3301f $ **FLOATING
C7418 a_44123_950.t1 VSS 0.11049f $ **FLOATING
C7419 a_44123_950.t2 VSS 0.14508f $ **FLOATING
C7420 a_44123_950.t7 VSS 0.1278f $ **FLOATING
C7421 a_44123_950.n4 VSS 0.34539f $ **FLOATING
C7422 a_44123_950.t3 VSS 0.14508f $ **FLOATING
C7423 a_44123_950.n5 VSS 0.34539f $ **FLOATING
C7424 a_50643_950.t9 VSS 0.12774f $ **FLOATING
C7425 a_50643_950.t8 VSS 0.127f $ **FLOATING
C7426 a_50643_950.n0 VSS 0.31135f $ **FLOATING
C7427 a_50643_950.t6 VSS 0.09845f $ **FLOATING
C7428 a_50643_950.n1 VSS 0.3791f $ **FLOATING
C7429 a_50643_950.t4 VSS 0.09618f $ **FLOATING
C7430 a_50643_950.n2 VSS 0.32994f $ **FLOATING
C7431 a_50643_950.t0 VSS 0.11043f $ **FLOATING
C7432 a_50643_950.t5 VSS 0.09618f $ **FLOATING
C7433 a_50643_950.n3 VSS 0.32994f $ **FLOATING
C7434 a_50643_950.t1 VSS 0.11043f $ **FLOATING
C7435 a_50643_950.t2 VSS 0.14501f $ **FLOATING
C7436 a_50643_950.t7 VSS 0.12774f $ **FLOATING
C7437 a_50643_950.n4 VSS 0.34522f $ **FLOATING
C7438 a_50643_950.t3 VSS 0.14501f $ **FLOATING
C7439 a_50643_950.n5 VSS 0.34522f $ **FLOATING
C7440 a_585_994.t0 VSS 0.09088f $ **FLOATING
C7441 a_585_994.t2 VSS 0.30514f $ **FLOATING
C7442 a_585_994.t1 VSS 0.14249f $ **FLOATING
C7443 a_585_994.n0 VSS 0.3793f $ **FLOATING
C7444 a_679_994.t0 VSS 0.03715f $ **FLOATING
C7445 a_n2966_249.t0 VSS 0.13645f $ **FLOATING
C7446 a_n2966_249.t1 VSS 0.19101f $ **FLOATING
C7447 a_n2966_249.t2 VSS 0.48854f $ **FLOATING
C7448 a_n2966_249.n0 VSS 0.61111f $ **FLOATING
C7449 a_890_598.t0 VSS 0.13379f $ **FLOATING
C7450 a_890_598.t1 VSS 0.20617f $ **FLOATING
C7451 a_890_598.n0 VSS 0.57814f $ **FLOATING
C7452 a_890_598.t2 VSS 0.28233f $ **FLOATING
C7453 a_1279_914.t1 VSS 0.16134f $ **FLOATING
C7454 a_1279_914.t3 VSS 0.18483f $ **FLOATING
C7455 a_1279_914.t2 VSS 0.25317f $ **FLOATING
C7456 a_1279_914.t0 VSS 0.25233f $ **FLOATING
C7457 a_1279_914.n0 VSS 0.39338f $ **FLOATING
C7458 a_1279_914.n1 VSS 0.36128f $ **FLOATING
C7459 a_1995_839.t0 VSS 0.14776f $ **FLOATING
C7460 a_1995_839.t2 VSS 0.13651f $ **FLOATING
C7461 a_1995_839.t3 VSS 0.31138f $ **FLOATING
C7462 a_1995_839.n0 VSS 0.43679f $ **FLOATING
C7463 a_1995_839.n1 VSS 0.3421f $ **FLOATING
C7464 a_1995_839.t1 VSS 0.14623f $ **FLOATING
C7465 a_1735_616.t0 VSS 0.18196f $ **FLOATING
C7466 a_1735_616.t1 VSS 0.18296f $ **FLOATING
C7467 a_1735_616.n0 VSS 0.98371f $ **FLOATING
C7468 a_1735_616.t2 VSS 0.1637f $ **FLOATING
C7469 a_1735_616.n1 VSS 1.06642f $ **FLOATING
C7470 a_1735_616.t3 VSS 0.16955f $ **FLOATING
C7471 a_2021_934.t0 VSS 0.19076f $ **FLOATING
C7472 a_2021_934.t4 VSS 0.24625f $ **FLOATING
C7473 a_2021_934.n0 VSS 0.50581f $ **FLOATING
C7474 a_2021_934.t2 VSS 0.26847f $ **FLOATING
C7475 a_2021_934.t3 VSS 0.27072f $ **FLOATING
C7476 a_2021_934.n1 VSS 0.8149f $ **FLOATING
C7477 a_2021_934.t1 VSS 0.27475f $ **FLOATING
C7478 a_2021_934.n2 VSS 0.49432f $ **FLOATING
C7479 a_2430_873.t0 VSS 0.15384f $ **FLOATING
C7480 a_2430_873.t3 VSS 0.59696f $ **FLOATING
C7481 a_2430_873.n0 VSS 0.31614f $ **FLOATING
C7482 a_2430_873.t1 VSS 0.22514f $ **FLOATING
C7483 a_2430_873.n1 VSS 0.17906f $ **FLOATING
C7484 a_2430_873.t2 VSS 0.24899f $ **FLOATING
C7485 a_2532_960.t0 VSS 0.19976f $ **FLOATING
C7486 a_2532_960.t3 VSS 0.28139f $ **FLOATING
C7487 a_2532_960.n0 VSS 0.63171f $ **FLOATING
C7488 a_2532_960.t1 VSS 0.30359f $ **FLOATING
C7489 a_2532_960.t2 VSS 0.27146f $ **FLOATING
C7490 a_2532_960.n1 VSS 0.33992f $ **FLOATING
C7491 a_1178_617.t1 VSS 0.0902f $ **FLOATING
C7492 a_1178_617.t0 VSS 0.09259f $ **FLOATING
C7493 a_1178_617.t2 VSS 0.08422f $ **FLOATING
C7494 a_1178_617.n0 VSS 0.26136f $ **FLOATING
C7495 a_3280_693.t1 VSS 0.15394f $ **FLOATING
C7496 a_3280_693.t2 VSS 0.77691f $ **FLOATING
C7497 a_3280_693.n0 VSS 0.43675f $ **FLOATING
C7498 a_3280_693.t0 VSS 0.23346f $ **FLOATING
C7499 a_3508_833.t0 VSS 0.10883f $ **FLOATING
C7500 a_3508_833.t2 VSS 0.21694f $ **FLOATING
C7501 a_3508_833.t1 VSS 0.10805f $ **FLOATING
C7502 a_3508_833.n0 VSS 0.47342f $ **FLOATING
C7503 a_4081_894.t0 VSS 0.08632f $ **FLOATING
C7504 a_4081_894.t2 VSS 0.28604f $ **FLOATING
C7505 a_4081_894.t1 VSS 0.1377f $ **FLOATING
C7506 a_4081_894.n0 VSS 0.32367f $ **FLOATING
C7507 a_7105_994.t0 VSS 0.08882f $ **FLOATING
C7508 a_7105_994.t2 VSS 0.29825f $ **FLOATING
C7509 a_7105_994.t1 VSS 0.13927f $ **FLOATING
C7510 a_7105_994.n0 VSS 0.37073f $ **FLOATING
C7511 a_2310_629.t0 VSS 0.44537f $ **FLOATING
C7512 a_2310_629.t1 VSS 0.38705f $ **FLOATING
C7513 a_3186_693.t0 VSS 0.3709f $ **FLOATING
C7514 a_3186_693.t1 VSS 0.37223f $ **FLOATING
C7515 a_5169_690.t3 VSS 0.07427f $ **FLOATING
C7516 a_5169_690.t6 VSS 0.07427f $ **FLOATING
C7517 a_5169_690.n0 VSS 0.12531f $ **FLOATING
C7518 a_5169_690.t2 VSS 0.07427f $ **FLOATING
C7519 a_5169_690.t7 VSS 0.07427f $ **FLOATING
C7520 a_5169_690.n1 VSS 0.1608f $ **FLOATING
C7521 a_5169_690.t1 VSS 0.07427f $ **FLOATING
C7522 a_5169_690.t5 VSS 0.07427f $ **FLOATING
C7523 a_5169_690.n2 VSS 0.1608f $ **FLOATING
C7524 a_5169_690.t0 VSS 0.07427f $ **FLOATING
C7525 a_5169_690.t4 VSS 0.07427f $ **FLOATING
C7526 a_5169_690.n3 VSS 0.12531f $ **FLOATING
C7527 a_7199_994.t0 VSS 0.03717f $ **FLOATING
C7528 a_7410_598.t0 VSS 0.13377f $ **FLOATING
C7529 a_7410_598.t1 VSS 0.20615f $ **FLOATING
C7530 a_7410_598.n0 VSS 0.57809f $ **FLOATING
C7531 a_7410_598.t2 VSS 0.28231f $ **FLOATING
C7532 a_7799_914.t1 VSS 0.16111f $ **FLOATING
C7533 a_7799_914.t3 VSS 0.18457f $ **FLOATING
C7534 a_7799_914.t2 VSS 0.25281f $ **FLOATING
C7535 a_7799_914.t0 VSS 0.25198f $ **FLOATING
C7536 a_7799_914.n0 VSS 0.39282f $ **FLOATING
C7537 a_7799_914.n1 VSS 0.36077f $ **FLOATING
C7538 a_8515_839.t0 VSS 0.14622f $ **FLOATING
C7539 a_8515_839.t1 VSS 0.14775f $ **FLOATING
C7540 a_8515_839.t2 VSS 0.1365f $ **FLOATING
C7541 a_8515_839.t3 VSS 0.31137f $ **FLOATING
C7542 a_8515_839.n0 VSS 0.43677f $ **FLOATING
C7543 a_8515_839.n1 VSS 0.34208f $ **FLOATING
C7544 a_8255_616.t0 VSS 0.18195f $ **FLOATING
C7545 a_8255_616.t1 VSS 0.18295f $ **FLOATING
C7546 a_8255_616.n0 VSS 0.98364f $ **FLOATING
C7547 a_8255_616.t2 VSS 0.16369f $ **FLOATING
C7548 a_8255_616.n1 VSS 1.06634f $ **FLOATING
C7549 a_8255_616.t3 VSS 0.16953f $ **FLOATING
C7550 a_8541_934.t0 VSS 0.19074f $ **FLOATING
C7551 a_8541_934.t4 VSS 0.24624f $ **FLOATING
C7552 a_8541_934.n0 VSS 0.50578f $ **FLOATING
C7553 a_8541_934.t2 VSS 0.26845f $ **FLOATING
C7554 a_8541_934.t3 VSS 0.2707f $ **FLOATING
C7555 a_8541_934.n1 VSS 0.81485f $ **FLOATING
C7556 a_8541_934.t1 VSS 0.27473f $ **FLOATING
C7557 a_8541_934.n2 VSS 0.4943f $ **FLOATING
C7558 a_8950_873.t0 VSS 0.15384f $ **FLOATING
C7559 a_8950_873.t3 VSS 0.59694f $ **FLOATING
C7560 a_8950_873.n0 VSS 0.31613f $ **FLOATING
C7561 a_8950_873.t1 VSS 0.22513f $ **FLOATING
C7562 a_8950_873.n1 VSS 0.17905f $ **FLOATING
C7563 a_8950_873.t2 VSS 0.24898f $ **FLOATING
C7564 a_9052_960.t0 VSS 0.19975f $ **FLOATING
C7565 a_9052_960.t3 VSS 0.28138f $ **FLOATING
C7566 a_9052_960.n0 VSS 0.6317f $ **FLOATING
C7567 a_9052_960.t1 VSS 0.30358f $ **FLOATING
C7568 a_9052_960.t2 VSS 0.27145f $ **FLOATING
C7569 a_9052_960.n1 VSS 0.33991f $ **FLOATING
C7570 a_7698_617.t1 VSS 0.09003f $ **FLOATING
C7571 a_7698_617.t0 VSS 0.09241f $ **FLOATING
C7572 a_7698_617.t2 VSS 0.08405f $ **FLOATING
C7573 a_7698_617.n0 VSS 0.26085f $ **FLOATING
C7574 a_9800_693.t1 VSS 0.15394f $ **FLOATING
C7575 a_9800_693.t2 VSS 0.77691f $ **FLOATING
C7576 a_9800_693.n0 VSS 0.43675f $ **FLOATING
C7577 a_9800_693.t0 VSS 0.23346f $ **FLOATING
C7578 a_10028_833.t0 VSS 0.10805f $ **FLOATING
C7579 a_10028_833.t1 VSS 0.10883f $ **FLOATING
C7580 a_10028_833.n0 VSS 0.47342f $ **FLOATING
C7581 a_10028_833.t2 VSS 0.21694f $ **FLOATING
C7582 a_10601_894.t0 VSS 0.08632f $ **FLOATING
C7583 a_10601_894.t2 VSS 0.28604f $ **FLOATING
C7584 a_10601_894.t1 VSS 0.1377f $ **FLOATING
C7585 a_10601_894.n0 VSS 0.32367f $ **FLOATING
C7586 a_13625_994.t0 VSS 0.08896f $ **FLOATING
C7587 a_13625_994.t2 VSS 0.29869f $ **FLOATING
C7588 a_13625_994.t1 VSS 0.13948f $ **FLOATING
C7589 a_13625_994.n0 VSS 0.37128f $ **FLOATING
C7590 a_8830_629.t0 VSS 0.44536f $ **FLOATING
C7591 a_8830_629.t1 VSS 0.38703f $ **FLOATING
C7592 a_9706_693.t0 VSS 0.3709f $ **FLOATING
C7593 a_9706_693.t1 VSS 0.37223f $ **FLOATING
C7594 a_11689_690.t3 VSS 0.07427f $ **FLOATING
C7595 a_11689_690.t6 VSS 0.07427f $ **FLOATING
C7596 a_11689_690.n0 VSS 0.12532f $ **FLOATING
C7597 a_11689_690.t2 VSS 0.07427f $ **FLOATING
C7598 a_11689_690.t7 VSS 0.07427f $ **FLOATING
C7599 a_11689_690.n1 VSS 0.16081f $ **FLOATING
C7600 a_11689_690.t1 VSS 0.07427f $ **FLOATING
C7601 a_11689_690.t5 VSS 0.07427f $ **FLOATING
C7602 a_11689_690.n2 VSS 0.16081f $ **FLOATING
C7603 a_11689_690.t0 VSS 0.07427f $ **FLOATING
C7604 a_11689_690.t4 VSS 0.07427f $ **FLOATING
C7605 a_11689_690.n3 VSS 0.12532f $ **FLOATING
C7606 a_13719_994.t0 VSS 0.0372f $ **FLOATING
C7607 a_13930_598.t0 VSS 0.13392f $ **FLOATING
C7608 a_13930_598.t1 VSS 0.20638f $ **FLOATING
C7609 a_13930_598.n0 VSS 0.57872f $ **FLOATING
C7610 a_13930_598.t2 VSS 0.28262f $ **FLOATING
C7611 a_14319_914.t1 VSS 0.16088f $ **FLOATING
C7612 a_14319_914.t3 VSS 0.18431f $ **FLOATING
C7613 a_14319_914.t2 VSS 0.25245f $ **FLOATING
C7614 a_14319_914.t0 VSS 0.25162f $ **FLOATING
C7615 a_14319_914.n0 VSS 0.39227f $ **FLOATING
C7616 a_14319_914.n1 VSS 0.36026f $ **FLOATING
C7617 a_15035_839.t0 VSS 0.14774f $ **FLOATING
C7618 a_15035_839.t2 VSS 0.13649f $ **FLOATING
C7619 a_15035_839.t3 VSS 0.31135f $ **FLOATING
C7620 a_15035_839.n0 VSS 0.43674f $ **FLOATING
C7621 a_15035_839.n1 VSS 0.34206f $ **FLOATING
C7622 a_15035_839.t1 VSS 0.14622f $ **FLOATING
C7623 a_14775_616.t0 VSS 0.18293f $ **FLOATING
C7624 a_14775_616.t2 VSS 0.16368f $ **FLOATING
C7625 a_14775_616.n0 VSS 1.06626f $ **FLOATING
C7626 a_14775_616.t3 VSS 0.16952f $ **FLOATING
C7627 a_14775_616.t1 VSS 0.18193f $ **FLOATING
C7628 a_14775_616.n1 VSS 0.98357f $ **FLOATING
C7629 a_15061_934.t0 VSS 0.19073f $ **FLOATING
C7630 a_15061_934.t4 VSS 0.24623f $ **FLOATING
C7631 a_15061_934.n0 VSS 0.50575f $ **FLOATING
C7632 a_15061_934.t2 VSS 0.26844f $ **FLOATING
C7633 a_15061_934.t3 VSS 0.27068f $ **FLOATING
C7634 a_15061_934.n1 VSS 0.8148f $ **FLOATING
C7635 a_15061_934.t1 VSS 0.27472f $ **FLOATING
C7636 a_15061_934.n2 VSS 0.49427f $ **FLOATING
C7637 a_15470_873.t0 VSS 0.15382f $ **FLOATING
C7638 a_15470_873.t3 VSS 0.59689f $ **FLOATING
C7639 a_15470_873.n0 VSS 0.3161f $ **FLOATING
C7640 a_15470_873.t1 VSS 0.22511f $ **FLOATING
C7641 a_15470_873.n1 VSS 0.17904f $ **FLOATING
C7642 a_15470_873.t2 VSS 0.24896f $ **FLOATING
C7643 a_15572_960.t0 VSS 0.19975f $ **FLOATING
C7644 a_15572_960.t3 VSS 0.28138f $ **FLOATING
C7645 a_15572_960.n0 VSS 0.63168f $ **FLOATING
C7646 a_15572_960.t1 VSS 0.30358f $ **FLOATING
C7647 a_15572_960.t2 VSS 0.27145f $ **FLOATING
C7648 a_15572_960.n1 VSS 0.33991f $ **FLOATING
C7649 a_14218_617.t1 VSS 0.08982f $ **FLOATING
C7650 a_14218_617.t0 VSS 0.0922f $ **FLOATING
C7651 a_14218_617.t2 VSS 0.08386f $ **FLOATING
C7652 a_14218_617.n0 VSS 0.26026f $ **FLOATING
C7653 a_16320_693.t1 VSS 0.15394f $ **FLOATING
C7654 a_16320_693.t2 VSS 0.77691f $ **FLOATING
C7655 a_16320_693.n0 VSS 0.43675f $ **FLOATING
C7656 a_16320_693.t0 VSS 0.23346f $ **FLOATING
C7657 a_16548_833.t0 VSS 0.10805f $ **FLOATING
C7658 a_16548_833.t1 VSS 0.10883f $ **FLOATING
C7659 a_16548_833.n0 VSS 0.47342f $ **FLOATING
C7660 a_16548_833.t2 VSS 0.21694f $ **FLOATING
C7661 a_17121_894.t0 VSS 0.08632f $ **FLOATING
C7662 a_17121_894.t2 VSS 0.28604f $ **FLOATING
C7663 a_17121_894.t1 VSS 0.1377f $ **FLOATING
C7664 a_17121_894.n0 VSS 0.32367f $ **FLOATING
C7665 a_20145_994.t0 VSS 0.0888f $ **FLOATING
C7666 a_20145_994.t2 VSS 0.29818f $ **FLOATING
C7667 a_20145_994.t1 VSS 0.13924f $ **FLOATING
C7668 a_20145_994.n0 VSS 0.37065f $ **FLOATING
C7669 a_15350_629.t0 VSS 0.44535f $ **FLOATING
C7670 a_15350_629.t1 VSS 0.38702f $ **FLOATING
C7671 a_16226_693.t0 VSS 0.3709f $ **FLOATING
C7672 a_16226_693.t1 VSS 0.37223f $ **FLOATING
C7673 a_18209_690.t3 VSS 0.07427f $ **FLOATING
C7674 a_18209_690.t6 VSS 0.07427f $ **FLOATING
C7675 a_18209_690.n0 VSS 0.12531f $ **FLOATING
C7676 a_18209_690.t2 VSS 0.07427f $ **FLOATING
C7677 a_18209_690.t7 VSS 0.07427f $ **FLOATING
C7678 a_18209_690.n1 VSS 0.1608f $ **FLOATING
C7679 a_18209_690.t1 VSS 0.07427f $ **FLOATING
C7680 a_18209_690.t5 VSS 0.07427f $ **FLOATING
C7681 a_18209_690.n2 VSS 0.1608f $ **FLOATING
C7682 a_18209_690.t0 VSS 0.07427f $ **FLOATING
C7683 a_18209_690.t4 VSS 0.07427f $ **FLOATING
C7684 a_18209_690.n3 VSS 0.12531f $ **FLOATING
C7685 a_20239_994.t0 VSS 0.03716f $ **FLOATING
C7686 a_20450_598.t0 VSS 0.13383f $ **FLOATING
C7687 a_20450_598.t1 VSS 0.20623f $ **FLOATING
C7688 a_20450_598.n0 VSS 0.57832f $ **FLOATING
C7689 a_20450_598.t2 VSS 0.28242f $ **FLOATING
C7690 a_20839_914.t1 VSS 0.16122f $ **FLOATING
C7691 a_20839_914.t3 VSS 0.1847f $ **FLOATING
C7692 a_20839_914.t2 VSS 0.25299f $ **FLOATING
C7693 a_20839_914.t0 VSS 0.25215f $ **FLOATING
C7694 a_20839_914.n0 VSS 0.3931f $ **FLOATING
C7695 a_20839_914.n1 VSS 0.36103f $ **FLOATING
C7696 a_21555_839.t0 VSS 0.14775f $ **FLOATING
C7697 a_21555_839.t2 VSS 0.1365f $ **FLOATING
C7698 a_21555_839.t3 VSS 0.31137f $ **FLOATING
C7699 a_21555_839.n0 VSS 0.43678f $ **FLOATING
C7700 a_21555_839.n1 VSS 0.34209f $ **FLOATING
C7701 a_21555_839.t1 VSS 0.14623f $ **FLOATING
C7702 a_21295_616.t0 VSS 0.18295f $ **FLOATING
C7703 a_21295_616.t3 VSS 0.1637f $ **FLOATING
C7704 a_21295_616.n0 VSS 1.06638f $ **FLOATING
C7705 a_21295_616.t2 VSS 0.16954f $ **FLOATING
C7706 a_21295_616.t1 VSS 0.18195f $ **FLOATING
C7707 a_21295_616.n1 VSS 0.98367f $ **FLOATING
C7708 a_21581_934.t0 VSS 0.19075f $ **FLOATING
C7709 a_21581_934.t4 VSS 0.24625f $ **FLOATING
C7710 a_21581_934.n0 VSS 0.5058f $ **FLOATING
C7711 a_21581_934.t3 VSS 0.26846f $ **FLOATING
C7712 a_21581_934.t2 VSS 0.27071f $ **FLOATING
C7713 a_21581_934.n1 VSS 0.81487f $ **FLOATING
C7714 a_21581_934.t1 VSS 0.27474f $ **FLOATING
C7715 a_21581_934.n2 VSS 0.49431f $ **FLOATING
C7716 a_21990_873.t0 VSS 0.15384f $ **FLOATING
C7717 a_21990_873.t3 VSS 0.59695f $ **FLOATING
C7718 a_21990_873.n0 VSS 0.31613f $ **FLOATING
C7719 a_21990_873.t1 VSS 0.22513f $ **FLOATING
C7720 a_21990_873.n1 VSS 0.17905f $ **FLOATING
C7721 a_21990_873.t2 VSS 0.24898f $ **FLOATING
C7722 a_22092_960.t0 VSS 0.19976f $ **FLOATING
C7723 a_22092_960.t3 VSS 0.28139f $ **FLOATING
C7724 a_22092_960.n0 VSS 0.6317f $ **FLOATING
C7725 a_22092_960.t1 VSS 0.30359f $ **FLOATING
C7726 a_22092_960.t2 VSS 0.27145f $ **FLOATING
C7727 a_22092_960.n1 VSS 0.33992f $ **FLOATING
C7728 a_20738_617.t1 VSS 0.09015f $ **FLOATING
C7729 a_20738_617.t0 VSS 0.09253f $ **FLOATING
C7730 a_20738_617.t2 VSS 0.08417f $ **FLOATING
C7731 a_20738_617.n0 VSS 0.2612f $ **FLOATING
C7732 a_22840_693.t1 VSS 0.15394f $ **FLOATING
C7733 a_22840_693.t2 VSS 0.77691f $ **FLOATING
C7734 a_22840_693.n0 VSS 0.43675f $ **FLOATING
C7735 a_22840_693.t0 VSS 0.23346f $ **FLOATING
C7736 a_23068_833.t0 VSS 0.10805f $ **FLOATING
C7737 a_23068_833.t1 VSS 0.10883f $ **FLOATING
C7738 a_23068_833.n0 VSS 0.47342f $ **FLOATING
C7739 a_23068_833.t2 VSS 0.21694f $ **FLOATING
C7740 a_23641_894.t0 VSS 0.08632f $ **FLOATING
C7741 a_23641_894.t2 VSS 0.28604f $ **FLOATING
C7742 a_23641_894.t1 VSS 0.1377f $ **FLOATING
C7743 a_23641_894.n0 VSS 0.32367f $ **FLOATING
C7744 a_26665_994.t0 VSS 0.08884f $ **FLOATING
C7745 a_26665_994.t2 VSS 0.29832f $ **FLOATING
C7746 a_26665_994.t1 VSS 0.13931f $ **FLOATING
C7747 a_26665_994.n0 VSS 0.37081f $ **FLOATING
C7748 a_21870_629.t0 VSS 0.44537f $ **FLOATING
C7749 a_21870_629.t1 VSS 0.38704f $ **FLOATING
C7750 a_22746_693.t0 VSS 0.3709f $ **FLOATING
C7751 a_22746_693.t1 VSS 0.37223f $ **FLOATING
C7752 a_24729_690.t3 VSS 0.07427f $ **FLOATING
C7753 a_24729_690.t6 VSS 0.07427f $ **FLOATING
C7754 a_24729_690.n0 VSS 0.12532f $ **FLOATING
C7755 a_24729_690.t2 VSS 0.07427f $ **FLOATING
C7756 a_24729_690.t7 VSS 0.07427f $ **FLOATING
C7757 a_24729_690.n1 VSS 0.16081f $ **FLOATING
C7758 a_24729_690.t1 VSS 0.07427f $ **FLOATING
C7759 a_24729_690.t5 VSS 0.07427f $ **FLOATING
C7760 a_24729_690.n2 VSS 0.16081f $ **FLOATING
C7761 a_24729_690.t0 VSS 0.07427f $ **FLOATING
C7762 a_24729_690.t4 VSS 0.07427f $ **FLOATING
C7763 a_24729_690.n3 VSS 0.12532f $ **FLOATING
C7764 a_26759_994.t0 VSS 0.03718f $ **FLOATING
C7765 a_26970_598.t0 VSS 0.13385f $ **FLOATING
C7766 a_26970_598.t1 VSS 0.20627f $ **FLOATING
C7767 a_26970_598.n0 VSS 0.57842f $ **FLOATING
C7768 a_26970_598.t2 VSS 0.28247f $ **FLOATING
C7769 a_27359_914.t1 VSS 0.16099f $ **FLOATING
C7770 a_27359_914.t3 VSS 0.18444f $ **FLOATING
C7771 a_27359_914.t2 VSS 0.25264f $ **FLOATING
C7772 a_27359_914.t0 VSS 0.2518f $ **FLOATING
C7773 a_27359_914.n0 VSS 0.39255f $ **FLOATING
C7774 a_27359_914.n1 VSS 0.36052f $ **FLOATING
C7775 a_28075_839.t0 VSS 0.14622f $ **FLOATING
C7776 a_28075_839.t1 VSS 0.14774f $ **FLOATING
C7777 a_28075_839.t2 VSS 0.13649f $ **FLOATING
C7778 a_28075_839.t3 VSS 0.31136f $ **FLOATING
C7779 a_28075_839.n0 VSS 0.43676f $ **FLOATING
C7780 a_28075_839.n1 VSS 0.34207f $ **FLOATING
C7781 a_27815_616.t0 VSS 0.18194f $ **FLOATING
C7782 a_27815_616.t1 VSS 0.18294f $ **FLOATING
C7783 a_27815_616.n0 VSS 0.9836f $ **FLOATING
C7784 a_27815_616.t2 VSS 0.16368f $ **FLOATING
C7785 a_27815_616.n1 VSS 1.0663f $ **FLOATING
C7786 a_27815_616.t3 VSS 0.16953f $ **FLOATING
C7787 a_28101_934.t0 VSS 0.19074f $ **FLOATING
C7788 a_28101_934.t4 VSS 0.24623f $ **FLOATING
C7789 a_28101_934.n0 VSS 0.50577f $ **FLOATING
C7790 a_28101_934.t2 VSS 0.26845f $ **FLOATING
C7791 a_28101_934.t3 VSS 0.27069f $ **FLOATING
C7792 a_28101_934.n1 VSS 0.81483f $ **FLOATING
C7793 a_28101_934.t1 VSS 0.27472f $ **FLOATING
C7794 a_28101_934.n2 VSS 0.49428f $ **FLOATING
C7795 a_28510_873.t0 VSS 0.15383f $ **FLOATING
C7796 a_28510_873.t3 VSS 0.59691f $ **FLOATING
C7797 a_28510_873.n0 VSS 0.31611f $ **FLOATING
C7798 a_28510_873.t1 VSS 0.22512f $ **FLOATING
C7799 a_28510_873.n1 VSS 0.17904f $ **FLOATING
C7800 a_28510_873.t2 VSS 0.24897f $ **FLOATING
C7801 a_28612_960.t0 VSS 0.19975f $ **FLOATING
C7802 a_28612_960.t3 VSS 0.28138f $ **FLOATING
C7803 a_28612_960.n0 VSS 0.63169f $ **FLOATING
C7804 a_28612_960.t1 VSS 0.30358f $ **FLOATING
C7805 a_28612_960.t2 VSS 0.27145f $ **FLOATING
C7806 a_28612_960.n1 VSS 0.33991f $ **FLOATING
C7807 a_27258_617.t1 VSS 0.08991f $ **FLOATING
C7808 a_27258_617.t0 VSS 0.09229f $ **FLOATING
C7809 a_27258_617.t2 VSS 0.08395f $ **FLOATING
C7810 a_27258_617.n0 VSS 0.26052f $ **FLOATING
C7811 a_29360_693.t1 VSS 0.15394f $ **FLOATING
C7812 a_29360_693.t2 VSS 0.77691f $ **FLOATING
C7813 a_29360_693.n0 VSS 0.43675f $ **FLOATING
C7814 a_29360_693.t0 VSS 0.23346f $ **FLOATING
C7815 a_29588_833.t0 VSS 0.10805f $ **FLOATING
C7816 a_29588_833.t1 VSS 0.10883f $ **FLOATING
C7817 a_29588_833.n0 VSS 0.47342f $ **FLOATING
C7818 a_29588_833.t2 VSS 0.21694f $ **FLOATING
C7819 a_30161_894.t0 VSS 0.08632f $ **FLOATING
C7820 a_30161_894.t2 VSS 0.28604f $ **FLOATING
C7821 a_30161_894.t1 VSS 0.1377f $ **FLOATING
C7822 a_30161_894.n0 VSS 0.32367f $ **FLOATING
C7823 a_33185_994.t0 VSS 0.08874f $ **FLOATING
C7824 a_33185_994.t2 VSS 0.29796f $ **FLOATING
C7825 a_33185_994.t1 VSS 0.13914f $ **FLOATING
C7826 a_33185_994.n0 VSS 0.37037f $ **FLOATING
C7827 a_28390_629.t0 VSS 0.44535f $ **FLOATING
C7828 a_28390_629.t1 VSS 0.38703f $ **FLOATING
C7829 a_29266_693.t0 VSS 0.3709f $ **FLOATING
C7830 a_29266_693.t1 VSS 0.37223f $ **FLOATING
C7831 a_31249_690.t3 VSS 0.07427f $ **FLOATING
C7832 a_31249_690.t6 VSS 0.07427f $ **FLOATING
C7833 a_31249_690.n0 VSS 0.12531f $ **FLOATING
C7834 a_31249_690.t2 VSS 0.07427f $ **FLOATING
C7835 a_31249_690.t7 VSS 0.07427f $ **FLOATING
C7836 a_31249_690.n1 VSS 0.16079f $ **FLOATING
C7837 a_31249_690.t1 VSS 0.07427f $ **FLOATING
C7838 a_31249_690.t5 VSS 0.07427f $ **FLOATING
C7839 a_31249_690.n2 VSS 0.16079f $ **FLOATING
C7840 a_31249_690.t0 VSS 0.07427f $ **FLOATING
C7841 a_31249_690.t4 VSS 0.07427f $ **FLOATING
C7842 a_31249_690.n3 VSS 0.1253f $ **FLOATING
C7843 a_33279_994.t0 VSS 0.03712f $ **FLOATING
C7844 a_33490_598.t0 VSS 0.13427f $ **FLOATING
C7845 a_33490_598.t1 VSS 0.20692f $ **FLOATING
C7846 a_33490_598.n0 VSS 0.58024f $ **FLOATING
C7847 a_33490_598.t2 VSS 0.28336f $ **FLOATING
C7848 a_33879_914.t1 VSS 0.16179f $ **FLOATING
C7849 a_33879_914.t3 VSS 0.18535f $ **FLOATING
C7850 a_33879_914.t2 VSS 0.25387f $ **FLOATING
C7851 a_33879_914.t0 VSS 0.25303f $ **FLOATING
C7852 a_33879_914.n0 VSS 0.39447f $ **FLOATING
C7853 a_33879_914.n1 VSS 0.36229f $ **FLOATING
C7854 a_34595_839.t0 VSS 0.14625f $ **FLOATING
C7855 a_34595_839.t1 VSS 0.14777f $ **FLOATING
C7856 a_34595_839.t2 VSS 0.13652f $ **FLOATING
C7857 a_34595_839.t3 VSS 0.31141f $ **FLOATING
C7858 a_34595_839.n0 VSS 0.43683f $ **FLOATING
C7859 a_34595_839.n1 VSS 0.34213f $ **FLOATING
C7860 a_34335_616.t0 VSS 0.18198f $ **FLOATING
C7861 a_34335_616.t1 VSS 0.18298f $ **FLOATING
C7862 a_34335_616.n0 VSS 0.98383f $ **FLOATING
C7863 a_34335_616.t2 VSS 0.16372f $ **FLOATING
C7864 a_34335_616.n1 VSS 1.06655f $ **FLOATING
C7865 a_34335_616.t3 VSS 0.16957f $ **FLOATING
C7866 a_34621_934.t0 VSS 0.19077f $ **FLOATING
C7867 a_34621_934.t4 VSS 0.24628f $ **FLOATING
C7868 a_34621_934.n0 VSS 0.50586f $ **FLOATING
C7869 a_34621_934.t2 VSS 0.2685f $ **FLOATING
C7870 a_34621_934.t3 VSS 0.27074f $ **FLOATING
C7871 a_34621_934.n1 VSS 0.81497f $ **FLOATING
C7872 a_34621_934.t1 VSS 0.27477f $ **FLOATING
C7873 a_34621_934.n2 VSS 0.49437f $ **FLOATING
C7874 a_35030_873.t0 VSS 0.15385f $ **FLOATING
C7875 a_35030_873.t3 VSS 0.59699f $ **FLOATING
C7876 a_35030_873.n0 VSS 0.31615f $ **FLOATING
C7877 a_35030_873.t1 VSS 0.22515f $ **FLOATING
C7878 a_35030_873.n1 VSS 0.17907f $ **FLOATING
C7879 a_35030_873.t2 VSS 0.249f $ **FLOATING
C7880 a_35132_960.t0 VSS 0.19977f $ **FLOATING
C7881 a_35132_960.t3 VSS 0.2814f $ **FLOATING
C7882 a_35132_960.n0 VSS 0.63173f $ **FLOATING
C7883 a_35132_960.t1 VSS 0.3036f $ **FLOATING
C7884 a_35132_960.t2 VSS 0.27147f $ **FLOATING
C7885 a_35132_960.n1 VSS 0.33993f $ **FLOATING
C7886 a_33778_617.t1 VSS 0.09063f $ **FLOATING
C7887 a_33778_617.t0 VSS 0.09303f $ **FLOATING
C7888 a_33778_617.t2 VSS 0.08462f $ **FLOATING
C7889 a_33778_617.n0 VSS 0.26261f $ **FLOATING
C7890 a_35880_693.t1 VSS 0.15394f $ **FLOATING
C7891 a_35880_693.t2 VSS 0.77691f $ **FLOATING
C7892 a_35880_693.n0 VSS 0.43675f $ **FLOATING
C7893 a_35880_693.t0 VSS 0.23346f $ **FLOATING
C7894 a_36108_833.t0 VSS 0.10805f $ **FLOATING
C7895 a_36108_833.t1 VSS 0.10883f $ **FLOATING
C7896 a_36108_833.n0 VSS 0.47342f $ **FLOATING
C7897 a_36108_833.t2 VSS 0.21694f $ **FLOATING
C7898 a_36681_894.t0 VSS 0.08632f $ **FLOATING
C7899 a_36681_894.t2 VSS 0.28604f $ **FLOATING
C7900 a_36681_894.t1 VSS 0.1377f $ **FLOATING
C7901 a_36681_894.n0 VSS 0.32367f $ **FLOATING
C7902 a_39705_994.t0 VSS 0.08877f $ **FLOATING
C7903 a_39705_994.t2 VSS 0.29807f $ **FLOATING
C7904 a_39705_994.t1 VSS 0.13919f $ **FLOATING
C7905 a_39705_994.n0 VSS 0.37051f $ **FLOATING
C7906 a_34910_629.t0 VSS 0.44539f $ **FLOATING
C7907 a_34910_629.t1 VSS 0.38706f $ **FLOATING
C7908 a_35786_693.t0 VSS 0.3709f $ **FLOATING
C7909 a_35786_693.t1 VSS 0.37223f $ **FLOATING
C7910 a_37769_690.t3 VSS 0.07427f $ **FLOATING
C7911 a_37769_690.t6 VSS 0.07427f $ **FLOATING
C7912 a_37769_690.n0 VSS 0.12531f $ **FLOATING
C7913 a_37769_690.t2 VSS 0.07427f $ **FLOATING
C7914 a_37769_690.t7 VSS 0.07427f $ **FLOATING
C7915 a_37769_690.n1 VSS 0.1608f $ **FLOATING
C7916 a_37769_690.t1 VSS 0.07427f $ **FLOATING
C7917 a_37769_690.t5 VSS 0.07427f $ **FLOATING
C7918 a_37769_690.n2 VSS 0.1608f $ **FLOATING
C7919 a_37769_690.t0 VSS 0.07427f $ **FLOATING
C7920 a_37769_690.t4 VSS 0.07427f $ **FLOATING
C7921 a_37769_690.n3 VSS 0.12531f $ **FLOATING
C7922 a_39799_994.t0 VSS 0.03714f $ **FLOATING
C7923 a_40010_598.t0 VSS 0.134f $ **FLOATING
C7924 a_40010_598.t1 VSS 0.2065f $ **FLOATING
C7925 a_40010_598.n0 VSS 0.57905f $ **FLOATING
C7926 a_40010_598.t2 VSS 0.28278f $ **FLOATING
C7927 a_40399_914.t1 VSS 0.16148f $ **FLOATING
C7928 a_40399_914.t3 VSS 0.185f $ **FLOATING
C7929 a_40399_914.t2 VSS 0.2534f $ **FLOATING
C7930 a_40399_914.t0 VSS 0.25256f $ **FLOATING
C7931 a_40399_914.n0 VSS 0.39374f $ **FLOATING
C7932 a_40399_914.n1 VSS 0.36161f $ **FLOATING
C7933 a_41115_839.t0 VSS 0.14624f $ **FLOATING
C7934 a_41115_839.t1 VSS 0.14776f $ **FLOATING
C7935 a_41115_839.t2 VSS 0.13651f $ **FLOATING
C7936 a_41115_839.t3 VSS 0.31139f $ **FLOATING
C7937 a_41115_839.n0 VSS 0.43681f $ **FLOATING
C7938 a_41115_839.n1 VSS 0.34211f $ **FLOATING
C7939 a_40855_616.t0 VSS 0.18197f $ **FLOATING
C7940 a_40855_616.t1 VSS 0.18297f $ **FLOATING
C7941 a_40855_616.n0 VSS 0.98375f $ **FLOATING
C7942 a_40855_616.t3 VSS 0.16371f $ **FLOATING
C7943 a_40855_616.n1 VSS 1.06646f $ **FLOATING
C7944 a_40855_616.t2 VSS 0.16955f $ **FLOATING
C7945 a_41141_934.t0 VSS 0.19076f $ **FLOATING
C7946 a_41141_934.t4 VSS 0.24626f $ **FLOATING
C7947 a_41141_934.n0 VSS 0.50583f $ **FLOATING
C7948 a_41141_934.t3 VSS 0.26848f $ **FLOATING
C7949 a_41141_934.t2 VSS 0.27072f $ **FLOATING
C7950 a_41141_934.n1 VSS 0.81492f $ **FLOATING
C7951 a_41141_934.t1 VSS 0.27476f $ **FLOATING
C7952 a_41141_934.n2 VSS 0.49434f $ **FLOATING
C7953 a_41550_873.t0 VSS 0.15385f $ **FLOATING
C7954 a_41550_873.t3 VSS 0.59697f $ **FLOATING
C7955 a_41550_873.n0 VSS 0.31614f $ **FLOATING
C7956 a_41550_873.t1 VSS 0.22514f $ **FLOATING
C7957 a_41550_873.n1 VSS 0.17906f $ **FLOATING
C7958 a_41550_873.t2 VSS 0.24899f $ **FLOATING
C7959 a_41652_960.t0 VSS 0.19976f $ **FLOATING
C7960 a_41652_960.t3 VSS 0.28139f $ **FLOATING
C7961 a_41652_960.n0 VSS 0.63172f $ **FLOATING
C7962 a_41652_960.t1 VSS 0.30359f $ **FLOATING
C7963 a_41652_960.t2 VSS 0.27146f $ **FLOATING
C7964 a_41652_960.n1 VSS 0.33992f $ **FLOATING
C7965 a_40298_617.t1 VSS 0.09034f $ **FLOATING
C7966 a_40298_617.t0 VSS 0.09273f $ **FLOATING
C7967 a_40298_617.t2 VSS 0.08435f $ **FLOATING
C7968 a_40298_617.n0 VSS 0.26176f $ **FLOATING
C7969 a_42400_693.t1 VSS 0.15394f $ **FLOATING
C7970 a_42400_693.t2 VSS 0.77691f $ **FLOATING
C7971 a_42400_693.n0 VSS 0.43675f $ **FLOATING
C7972 a_42400_693.t0 VSS 0.23346f $ **FLOATING
C7973 a_42628_833.t0 VSS 0.10805f $ **FLOATING
C7974 a_42628_833.t1 VSS 0.10883f $ **FLOATING
C7975 a_42628_833.n0 VSS 0.47342f $ **FLOATING
C7976 a_42628_833.t2 VSS 0.21694f $ **FLOATING
C7977 a_43201_894.t0 VSS 0.08632f $ **FLOATING
C7978 a_43201_894.t2 VSS 0.28604f $ **FLOATING
C7979 a_43201_894.t1 VSS 0.1377f $ **FLOATING
C7980 a_43201_894.n0 VSS 0.32367f $ **FLOATING
C7981 a_46225_994.t0 VSS 0.06966f $ **FLOATING
C7982 a_46225_994.t2 VSS 0.23389f $ **FLOATING
C7983 a_46225_994.t1 VSS 0.10922f $ **FLOATING
C7984 a_46225_994.n0 VSS 0.29073f $ **FLOATING
C7985 a_41430_629.t0 VSS 0.44538f $ **FLOATING
C7986 a_41430_629.t1 VSS 0.38705f $ **FLOATING
C7987 a_42306_693.t0 VSS 0.3709f $ **FLOATING
C7988 a_42306_693.t1 VSS 0.37223f $ **FLOATING
C7989 a_44289_690.t3 VSS 0.07401f $ **FLOATING
C7990 a_44289_690.t6 VSS 0.07401f $ **FLOATING
C7991 a_44289_690.n0 VSS 0.12486f $ **FLOATING
C7992 a_44289_690.t2 VSS 0.07401f $ **FLOATING
C7993 a_44289_690.t7 VSS 0.07401f $ **FLOATING
C7994 a_44289_690.n1 VSS 0.16023f $ **FLOATING
C7995 a_44289_690.t1 VSS 0.07401f $ **FLOATING
C7996 a_44289_690.t5 VSS 0.07401f $ **FLOATING
C7997 a_44289_690.n2 VSS 0.16023f $ **FLOATING
C7998 a_44289_690.t0 VSS 0.07401f $ **FLOATING
C7999 a_44289_690.t4 VSS 0.07401f $ **FLOATING
C8000 a_44289_690.n3 VSS 0.12486f $ **FLOATING
C8001 a_46530_598.t0 VSS 0.13268f $ **FLOATING
C8002 a_46530_598.t1 VSS 0.20447f $ **FLOATING
C8003 a_46530_598.n0 VSS 0.57337f $ **FLOATING
C8004 a_46530_598.t2 VSS 0.28f $ **FLOATING
C8005 a_46919_914.t1 VSS 0.16147f $ **FLOATING
C8006 a_46919_914.t3 VSS 0.18499f $ **FLOATING
C8007 a_46919_914.t2 VSS 0.25338f $ **FLOATING
C8008 a_46919_914.t0 VSS 0.25254f $ **FLOATING
C8009 a_46919_914.n0 VSS 0.3937f $ **FLOATING
C8010 a_46919_914.n1 VSS 0.36158f $ **FLOATING
C8011 a_47635_839.t0 VSS 0.14624f $ **FLOATING
C8012 a_47635_839.t1 VSS 0.14776f $ **FLOATING
C8013 a_47635_839.t2 VSS 0.13651f $ **FLOATING
C8014 a_47635_839.t3 VSS 0.31139f $ **FLOATING
C8015 a_47635_839.n0 VSS 0.43681f $ **FLOATING
C8016 a_47635_839.n1 VSS 0.34211f $ **FLOATING
C8017 a_47375_616.t0 VSS 0.18197f $ **FLOATING
C8018 a_47375_616.t1 VSS 0.18297f $ **FLOATING
C8019 a_47375_616.n0 VSS 0.98375f $ **FLOATING
C8020 a_47375_616.t2 VSS 0.16371f $ **FLOATING
C8021 a_47375_616.n1 VSS 1.06646f $ **FLOATING
C8022 a_47375_616.t3 VSS 0.16955f $ **FLOATING
C8023 a_47661_934.t0 VSS 0.19076f $ **FLOATING
C8024 a_47661_934.t4 VSS 0.24626f $ **FLOATING
C8025 a_47661_934.n0 VSS 0.50583f $ **FLOATING
C8026 a_47661_934.t2 VSS 0.26848f $ **FLOATING
C8027 a_47661_934.t3 VSS 0.27072f $ **FLOATING
C8028 a_47661_934.n1 VSS 0.81492f $ **FLOATING
C8029 a_47661_934.t1 VSS 0.27476f $ **FLOATING
C8030 a_47661_934.n2 VSS 0.49434f $ **FLOATING
C8031 a_48070_873.t0 VSS 0.15385f $ **FLOATING
C8032 a_48070_873.t3 VSS 0.59697f $ **FLOATING
C8033 a_48070_873.n0 VSS 0.31614f $ **FLOATING
C8034 a_48070_873.t1 VSS 0.22514f $ **FLOATING
C8035 a_48070_873.n1 VSS 0.17906f $ **FLOATING
C8036 a_48070_873.t2 VSS 0.24899f $ **FLOATING
C8037 a_48172_960.t0 VSS 0.19976f $ **FLOATING
C8038 a_48172_960.t3 VSS 0.28139f $ **FLOATING
C8039 a_48172_960.n0 VSS 0.63172f $ **FLOATING
C8040 a_48172_960.t1 VSS 0.30359f $ **FLOATING
C8041 a_48172_960.t2 VSS 0.27146f $ **FLOATING
C8042 a_48172_960.n1 VSS 0.33992f $ **FLOATING
C8043 a_46818_617.t1 VSS 0.09017f $ **FLOATING
C8044 a_46818_617.t0 VSS 0.09255f $ **FLOATING
C8045 a_46818_617.t2 VSS 0.08418f $ **FLOATING
C8046 a_46818_617.n0 VSS 0.26125f $ **FLOATING
C8047 a_48920_693.t1 VSS 0.15394f $ **FLOATING
C8048 a_48920_693.t2 VSS 0.77691f $ **FLOATING
C8049 a_48920_693.n0 VSS 0.43675f $ **FLOATING
C8050 a_48920_693.t0 VSS 0.23346f $ **FLOATING
C8051 a_49148_833.t0 VSS 0.10805f $ **FLOATING
C8052 a_49148_833.t1 VSS 0.10883f $ **FLOATING
C8053 a_49148_833.n0 VSS 0.47342f $ **FLOATING
C8054 a_49148_833.t2 VSS 0.21694f $ **FLOATING
C8055 a_49721_894.t0 VSS 0.08632f $ **FLOATING
C8056 a_49721_894.t2 VSS 0.28604f $ **FLOATING
C8057 a_49721_894.t1 VSS 0.1377f $ **FLOATING
C8058 a_49721_894.n0 VSS 0.32367f $ **FLOATING
C8059 a_47950_629.t0 VSS 0.44538f $ **FLOATING
C8060 a_47950_629.t1 VSS 0.38705f $ **FLOATING
C8061 a_48826_693.t0 VSS 0.3709f $ **FLOATING
C8062 a_48826_693.t1 VSS 0.37223f $ **FLOATING
C8063 a_50809_690.t3 VSS 0.07395f $ **FLOATING
C8064 a_50809_690.t6 VSS 0.07395f $ **FLOATING
C8065 a_50809_690.n0 VSS 0.12478f $ **FLOATING
C8066 a_50809_690.t2 VSS 0.07395f $ **FLOATING
C8067 a_50809_690.t7 VSS 0.07395f $ **FLOATING
C8068 a_50809_690.n1 VSS 0.16012f $ **FLOATING
C8069 a_50809_690.t1 VSS 0.07395f $ **FLOATING
C8070 a_50809_690.t5 VSS 0.07395f $ **FLOATING
C8071 a_50809_690.n2 VSS 0.16012f $ **FLOATING
C8072 a_50809_690.t0 VSS 0.07395f $ **FLOATING
C8073 a_50809_690.t4 VSS 0.07395f $ **FLOATING
C8074 a_50809_690.n3 VSS 0.12478f $ **FLOATING
C8075 VDD.t610 VSS 0.15607f $ **FLOATING
C8076 VDD.n5 VSS 0.08349f $ **FLOATING
C8077 VDD.n6 VSS 7.56366f $ **FLOATING
C8078 VDD.n7 VSS 0.15075f $ **FLOATING
C8079 VDD.n8 VSS 0.15075f $ **FLOATING
C8080 VDD.n9 VSS 0.40199f $ **FLOATING
C8081 VDD.n10 VSS 0.15075f $ **FLOATING
C8082 VDD.n11 VSS 0.40199f $ **FLOATING
C8083 VDD.n12 VSS 0.15075f $ **FLOATING
C8084 VDD.n13 VSS 0.15075f $ **FLOATING
C8085 VDD.n14 VSS 0.13113f $ **FLOATING
C8086 VDD.n15 VSS 10.7063f $ **FLOATING
C8087 VDD.n16 VSS 2.71004f $ **FLOATING
C8088 VDD.n19 VSS 0.02037f $ **FLOATING
C8089 VDD.n28 VSS 0.02632f $ **FLOATING
C8090 VDD.t1521 VSS 0.04876f $ **FLOATING
C8091 VDD.n29 VSS 0.02188f $ **FLOATING
C8092 VDD.n31 VSS 0.02792f $ **FLOATING
C8093 VDD.n32 VSS 0.02713f $ **FLOATING
C8094 VDD.n33 VSS 0.03303f $ **FLOATING
C8095 VDD.t143 VSS 1.07657f $ **FLOATING
C8096 VDD.t321 VSS 0.16701f $ **FLOATING
C8097 VDD.n40 VSS 0.43002f $ **FLOATING
C8098 VDD.t1629 VSS 0.02072f $ **FLOATING
C8099 VDD.n41 VSS 0.27819f $ **FLOATING
C8100 VDD.n44 VSS 0.02037f $ **FLOATING
C8101 VDD.n54 VSS 0.02632f $ **FLOATING
C8102 VDD.t1627 VSS 0.04876f $ **FLOATING
C8103 VDD.n55 VSS 0.02188f $ **FLOATING
C8104 VDD.n57 VSS 0.02792f $ **FLOATING
C8105 VDD.n58 VSS 0.02713f $ **FLOATING
C8106 VDD.n59 VSS 0.03303f $ **FLOATING
C8107 VDD.t460 VSS 1.07657f $ **FLOATING
C8108 VDD.t633 VSS 0.16701f $ **FLOATING
C8109 VDD.n66 VSS 0.33312f $ **FLOATING
C8110 VDD.n67 VSS 0.534f $ **FLOATING
C8111 VDD.n68 VSS 0.534f $ **FLOATING
C8112 VDD.n69 VSS 0.534f $ **FLOATING
C8113 VDD.n70 VSS 0.534f $ **FLOATING
C8114 VDD.n71 VSS 0.534f $ **FLOATING
C8115 VDD.n72 VSS 8.67711f $ **FLOATING
C8116 VDD.n75 VSS 0.02037f $ **FLOATING
C8117 VDD.n84 VSS 0.02632f $ **FLOATING
C8118 VDD.t1563 VSS 0.04876f $ **FLOATING
C8119 VDD.n85 VSS 0.02188f $ **FLOATING
C8120 VDD.n87 VSS 0.02792f $ **FLOATING
C8121 VDD.n88 VSS 0.02713f $ **FLOATING
C8122 VDD.n89 VSS 0.03303f $ **FLOATING
C8123 VDD.t0 VSS 1.07657f $ **FLOATING
C8124 VDD.t426 VSS 0.16701f $ **FLOATING
C8125 VDD.n96 VSS 0.42473f $ **FLOATING
C8126 VDD.n104 VSS 0.13113f $ **FLOATING
C8127 VDD.n105 VSS 0.15075f $ **FLOATING
C8128 VDD.n106 VSS 0.15075f $ **FLOATING
C8129 VDD.n107 VSS 0.40199f $ **FLOATING
C8130 VDD.n108 VSS 0.15075f $ **FLOATING
C8131 VDD.n109 VSS 0.40199f $ **FLOATING
C8132 VDD.n110 VSS 0.15075f $ **FLOATING
C8133 VDD.n111 VSS 0.15075f $ **FLOATING
C8134 VDD.n112 VSS 0.13113f $ **FLOATING
C8135 VDD.n114 VSS 0.15075f $ **FLOATING
C8136 VDD.n116 VSS 0.40199f $ **FLOATING
C8137 VDD.n118 VSS 0.15075f $ **FLOATING
C8138 VDD.n120 VSS 0.15075f $ **FLOATING
C8139 VDD.n122 VSS 0.40199f $ **FLOATING
C8140 VDD.n124 VSS 0.15075f $ **FLOATING
C8141 VDD.n131 VSS 0.13113f $ **FLOATING
C8142 VDD.n133 VSS 0.34968f $ **FLOATING
C8143 VDD.n134 VSS 0.13113f $ **FLOATING
C8144 VDD.n135 VSS 0.34968f $ **FLOATING
C8145 VDD.n136 VSS 0.13113f $ **FLOATING
C8146 VDD.n137 VSS 0.13113f $ **FLOATING
C8147 VDD.n139 VSS 0.13113f $ **FLOATING
C8148 VDD.n141 VSS 0.34968f $ **FLOATING
C8149 VDD.n143 VSS 0.13113f $ **FLOATING
C8150 VDD.n145 VSS 0.13113f $ **FLOATING
C8151 VDD.n147 VSS 0.34968f $ **FLOATING
C8152 VDD.n149 VSS 0.44596f $ **FLOATING
C8153 VDD.n150 VSS 0.58872f $ **FLOATING
C8154 VDD.n151 VSS 7.79166f $ **FLOATING
C8155 VDD.n152 VSS 14.6504f $ **FLOATING
C8156 VDD.n153 VSS 2.72297f $ **FLOATING
C8157 VDD.n156 VSS 0.02037f $ **FLOATING
C8158 VDD.n165 VSS 0.02632f $ **FLOATING
C8159 VDD.t1461 VSS 0.04876f $ **FLOATING
C8160 VDD.n166 VSS 0.02188f $ **FLOATING
C8161 VDD.n168 VSS 0.02792f $ **FLOATING
C8162 VDD.n169 VSS 0.02713f $ **FLOATING
C8163 VDD.n170 VSS 0.03303f $ **FLOATING
C8164 VDD.t91 VSS 1.07657f $ **FLOATING
C8165 VDD.t99 VSS 0.16701f $ **FLOATING
C8166 VDD.n177 VSS 0.42616f $ **FLOATING
C8167 VDD.n178 VSS 3.89699f $ **FLOATING
C8168 VDD.n179 VSS 2.73111f $ **FLOATING
C8169 VDD.n182 VSS 0.02037f $ **FLOATING
C8170 VDD.n190 VSS 0.02632f $ **FLOATING
C8171 VDD.t1375 VSS 0.04876f $ **FLOATING
C8172 VDD.n191 VSS 0.02188f $ **FLOATING
C8173 VDD.n193 VSS 0.02792f $ **FLOATING
C8174 VDD.n194 VSS 0.02713f $ **FLOATING
C8175 VDD.n195 VSS 0.03303f $ **FLOATING
C8176 VDD.t893 VSS 1.07657f $ **FLOATING
C8177 VDD.t898 VSS 0.16701f $ **FLOATING
C8178 VDD.n203 VSS 0.42927f $ **FLOATING
C8179 VDD.n204 VSS 2.71505f $ **FLOATING
C8180 VDD.n205 VSS 2.71901f $ **FLOATING
C8181 VDD.n208 VSS 0.02037f $ **FLOATING
C8182 VDD.n218 VSS 0.02632f $ **FLOATING
C8183 VDD.t1379 VSS 0.04876f $ **FLOATING
C8184 VDD.n219 VSS 0.02188f $ **FLOATING
C8185 VDD.n221 VSS 0.02792f $ **FLOATING
C8186 VDD.n222 VSS 0.02713f $ **FLOATING
C8187 VDD.n223 VSS 0.03303f $ **FLOATING
C8188 VDD.t733 VSS 1.07657f $ **FLOATING
C8189 VDD.t735 VSS 0.16701f $ **FLOATING
C8190 VDD.n230 VSS 0.43405f $ **FLOATING
C8191 VDD.n233 VSS 0.02037f $ **FLOATING
C8192 VDD.n243 VSS 0.02632f $ **FLOATING
C8193 VDD.t1657 VSS 0.04876f $ **FLOATING
C8194 VDD.n244 VSS 0.02188f $ **FLOATING
C8195 VDD.n246 VSS 0.02792f $ **FLOATING
C8196 VDD.n247 VSS 0.02713f $ **FLOATING
C8197 VDD.n248 VSS 0.03303f $ **FLOATING
C8198 VDD.t456 VSS 1.07657f $ **FLOATING
C8199 VDD.t678 VSS 0.16701f $ **FLOATING
C8200 VDD.n255 VSS 0.3332f $ **FLOATING
C8201 VDD.n258 VSS 0.02037f $ **FLOATING
C8202 VDD.n268 VSS 0.02632f $ **FLOATING
C8203 VDD.t1593 VSS 0.04876f $ **FLOATING
C8204 VDD.n269 VSS 0.02188f $ **FLOATING
C8205 VDD.n271 VSS 0.02792f $ **FLOATING
C8206 VDD.n272 VSS 0.02713f $ **FLOATING
C8207 VDD.n273 VSS 0.03303f $ **FLOATING
C8208 VDD.t295 VSS 1.07657f $ **FLOATING
C8209 VDD.t540 VSS 0.16701f $ **FLOATING
C8210 VDD.n280 VSS 0.28358f $ **FLOATING
C8211 VDD.n281 VSS 2.71526f $ **FLOATING
C8212 VDD.n284 VSS 0.02037f $ **FLOATING
C8213 VDD.n293 VSS 0.02632f $ **FLOATING
C8214 VDD.t1265 VSS 0.04876f $ **FLOATING
C8215 VDD.n294 VSS 0.02188f $ **FLOATING
C8216 VDD.n296 VSS 0.02792f $ **FLOATING
C8217 VDD.n297 VSS 0.02713f $ **FLOATING
C8218 VDD.n298 VSS 0.03303f $ **FLOATING
C8219 VDD.t34 VSS 1.07657f $ **FLOATING
C8220 VDD.t42 VSS 0.16701f $ **FLOATING
C8221 VDD.n305 VSS 0.42456f $ **FLOATING
C8222 VDD.n306 VSS 2.71276f $ **FLOATING
C8223 VDD.n309 VSS 0.02037f $ **FLOATING
C8224 VDD.n319 VSS 0.02632f $ **FLOATING
C8225 VDD.t1367 VSS 0.04876f $ **FLOATING
C8226 VDD.n320 VSS 0.02188f $ **FLOATING
C8227 VDD.n322 VSS 0.02792f $ **FLOATING
C8228 VDD.n323 VSS 0.02713f $ **FLOATING
C8229 VDD.n324 VSS 0.03303f $ **FLOATING
C8230 VDD.t748 VSS 1.07657f $ **FLOATING
C8231 VDD.t764 VSS 0.16701f $ **FLOATING
C8232 VDD.n331 VSS 0.42918f $ **FLOATING
C8233 VDD.n332 VSS 3.26995f $ **FLOATING
C8234 VDD.t73 VSS 0.15607f $ **FLOATING
C8235 VDD.n339 VSS 0.08349f $ **FLOATING
C8236 VDD.t76 VSS 0.58003f $ **FLOATING
C8237 VDD.n371 VSS 0.15468f $ **FLOATING
C8238 VDD.n373 VSS 0.02674f $ **FLOATING
C8239 VDD.t71 VSS 0.46912f $ **FLOATING
C8240 VDD.n392 VSS 0.15463f $ **FLOATING
C8241 VDD.t77 VSS 0.34573f $ **FLOATING
C8242 VDD.n420 VSS 0.20955f $ **FLOATING
C8243 VDD.n421 VSS 0.63078f $ **FLOATING
C8244 VDD.n422 VSS 2.72047f $ **FLOATING
C8245 VDD.n423 VSS 5.13163f $ **FLOATING
C8246 VDD.n424 VSS 2.72214f $ **FLOATING
C8247 VDD.n427 VSS 0.02037f $ **FLOATING
C8248 VDD.n437 VSS 0.02632f $ **FLOATING
C8249 VDD.t1283 VSS 0.04876f $ **FLOATING
C8250 VDD.n438 VSS 0.02188f $ **FLOATING
C8251 VDD.n440 VSS 0.02792f $ **FLOATING
C8252 VDD.n441 VSS 0.02713f $ **FLOATING
C8253 VDD.n442 VSS 0.03303f $ **FLOATING
C8254 VDD.t7 VSS 1.07657f $ **FLOATING
C8255 VDD.t845 VSS 0.16701f $ **FLOATING
C8256 VDD.n449 VSS 0.28055f $ **FLOATING
C8257 VDD.n450 VSS 0.54623f $ **FLOATING
C8258 VDD.n451 VSS 1.02042f $ **FLOATING
C8259 VDD.n452 VSS 1.01874f $ **FLOATING
C8260 VDD.n453 VSS 1.02093f $ **FLOATING
C8261 VDD.n454 VSS 1.02093f $ **FLOATING
C8262 VDD.n455 VSS 1.01874f $ **FLOATING
C8263 VDD.n456 VSS 1.02093f $ **FLOATING
C8264 VDD.n457 VSS 7.42901f $ **FLOATING
C8265 VDD.t1293 VSS 0.04318f $ **FLOATING
C8266 VDD.t1317 VSS 0.04318f $ **FLOATING
C8267 VDD.n458 VSS 0.02673f $ **FLOATING
C8268 VDD.n460 VSS 0.02037f $ **FLOATING
C8269 VDD.n465 VSS 0.03169f $ **FLOATING
C8270 VDD.t760 VSS 0.75918f $ **FLOATING
C8271 VDD.t1161 VSS 0.12804f $ **FLOATING
C8272 VDD.n471 VSS 0.02346f $ **FLOATING
C8273 VDD.n472 VSS 0.06009f $ **FLOATING
C8274 VDD.n473 VSS 0.06458f $ **FLOATING
C8275 VDD.n474 VSS 0.06488f $ **FLOATING
C8276 VDD.n475 VSS 0.02673f $ **FLOATING
C8277 VDD.n477 VSS 0.02037f $ **FLOATING
C8278 VDD.n482 VSS 0.03169f $ **FLOATING
C8279 VDD.t813 VSS 0.75917f $ **FLOATING
C8280 VDD.t992 VSS 0.12804f $ **FLOATING
C8281 VDD.n488 VSS 0.02346f $ **FLOATING
C8282 VDD.n489 VSS 0.06876f $ **FLOATING
C8283 VDD.n493 VSS 0.02037f $ **FLOATING
C8284 VDD.n495 VSS 0.02792f $ **FLOATING
C8285 VDD.n496 VSS 0.02713f $ **FLOATING
C8286 VDD.n497 VSS 0.03303f $ **FLOATING
C8287 VDD.t13 VSS 0.75918f $ **FLOATING
C8288 VDD.t981 VSS 0.12804f $ **FLOATING
C8289 VDD.n504 VSS 0.06866f $ **FLOATING
C8290 VDD.t1311 VSS 0.04315f $ **FLOATING
C8291 VDD.n505 VSS 0.0447f $ **FLOATING
C8292 VDD.n507 VSS 0.34954f $ **FLOATING
C8293 VDD.n508 VSS 0.13108f $ **FLOATING
C8294 VDD.n509 VSS 0.34954f $ **FLOATING
C8295 VDD.n510 VSS 0.13108f $ **FLOATING
C8296 VDD.n511 VSS 0.13108f $ **FLOATING
C8297 VDD.n512 VSS 0.13108f $ **FLOATING
C8298 VDD.n513 VSS 0.34954f $ **FLOATING
C8299 VDD.n514 VSS 0.13108f $ **FLOATING
C8300 VDD.n515 VSS 0.13108f $ **FLOATING
C8301 VDD.n516 VSS 0.34954f $ **FLOATING
C8302 VDD.n518 VSS 0.15075f $ **FLOATING
C8303 VDD.n519 VSS 0.15075f $ **FLOATING
C8304 VDD.n520 VSS 0.40199f $ **FLOATING
C8305 VDD.n521 VSS 0.15075f $ **FLOATING
C8306 VDD.n522 VSS 0.40199f $ **FLOATING
C8307 VDD.n523 VSS 0.15075f $ **FLOATING
C8308 VDD.n529 VSS 0.15075f $ **FLOATING
C8309 VDD.n530 VSS 0.13108f $ **FLOATING
C8310 VDD.n537 VSS 0.32976f $ **FLOATING
C8311 VDD.n539 VSS 0.15075f $ **FLOATING
C8312 VDD.n541 VSS 0.40199f $ **FLOATING
C8313 VDD.n543 VSS 0.15075f $ **FLOATING
C8314 VDD.n545 VSS 0.15075f $ **FLOATING
C8315 VDD.n547 VSS 0.40199f $ **FLOATING
C8316 VDD.n556 VSS 0.13108f $ **FLOATING
C8317 VDD.n557 VSS 0.13108f $ **FLOATING
C8318 VDD.n558 VSS 0.15075f $ **FLOATING
C8319 VDD.n559 VSS 0.57209f $ **FLOATING
C8320 VDD.n560 VSS 5.13556f $ **FLOATING
C8321 VDD.n563 VSS 0.02037f $ **FLOATING
C8322 VDD.n572 VSS 0.02632f $ **FLOATING
C8323 VDD.t1409 VSS 0.04876f $ **FLOATING
C8324 VDD.n573 VSS 0.02188f $ **FLOATING
C8325 VDD.n575 VSS 0.02792f $ **FLOATING
C8326 VDD.n576 VSS 0.02713f $ **FLOATING
C8327 VDD.n577 VSS 0.03303f $ **FLOATING
C8328 VDD.t736 VSS 1.07657f $ **FLOATING
C8329 VDD.t877 VSS 0.16701f $ **FLOATING
C8330 VDD.n584 VSS 0.27913f $ **FLOATING
C8331 VDD.n585 VSS 0.23512f $ **FLOATING
C8332 VDD.n588 VSS 0.02037f $ **FLOATING
C8333 VDD.n597 VSS 0.02632f $ **FLOATING
C8334 VDD.t1371 VSS 0.04876f $ **FLOATING
C8335 VDD.n598 VSS 0.02188f $ **FLOATING
C8336 VDD.n600 VSS 0.02792f $ **FLOATING
C8337 VDD.n601 VSS 0.02713f $ **FLOATING
C8338 VDD.n602 VSS 0.03303f $ **FLOATING
C8339 VDD.t737 VSS 1.07657f $ **FLOATING
C8340 VDD.t1216 VSS 0.16701f $ **FLOATING
C8341 VDD.n609 VSS 0.43078f $ **FLOATING
C8342 VDD.n612 VSS 0.02037f $ **FLOATING
C8343 VDD.n621 VSS 0.02632f $ **FLOATING
C8344 VDD.t1335 VSS 0.04876f $ **FLOATING
C8345 VDD.n622 VSS 0.02188f $ **FLOATING
C8346 VDD.n624 VSS 0.02792f $ **FLOATING
C8347 VDD.n625 VSS 0.02713f $ **FLOATING
C8348 VDD.n626 VSS 0.03303f $ **FLOATING
C8349 VDD.t11 VSS 1.07657f $ **FLOATING
C8350 VDD.t994 VSS 0.16701f $ **FLOATING
C8351 VDD.n633 VSS 0.28223f $ **FLOATING
C8352 VDD.n634 VSS 0.54565f $ **FLOATING
C8353 VDD.n635 VSS 2.72193f $ **FLOATING
C8354 VDD.n638 VSS 0.02037f $ **FLOATING
C8355 VDD.n648 VSS 0.02632f $ **FLOATING
C8356 VDD.t1291 VSS 0.04876f $ **FLOATING
C8357 VDD.n649 VSS 0.02188f $ **FLOATING
C8358 VDD.n651 VSS 0.02792f $ **FLOATING
C8359 VDD.n652 VSS 0.02713f $ **FLOATING
C8360 VDD.n653 VSS 0.03303f $ **FLOATING
C8361 VDD.t9 VSS 1.07657f $ **FLOATING
C8362 VDD.t989 VSS 0.16701f $ **FLOATING
C8363 VDD.n660 VSS 0.28005f $ **FLOATING
C8364 VDD.n661 VSS 0.54388f $ **FLOATING
C8365 VDD.n662 VSS 2.72819f $ **FLOATING
C8366 VDD.n665 VSS 0.02037f $ **FLOATING
C8367 VDD.n673 VSS 0.02632f $ **FLOATING
C8368 VDD.t1287 VSS 0.04876f $ **FLOATING
C8369 VDD.n674 VSS 0.02188f $ **FLOATING
C8370 VDD.n676 VSS 0.02792f $ **FLOATING
C8371 VDD.n677 VSS 0.02713f $ **FLOATING
C8372 VDD.n678 VSS 0.03303f $ **FLOATING
C8373 VDD.t793 VSS 1.07657f $ **FLOATING
C8374 VDD.t794 VSS 0.16701f $ **FLOATING
C8375 VDD.n686 VSS 0.28005f $ **FLOATING
C8376 VDD.n687 VSS 0.54817f $ **FLOATING
C8377 VDD.n688 VSS 2.72276f $ **FLOATING
C8378 VDD.n691 VSS 0.02037f $ **FLOATING
C8379 VDD.n700 VSS 0.02632f $ **FLOATING
C8380 VDD.t1427 VSS 0.04876f $ **FLOATING
C8381 VDD.n701 VSS 0.02188f $ **FLOATING
C8382 VDD.n703 VSS 0.02792f $ **FLOATING
C8383 VDD.n704 VSS 0.02713f $ **FLOATING
C8384 VDD.n705 VSS 0.03303f $ **FLOATING
C8385 VDD.t810 VSS 1.07657f $ **FLOATING
C8386 VDD.t862 VSS 0.16701f $ **FLOATING
C8387 VDD.n712 VSS 0.2871f $ **FLOATING
C8388 VDD.n713 VSS 0.23512f $ **FLOATING
C8389 VDD.n716 VSS 0.02037f $ **FLOATING
C8390 VDD.n725 VSS 0.02632f $ **FLOATING
C8391 VDD.t1307 VSS 0.04876f $ **FLOATING
C8392 VDD.n726 VSS 0.02188f $ **FLOATING
C8393 VDD.n728 VSS 0.02792f $ **FLOATING
C8394 VDD.n729 VSS 0.02713f $ **FLOATING
C8395 VDD.n730 VSS 0.03303f $ **FLOATING
C8396 VDD.t812 VSS 1.07657f $ **FLOATING
C8397 VDD.t1062 VSS 0.16701f $ **FLOATING
C8398 VDD.n737 VSS 0.4228f $ **FLOATING
C8399 VDD.n740 VSS 0.02037f $ **FLOATING
C8400 VDD.n749 VSS 0.02632f $ **FLOATING
C8401 VDD.t1277 VSS 0.04876f $ **FLOATING
C8402 VDD.n750 VSS 0.02188f $ **FLOATING
C8403 VDD.n752 VSS 0.02792f $ **FLOATING
C8404 VDD.n753 VSS 0.02713f $ **FLOATING
C8405 VDD.n754 VSS 0.03303f $ **FLOATING
C8406 VDD.t801 VSS 1.07657f $ **FLOATING
C8407 VDD.t802 VSS 0.16701f $ **FLOATING
C8408 VDD.n761 VSS 0.28223f $ **FLOATING
C8409 VDD.n762 VSS 0.54649f $ **FLOATING
C8410 VDD.n763 VSS 2.71192f $ **FLOATING
C8411 VDD.n764 VSS 3.90054f $ **FLOATING
C8412 VDD.n765 VSS 0.78161f $ **FLOATING
C8413 VDD.n768 VSS 0.02037f $ **FLOATING
C8414 VDD.n777 VSS 0.02632f $ **FLOATING
C8415 VDD.t1389 VSS 0.04876f $ **FLOATING
C8416 VDD.n778 VSS 0.02188f $ **FLOATING
C8417 VDD.n780 VSS 0.02792f $ **FLOATING
C8418 VDD.n781 VSS 0.02713f $ **FLOATING
C8419 VDD.n782 VSS 0.03303f $ **FLOATING
C8420 VDD.t905 VSS 1.07657f $ **FLOATING
C8421 VDD.t1051 VSS 0.16701f $ **FLOATING
C8422 VDD.n789 VSS 0.47184f $ **FLOATING
C8423 VDD.n792 VSS 0.02037f $ **FLOATING
C8424 VDD.n801 VSS 0.02632f $ **FLOATING
C8425 VDD.t1515 VSS 0.04876f $ **FLOATING
C8426 VDD.n802 VSS 0.02188f $ **FLOATING
C8427 VDD.n804 VSS 0.02792f $ **FLOATING
C8428 VDD.n805 VSS 0.02713f $ **FLOATING
C8429 VDD.n806 VSS 0.03303f $ **FLOATING
C8430 VDD.t2 VSS 1.07657f $ **FLOATING
C8431 VDD.t272 VSS 0.16701f $ **FLOATING
C8432 VDD.n813 VSS 0.28215f $ **FLOATING
C8433 VDD.n814 VSS 0.23504f $ **FLOATING
C8434 VDD.n817 VSS 0.02037f $ **FLOATING
C8435 VDD.n826 VSS 0.02632f $ **FLOATING
C8436 VDD.t1467 VSS 0.04876f $ **FLOATING
C8437 VDD.n827 VSS 0.02188f $ **FLOATING
C8438 VDD.n829 VSS 0.02792f $ **FLOATING
C8439 VDD.n830 VSS 0.02713f $ **FLOATING
C8440 VDD.n831 VSS 0.03303f $ **FLOATING
C8441 VDD.t1 VSS 1.07657f $ **FLOATING
C8442 VDD.t114 VSS 0.16701f $ **FLOATING
C8443 VDD.n838 VSS 0.42776f $ **FLOATING
C8444 VDD.n841 VSS 0.02037f $ **FLOATING
C8445 VDD.n850 VSS 0.02632f $ **FLOATING
C8446 VDD.t1271 VSS 0.04876f $ **FLOATING
C8447 VDD.n851 VSS 0.02188f $ **FLOATING
C8448 VDD.n853 VSS 0.02792f $ **FLOATING
C8449 VDD.n854 VSS 0.02713f $ **FLOATING
C8450 VDD.n855 VSS 0.03303f $ **FLOATING
C8451 VDD.t3 VSS 1.07657f $ **FLOATING
C8452 VDD.t732 VSS 0.16701f $ **FLOATING
C8453 VDD.n862 VSS 0.28081f $ **FLOATING
C8454 VDD.n863 VSS 0.23512f $ **FLOATING
C8455 VDD.n864 VSS 3.89699f $ **FLOATING
C8456 VDD.n865 VSS 11.3309f $ **FLOATING
C8457 VDD.n866 VSS 11.3309f $ **FLOATING
C8458 VDD.n867 VSS 11.646f $ **FLOATING
C8459 VDD.n868 VSS 11.9247f $ **FLOATING
C8460 VDD.n869 VSS 2.72318f $ **FLOATING
C8461 VDD.n870 VSS 2.72506f $ **FLOATING
C8462 VDD.n871 VSS 2.72756f $ **FLOATING
C8463 VDD.n872 VSS 2.71651f $ **FLOATING
C8464 VDD.n873 VSS 1.74372f $ **FLOATING
C8465 VDD.n874 VSS 2.54692f $ **FLOATING
C8466 VDD.n875 VSS 0.04353f $ **FLOATING
C8467 VDD.t1301 VSS 0.04315f $ **FLOATING
C8468 VDD.n876 VSS 0.03793f $ **FLOATING
C8469 VDD.n878 VSS 0.02036f $ **FLOATING
C8470 VDD.n883 VSS 0.03298f $ **FLOATING
C8471 VDD.n884 VSS 0.02798f $ **FLOATING
C8472 VDD.n885 VSS 0.02711f $ **FLOATING
C8473 VDD.t14 VSS 0.75917f $ **FLOATING
C8474 VDD.t998 VSS 0.12804f $ **FLOATING
C8475 VDD.n891 VSS 0.39343f $ **FLOATING
C8476 VDD.n892 VSS 9.05019f $ **FLOATING
C8477 VDD.n893 VSS 6.22095f $ **FLOATING
C8478 VDD.n894 VSS 9.40569f $ **FLOATING
C8479 VDD.n895 VSS 9.44489f $ **FLOATING
C8480 VDD.n896 VSS 9.44926f $ **FLOATING
C8481 VDD.n897 VSS 9.42702f $ **FLOATING
C8482 VDD.n898 VSS 9.42643f $ **FLOATING
C8483 VDD.n899 VSS 0.15075f $ **FLOATING
C8484 VDD.n900 VSS 0.15075f $ **FLOATING
C8485 VDD.n901 VSS 0.15075f $ **FLOATING
C8486 VDD.n902 VSS 0.15075f $ **FLOATING
C8487 VDD.n903 VSS 0.40199f $ **FLOATING
C8488 VDD.n904 VSS 0.15075f $ **FLOATING
C8489 VDD.n905 VSS 0.15075f $ **FLOATING
C8490 VDD.n907 VSS 0.15075f $ **FLOATING
C8491 VDD.n908 VSS 0.40199f $ **FLOATING
C8492 VDD.n909 VSS 0.15075f $ **FLOATING
C8493 VDD.n910 VSS 0.40199f $ **FLOATING
C8494 VDD.n911 VSS 0.40199f $ **FLOATING
C8495 VDD.n914 VSS 0.34954f $ **FLOATING
C8496 VDD.n915 VSS 0.13108f $ **FLOATING
C8497 VDD.n916 VSS 0.34954f $ **FLOATING
C8498 VDD.n917 VSS 0.13108f $ **FLOATING
C8499 VDD.n918 VSS 0.13108f $ **FLOATING
C8500 VDD.n920 VSS 0.13108f $ **FLOATING
C8501 VDD.n922 VSS 0.34954f $ **FLOATING
C8502 VDD.n924 VSS 0.13108f $ **FLOATING
C8503 VDD.n926 VSS 0.13108f $ **FLOATING
C8504 VDD.n928 VSS 0.34954f $ **FLOATING
C8505 VDD.n929 VSS 0.13108f $ **FLOATING
C8506 VDD.n936 VSS 0.13108f $ **FLOATING
C8507 VDD.n944 VSS 0.13108f $ **FLOATING
C8508 VDD.n950 VSS 0.33761f $ **FLOATING
C8509 VDD.n951 VSS 0.33861f $ **FLOATING
C8510 VDD.n952 VSS 0.15075f $ **FLOATING
C8511 VDD.n953 VSS 11.0609f $ **FLOATING
C8512 VDD.n954 VSS 15.9516f $ **FLOATING
C8513 VDD.n955 VSS 0.67295f $ **FLOATING
C8514 VDD.n956 VSS 4.62455f $ **FLOATING
C8515 VDD.n957 VSS 13.0378f $ **FLOATING
C8516 VDD.n958 VSS 10.709f $ **FLOATING
C8517 VDD.n959 VSS 11.0231f $ **FLOATING
C8518 VDD.n962 VSS 0.02037f $ **FLOATING
C8519 VDD.n971 VSS 0.02632f $ **FLOATING
C8520 VDD.t1473 VSS 0.04876f $ **FLOATING
C8521 VDD.n972 VSS 0.02188f $ **FLOATING
C8522 VDD.n974 VSS 0.02792f $ **FLOATING
C8523 VDD.n975 VSS 0.02713f $ **FLOATING
C8524 VDD.n976 VSS 0.03303f $ **FLOATING
C8525 VDD.t122 VSS 1.07657f $ **FLOATING
C8526 VDD.t167 VSS 0.16701f $ **FLOATING
C8527 VDD.n983 VSS 0.27938f $ **FLOATING
C8528 VDD.n984 VSS 3.26995f $ **FLOATING
C8529 VDD.n985 VSS 0.23512f $ **FLOATING
C8530 VDD.n988 VSS 0.02037f $ **FLOATING
C8531 VDD.n997 VSS 0.02632f $ **FLOATING
C8532 VDD.t1435 VSS 0.04876f $ **FLOATING
C8533 VDD.n998 VSS 0.02188f $ **FLOATING
C8534 VDD.n1000 VSS 0.02792f $ **FLOATING
C8535 VDD.n1001 VSS 0.02713f $ **FLOATING
C8536 VDD.n1002 VSS 0.03303f $ **FLOATING
C8537 VDD.t765 VSS 1.07657f $ **FLOATING
C8538 VDD.t766 VSS 0.16701f $ **FLOATING
C8539 VDD.n1009 VSS 0.43053f $ **FLOATING
C8540 VDD.n1012 VSS 0.02037f $ **FLOATING
C8541 VDD.n1021 VSS 0.02632f $ **FLOATING
C8542 VDD.t1281 VSS 0.04876f $ **FLOATING
C8543 VDD.n1022 VSS 0.02188f $ **FLOATING
C8544 VDD.n1024 VSS 0.02792f $ **FLOATING
C8545 VDD.n1025 VSS 0.02713f $ **FLOATING
C8546 VDD.n1026 VSS 0.03303f $ **FLOATING
C8547 VDD.t817 VSS 1.07657f $ **FLOATING
C8548 VDD.t962 VSS 0.16701f $ **FLOATING
C8549 VDD.n1033 VSS 0.28005f $ **FLOATING
C8550 VDD.n1034 VSS 0.23512f $ **FLOATING
C8551 VDD.n1037 VSS 0.02037f $ **FLOATING
C8552 VDD.n1046 VSS 0.02632f $ **FLOATING
C8553 VDD.t1353 VSS 0.04876f $ **FLOATING
C8554 VDD.n1047 VSS 0.02188f $ **FLOATING
C8555 VDD.n1049 VSS 0.02792f $ **FLOATING
C8556 VDD.n1050 VSS 0.02713f $ **FLOATING
C8557 VDD.n1051 VSS 0.03303f $ **FLOATING
C8558 VDD.t752 VSS 1.07657f $ **FLOATING
C8559 VDD.t753 VSS 0.16701f $ **FLOATING
C8560 VDD.n1058 VSS 0.42986f $ **FLOATING
C8561 VDD.n1061 VSS 0.02037f $ **FLOATING
C8562 VDD.n1070 VSS 0.02632f $ **FLOATING
C8563 VDD.t1295 VSS 0.04876f $ **FLOATING
C8564 VDD.n1071 VSS 0.02188f $ **FLOATING
C8565 VDD.n1073 VSS 0.02792f $ **FLOATING
C8566 VDD.n1074 VSS 0.02713f $ **FLOATING
C8567 VDD.n1075 VSS 0.03303f $ **FLOATING
C8568 VDD.t5 VSS 1.07657f $ **FLOATING
C8569 VDD.t1023 VSS 0.16701f $ **FLOATING
C8570 VDD.n1082 VSS 0.55378f $ **FLOATING
C8571 VDD.n1083 VSS 3.31503f $ **FLOATING
C8572 VDD.n1084 VSS 2.71192f $ **FLOATING
C8573 VDD.n1085 VSS 0.39064f $ **FLOATING
C8574 VDD.n1088 VSS 0.02037f $ **FLOATING
C8575 VDD.n1098 VSS 0.02632f $ **FLOATING
C8576 VDD.t1323 VSS 0.04876f $ **FLOATING
C8577 VDD.n1099 VSS 0.02188f $ **FLOATING
C8578 VDD.n1101 VSS 0.02792f $ **FLOATING
C8579 VDD.n1102 VSS 0.02713f $ **FLOATING
C8580 VDD.n1103 VSS 0.03303f $ **FLOATING
C8581 VDD.t762 VSS 1.07657f $ **FLOATING
C8582 VDD.t763 VSS 0.16701f $ **FLOATING
C8583 VDD.n1110 VSS 0.28257f $ **FLOATING
C8584 VDD.n1113 VSS 0.02037f $ **FLOATING
C8585 VDD.n1122 VSS 0.02632f $ **FLOATING
C8586 VDD.t1357 VSS 0.04876f $ **FLOATING
C8587 VDD.n1123 VSS 0.02188f $ **FLOATING
C8588 VDD.n1125 VSS 0.02792f $ **FLOATING
C8589 VDD.n1126 VSS 0.02713f $ **FLOATING
C8590 VDD.n1127 VSS 0.03303f $ **FLOATING
C8591 VDD.t741 VSS 1.07657f $ **FLOATING
C8592 VDD.t1056 VSS 0.16701f $ **FLOATING
C8593 VDD.n1134 VSS 0.42759f $ **FLOATING
C8594 VDD.n1137 VSS 0.02037f $ **FLOATING
C8595 VDD.n1146 VSS 0.02632f $ **FLOATING
C8596 VDD.t1575 VSS 0.04876f $ **FLOATING
C8597 VDD.n1147 VSS 0.02188f $ **FLOATING
C8598 VDD.n1149 VSS 0.02792f $ **FLOATING
C8599 VDD.n1150 VSS 0.02713f $ **FLOATING
C8600 VDD.n1151 VSS 0.03303f $ **FLOATING
C8601 VDD.t301 VSS 1.07657f $ **FLOATING
C8602 VDD.t495 VSS 0.16701f $ **FLOATING
C8603 VDD.n1158 VSS 0.28198f $ **FLOATING
C8604 VDD.n1159 VSS 0.23512f $ **FLOATING
C8605 VDD.n1162 VSS 0.02037f $ **FLOATING
C8606 VDD.n1172 VSS 0.02632f $ **FLOATING
C8607 VDD.t1527 VSS 0.04876f $ **FLOATING
C8608 VDD.n1173 VSS 0.02188f $ **FLOATING
C8609 VDD.n1175 VSS 0.02792f $ **FLOATING
C8610 VDD.n1176 VSS 0.02713f $ **FLOATING
C8611 VDD.n1177 VSS 0.03303f $ **FLOATING
C8612 VDD.t141 VSS 1.07657f $ **FLOATING
C8613 VDD.t336 VSS 0.16701f $ **FLOATING
C8614 VDD.n1184 VSS 0.42792f $ **FLOATING
C8615 VDD.n1187 VSS 0.02037f $ **FLOATING
C8616 VDD.n1196 VSS 0.02632f $ **FLOATING
C8617 VDD.t1479 VSS 0.04876f $ **FLOATING
C8618 VDD.n1197 VSS 0.02188f $ **FLOATING
C8619 VDD.n1199 VSS 0.02792f $ **FLOATING
C8620 VDD.n1200 VSS 0.02713f $ **FLOATING
C8621 VDD.n1201 VSS 0.03303f $ **FLOATING
C8622 VDD.t162 VSS 1.07657f $ **FLOATING
C8623 VDD.t186 VSS 0.16701f $ **FLOATING
C8624 VDD.n1208 VSS 0.28215f $ **FLOATING
C8625 VDD.n1209 VSS 0.23512f $ **FLOATING
C8626 VDD.n1212 VSS 0.02037f $ **FLOATING
C8627 VDD.n1221 VSS 0.02632f $ **FLOATING
C8628 VDD.t1273 VSS 0.04876f $ **FLOATING
C8629 VDD.n1222 VSS 0.02188f $ **FLOATING
C8630 VDD.n1224 VSS 0.02792f $ **FLOATING
C8631 VDD.n1225 VSS 0.02713f $ **FLOATING
C8632 VDD.n1226 VSS 0.03303f $ **FLOATING
C8633 VDD.t17 VSS 1.07657f $ **FLOATING
C8634 VDD.t18 VSS 0.16701f $ **FLOATING
C8635 VDD.n1233 VSS 0.42776f $ **FLOATING
C8636 VDD.n1236 VSS 0.02037f $ **FLOATING
C8637 VDD.n1245 VSS 0.02632f $ **FLOATING
C8638 VDD.t1399 VSS 0.04876f $ **FLOATING
C8639 VDD.n1246 VSS 0.02188f $ **FLOATING
C8640 VDD.n1248 VSS 0.02792f $ **FLOATING
C8641 VDD.n1249 VSS 0.02713f $ **FLOATING
C8642 VDD.n1250 VSS 0.03303f $ **FLOATING
C8643 VDD.t912 VSS 1.07657f $ **FLOATING
C8644 VDD.t1220 VSS 0.16701f $ **FLOATING
C8645 VDD.n1257 VSS 0.28232f $ **FLOATING
C8646 VDD.n1258 VSS 0.23512f $ **FLOATING
C8647 VDD.n1259 VSS 2.71004f $ **FLOATING
C8648 VDD.n1260 VSS 2.72318f $ **FLOATING
C8649 VDD.n1261 VSS 0.23512f $ **FLOATING
C8650 VDD.n1264 VSS 0.02037f $ **FLOATING
C8651 VDD.n1274 VSS 0.02632f $ **FLOATING
C8652 VDD.t1393 VSS 0.04876f $ **FLOATING
C8653 VDD.n1275 VSS 0.02188f $ **FLOATING
C8654 VDD.n1277 VSS 0.02792f $ **FLOATING
C8655 VDD.n1278 VSS 0.02713f $ **FLOATING
C8656 VDD.n1279 VSS 0.03303f $ **FLOATING
C8657 VDD.t887 VSS 1.07657f $ **FLOATING
C8658 VDD.t888 VSS 0.16701f $ **FLOATING
C8659 VDD.n1286 VSS 0.28072f $ **FLOATING
C8660 VDD.n1289 VSS 0.02037f $ **FLOATING
C8661 VDD.n1299 VSS 0.02632f $ **FLOATING
C8662 VDD.t1441 VSS 0.04876f $ **FLOATING
C8663 VDD.n1300 VSS 0.02188f $ **FLOATING
C8664 VDD.n1302 VSS 0.02792f $ **FLOATING
C8665 VDD.n1303 VSS 0.02713f $ **FLOATING
C8666 VDD.n1304 VSS 0.03303f $ **FLOATING
C8667 VDD.t25 VSS 1.07657f $ **FLOATING
C8668 VDD.t1126 VSS 0.16701f $ **FLOATING
C8669 VDD.n1311 VSS 0.42776f $ **FLOATING
C8670 VDD.n1314 VSS 0.02037f $ **FLOATING
C8671 VDD.n1324 VSS 0.02632f $ **FLOATING
C8672 VDD.t1641 VSS 0.04876f $ **FLOATING
C8673 VDD.n1325 VSS 0.02188f $ **FLOATING
C8674 VDD.n1327 VSS 0.02792f $ **FLOATING
C8675 VDD.n1328 VSS 0.02713f $ **FLOATING
C8676 VDD.n1329 VSS 0.03303f $ **FLOATING
C8677 VDD.t444 VSS 1.07657f $ **FLOATING
C8678 VDD.t648 VSS 0.16701f $ **FLOATING
C8679 VDD.n1336 VSS 0.33312f $ **FLOATING
C8680 VDD.n1339 VSS 0.02037f $ **FLOATING
C8681 VDD.n1349 VSS 0.02632f $ **FLOATING
C8682 VDD.t1581 VSS 0.04876f $ **FLOATING
C8683 VDD.n1350 VSS 0.02188f $ **FLOATING
C8684 VDD.n1352 VSS 0.02792f $ **FLOATING
C8685 VDD.n1353 VSS 0.02713f $ **FLOATING
C8686 VDD.n1354 VSS 0.03303f $ **FLOATING
C8687 VDD.t299 VSS 1.07657f $ **FLOATING
C8688 VDD.t510 VSS 0.16701f $ **FLOATING
C8689 VDD.n1361 VSS 0.27871f $ **FLOATING
C8690 VDD.n1362 VSS 0.23512f $ **FLOATING
C8691 VDD.n1365 VSS 0.02037f $ **FLOATING
C8692 VDD.n1375 VSS 0.02632f $ **FLOATING
C8693 VDD.t1533 VSS 0.04876f $ **FLOATING
C8694 VDD.n1376 VSS 0.02188f $ **FLOATING
C8695 VDD.n1378 VSS 0.02792f $ **FLOATING
C8696 VDD.n1379 VSS 0.02713f $ **FLOATING
C8697 VDD.n1380 VSS 0.03303f $ **FLOATING
C8698 VDD.t127 VSS 1.07657f $ **FLOATING
C8699 VDD.t351 VSS 0.16701f $ **FLOATING
C8700 VDD.n1387 VSS 0.4312f $ **FLOATING
C8701 VDD.n1390 VSS 0.02037f $ **FLOATING
C8702 VDD.n1400 VSS 0.02632f $ **FLOATING
C8703 VDD.t1485 VSS 0.04876f $ **FLOATING
C8704 VDD.n1401 VSS 0.02188f $ **FLOATING
C8705 VDD.n1403 VSS 0.02792f $ **FLOATING
C8706 VDD.n1404 VSS 0.02713f $ **FLOATING
C8707 VDD.n1405 VSS 0.03303f $ **FLOATING
C8708 VDD.t159 VSS 1.07657f $ **FLOATING
C8709 VDD.t199 VSS 0.16701f $ **FLOATING
C8710 VDD.n1412 VSS 0.28215f $ **FLOATING
C8711 VDD.n1413 VSS 0.23512f $ **FLOATING
C8712 VDD.n1414 VSS 2.71922f $ **FLOATING
C8713 VDD.n1415 VSS 2.71901f $ **FLOATING
C8714 VDD.n1416 VSS 0.23512f $ **FLOATING
C8715 VDD.n1419 VSS 0.02037f $ **FLOATING
C8716 VDD.n1428 VSS 0.02632f $ **FLOATING
C8717 VDD.t1491 VSS 0.04876f $ **FLOATING
C8718 VDD.n1429 VSS 0.02188f $ **FLOATING
C8719 VDD.n1431 VSS 0.02792f $ **FLOATING
C8720 VDD.n1432 VSS 0.02713f $ **FLOATING
C8721 VDD.n1433 VSS 0.03303f $ **FLOATING
C8722 VDD.t156 VSS 1.07657f $ **FLOATING
C8723 VDD.t212 VSS 0.16701f $ **FLOATING
C8724 VDD.n1440 VSS 0.28534f $ **FLOATING
C8725 VDD.n1443 VSS 0.02037f $ **FLOATING
C8726 VDD.n1452 VSS 0.02632f $ **FLOATING
C8727 VDD.t1539 VSS 0.04876f $ **FLOATING
C8728 VDD.n1453 VSS 0.02188f $ **FLOATING
C8729 VDD.n1455 VSS 0.02792f $ **FLOATING
C8730 VDD.n1456 VSS 0.02713f $ **FLOATING
C8731 VDD.n1457 VSS 0.03303f $ **FLOATING
C8732 VDD.t139 VSS 1.07657f $ **FLOATING
C8733 VDD.t366 VSS 0.16701f $ **FLOATING
C8734 VDD.n1464 VSS 0.42633f $ **FLOATING
C8735 VDD.n1467 VSS 0.02037f $ **FLOATING
C8736 VDD.n1476 VSS 0.02632f $ **FLOATING
C8737 VDD.t1651 VSS 0.04876f $ **FLOATING
C8738 VDD.n1477 VSS 0.02188f $ **FLOATING
C8739 VDD.n1479 VSS 0.02792f $ **FLOATING
C8740 VDD.n1480 VSS 0.02713f $ **FLOATING
C8741 VDD.n1481 VSS 0.03303f $ **FLOATING
C8742 VDD.t458 VSS 1.07657f $ **FLOATING
C8743 VDD.t663 VSS 0.16701f $ **FLOATING
C8744 VDD.n1488 VSS 0.33312f $ **FLOATING
C8745 VDD.n1491 VSS 0.02037f $ **FLOATING
C8746 VDD.n1500 VSS 0.02632f $ **FLOATING
C8747 VDD.t1587 VSS 0.04876f $ **FLOATING
C8748 VDD.n1501 VSS 0.02188f $ **FLOATING
C8749 VDD.n1503 VSS 0.02792f $ **FLOATING
C8750 VDD.n1504 VSS 0.02713f $ **FLOATING
C8751 VDD.n1505 VSS 0.03303f $ **FLOATING
C8752 VDD.t297 VSS 1.07657f $ **FLOATING
C8753 VDD.t525 VSS 0.16701f $ **FLOATING
C8754 VDD.n1512 VSS 0.28358f $ **FLOATING
C8755 VDD.n1513 VSS 0.23512f $ **FLOATING
C8756 VDD.n1514 VSS 2.72318f $ **FLOATING
C8757 VDD.n1515 VSS 2.72714f $ **FLOATING
C8758 VDD.n1516 VSS 0.23512f $ **FLOATING
C8759 VDD.n1519 VSS 0.02037f $ **FLOATING
C8760 VDD.n1529 VSS 0.02632f $ **FLOATING
C8761 VDD.t1545 VSS 0.04876f $ **FLOATING
C8762 VDD.n1530 VSS 0.02188f $ **FLOATING
C8763 VDD.n1532 VSS 0.02792f $ **FLOATING
C8764 VDD.n1533 VSS 0.02713f $ **FLOATING
C8765 VDD.n1534 VSS 0.03303f $ **FLOATING
C8766 VDD.t137 VSS 1.07657f $ **FLOATING
C8767 VDD.t381 VSS 0.16701f $ **FLOATING
C8768 VDD.n1541 VSS 0.42633f $ **FLOATING
C8769 VDD.n1544 VSS 0.02037f $ **FLOATING
C8770 VDD.n1554 VSS 0.02632f $ **FLOATING
C8771 VDD.t1497 VSS 0.04876f $ **FLOATING
C8772 VDD.n1555 VSS 0.02188f $ **FLOATING
C8773 VDD.n1557 VSS 0.02792f $ **FLOATING
C8774 VDD.n1558 VSS 0.02713f $ **FLOATING
C8775 VDD.n1559 VSS 0.03303f $ **FLOATING
C8776 VDD.t153 VSS 1.07657f $ **FLOATING
C8777 VDD.t227 VSS 0.16701f $ **FLOATING
C8778 VDD.n1566 VSS 0.28534f $ **FLOATING
C8779 VDD.n1567 VSS 0.23512f $ **FLOATING
C8780 VDD.n1570 VSS 0.02037f $ **FLOATING
C8781 VDD.n1580 VSS 0.02632f $ **FLOATING
C8782 VDD.t1449 VSS 0.04876f $ **FLOATING
C8783 VDD.n1581 VSS 0.02188f $ **FLOATING
C8784 VDD.n1583 VSS 0.02792f $ **FLOATING
C8785 VDD.n1584 VSS 0.02713f $ **FLOATING
C8786 VDD.n1585 VSS 0.03303f $ **FLOATING
C8787 VDD.t50 VSS 1.07657f $ **FLOATING
C8788 VDD.t58 VSS 0.16701f $ **FLOATING
C8789 VDD.n1592 VSS 0.42456f $ **FLOATING
C8790 VDD.n1595 VSS 0.02037f $ **FLOATING
C8791 VDD.n1605 VSS 0.02632f $ **FLOATING
C8792 VDD.t1417 VSS 0.04876f $ **FLOATING
C8793 VDD.n1606 VSS 0.02188f $ **FLOATING
C8794 VDD.n1608 VSS 0.02792f $ **FLOATING
C8795 VDD.n1609 VSS 0.02713f $ **FLOATING
C8796 VDD.n1610 VSS 0.03303f $ **FLOATING
C8797 VDD.t884 VSS 1.07657f $ **FLOATING
C8798 VDD.t982 VSS 0.16701f $ **FLOATING
C8799 VDD.n1617 VSS 0.27585f $ **FLOATING
C8800 VDD.n1618 VSS 0.23512f $ **FLOATING
C8801 VDD.n1619 VSS 2.72714f $ **FLOATING
C8802 VDD.n1620 VSS 2.73111f $ **FLOATING
C8803 VDD.n1621 VSS 0.23512f $ **FLOATING
C8804 VDD.n1624 VSS 0.02037f $ **FLOATING
C8805 VDD.n1632 VSS 0.02632f $ **FLOATING
C8806 VDD.t1415 VSS 0.04876f $ **FLOATING
C8807 VDD.n1633 VSS 0.02188f $ **FLOATING
C8808 VDD.n1635 VSS 0.02792f $ **FLOATING
C8809 VDD.n1636 VSS 0.02713f $ **FLOATING
C8810 VDD.n1637 VSS 0.03303f $ **FLOATING
C8811 VDD.t846 VSS 1.07657f $ **FLOATING
C8812 VDD.t1222 VSS 0.16701f $ **FLOATING
C8813 VDD.n1645 VSS 0.28072f $ **FLOATING
C8814 VDD.n1648 VSS 0.02037f $ **FLOATING
C8815 VDD.n1656 VSS 0.02632f $ **FLOATING
C8816 VDD.t1455 VSS 0.04876f $ **FLOATING
C8817 VDD.n1657 VSS 0.02188f $ **FLOATING
C8818 VDD.n1659 VSS 0.02792f $ **FLOATING
C8819 VDD.n1660 VSS 0.02713f $ **FLOATING
C8820 VDD.n1661 VSS 0.03303f $ **FLOATING
C8821 VDD.t66 VSS 1.07657f $ **FLOATING
C8822 VDD.t83 VSS 0.16701f $ **FLOATING
C8823 VDD.n1669 VSS 0.43095f $ **FLOATING
C8824 VDD.n1672 VSS 0.02037f $ **FLOATING
C8825 VDD.n1680 VSS 0.02632f $ **FLOATING
C8826 VDD.t1667 VSS 0.04876f $ **FLOATING
C8827 VDD.n1681 VSS 0.02188f $ **FLOATING
C8828 VDD.n1683 VSS 0.02792f $ **FLOATING
C8829 VDD.n1684 VSS 0.02713f $ **FLOATING
C8830 VDD.n1685 VSS 0.03303f $ **FLOATING
C8831 VDD.t454 VSS 1.07657f $ **FLOATING
C8832 VDD.t693 VSS 0.16701f $ **FLOATING
C8833 VDD.n1693 VSS 0.33312f $ **FLOATING
C8834 VDD.n1696 VSS 0.02037f $ **FLOATING
C8835 VDD.n1704 VSS 0.02632f $ **FLOATING
C8836 VDD.t1599 VSS 0.04876f $ **FLOATING
C8837 VDD.n1705 VSS 0.02188f $ **FLOATING
C8838 VDD.n1707 VSS 0.02792f $ **FLOATING
C8839 VDD.n1708 VSS 0.02713f $ **FLOATING
C8840 VDD.n1709 VSS 0.03303f $ **FLOATING
C8841 VDD.t290 VSS 1.07657f $ **FLOATING
C8842 VDD.t555 VSS 0.16701f $ **FLOATING
C8843 VDD.n1717 VSS 0.28358f $ **FLOATING
C8844 VDD.n1718 VSS 0.23512f $ **FLOATING
C8845 VDD.n1721 VSS 0.02037f $ **FLOATING
C8846 VDD.n1729 VSS 0.02632f $ **FLOATING
C8847 VDD.t1551 VSS 0.04876f $ **FLOATING
C8848 VDD.n1730 VSS 0.02188f $ **FLOATING
C8849 VDD.n1732 VSS 0.02792f $ **FLOATING
C8850 VDD.n1733 VSS 0.02713f $ **FLOATING
C8851 VDD.n1734 VSS 0.03303f $ **FLOATING
C8852 VDD.t135 VSS 1.07657f $ **FLOATING
C8853 VDD.t396 VSS 0.16701f $ **FLOATING
C8854 VDD.n1742 VSS 0.42633f $ **FLOATING
C8855 VDD.n1745 VSS 0.02037f $ **FLOATING
C8856 VDD.n1753 VSS 0.02632f $ **FLOATING
C8857 VDD.t1503 VSS 0.04876f $ **FLOATING
C8858 VDD.n1754 VSS 0.02188f $ **FLOATING
C8859 VDD.n1756 VSS 0.02792f $ **FLOATING
C8860 VDD.n1757 VSS 0.02713f $ **FLOATING
C8861 VDD.n1758 VSS 0.03303f $ **FLOATING
C8862 VDD.t150 VSS 1.07657f $ **FLOATING
C8863 VDD.t242 VSS 0.16701f $ **FLOATING
C8864 VDD.n1766 VSS 0.27896f $ **FLOATING
C8865 VDD.n1767 VSS 0.23512f $ **FLOATING
C8866 VDD.n1768 VSS 2.73111f $ **FLOATING
C8867 VDD.n1769 VSS 2.71505f $ **FLOATING
C8868 VDD.n1770 VSS 0.23512f $ **FLOATING
C8869 VDD.n1773 VSS 0.02037f $ **FLOATING
C8870 VDD.n1782 VSS 0.02632f $ **FLOATING
C8871 VDD.t1509 VSS 0.04876f $ **FLOATING
C8872 VDD.n1783 VSS 0.02188f $ **FLOATING
C8873 VDD.n1785 VSS 0.02792f $ **FLOATING
C8874 VDD.n1786 VSS 0.02713f $ **FLOATING
C8875 VDD.n1787 VSS 0.03303f $ **FLOATING
C8876 VDD.t147 VSS 1.07657f $ **FLOATING
C8877 VDD.t257 VSS 0.16701f $ **FLOATING
C8878 VDD.n1794 VSS 0.28374f $ **FLOATING
C8879 VDD.n1797 VSS 0.02037f $ **FLOATING
C8880 VDD.n1806 VSS 0.02632f $ **FLOATING
C8881 VDD.t1557 VSS 0.04876f $ **FLOATING
C8882 VDD.n1807 VSS 0.02188f $ **FLOATING
C8883 VDD.n1809 VSS 0.02792f $ **FLOATING
C8884 VDD.n1810 VSS 0.02713f $ **FLOATING
C8885 VDD.n1811 VSS 0.03303f $ **FLOATING
C8886 VDD.t125 VSS 1.07657f $ **FLOATING
C8887 VDD.t411 VSS 0.16701f $ **FLOATING
C8888 VDD.n1818 VSS 0.42952f $ **FLOATING
C8889 VDD.n1821 VSS 0.02037f $ **FLOATING
C8890 VDD.n1830 VSS 0.02632f $ **FLOATING
C8891 VDD.t1677 VSS 0.04876f $ **FLOATING
C8892 VDD.n1831 VSS 0.02188f $ **FLOATING
C8893 VDD.n1833 VSS 0.02792f $ **FLOATING
C8894 VDD.n1834 VSS 0.02713f $ **FLOATING
C8895 VDD.n1835 VSS 0.03303f $ **FLOATING
C8896 VDD.t448 VSS 1.07657f $ **FLOATING
C8897 VDD.t708 VSS 0.16701f $ **FLOATING
C8898 VDD.n1842 VSS 0.33312f $ **FLOATING
C8899 VDD.n1845 VSS 0.02037f $ **FLOATING
C8900 VDD.n1854 VSS 0.02632f $ **FLOATING
C8901 VDD.t1605 VSS 0.04876f $ **FLOATING
C8902 VDD.n1855 VSS 0.02188f $ **FLOATING
C8903 VDD.n1857 VSS 0.02792f $ **FLOATING
C8904 VDD.n1858 VSS 0.02713f $ **FLOATING
C8905 VDD.n1859 VSS 0.03303f $ **FLOATING
C8906 VDD.t282 VSS 1.07657f $ **FLOATING
C8907 VDD.t570 VSS 0.16701f $ **FLOATING
C8908 VDD.n1866 VSS 0.28039f $ **FLOATING
C8909 VDD.n1867 VSS 0.23512f $ **FLOATING
C8910 VDD.n1868 VSS 2.71901f $ **FLOATING
C8911 VDD.n1869 VSS 3.90095f $ **FLOATING
C8912 VDD.n1870 VSS 0.23512f $ **FLOATING
C8913 VDD.n1873 VSS 0.02037f $ **FLOATING
C8914 VDD.n1882 VSS 0.02632f $ **FLOATING
C8915 VDD.t1611 VSS 0.04876f $ **FLOATING
C8916 VDD.n1883 VSS 0.02188f $ **FLOATING
C8917 VDD.n1885 VSS 0.02792f $ **FLOATING
C8918 VDD.n1886 VSS 0.02713f $ **FLOATING
C8919 VDD.n1887 VSS 0.03303f $ **FLOATING
C8920 VDD.t293 VSS 1.07657f $ **FLOATING
C8921 VDD.t587 VSS 0.16701f $ **FLOATING
C8922 VDD.n1894 VSS 0.28517f $ **FLOATING
C8923 VDD.n1897 VSS 0.02037f $ **FLOATING
C8924 VDD.n1906 VSS 0.02632f $ **FLOATING
C8925 VDD.t1691 VSS 0.04876f $ **FLOATING
C8926 VDD.n1907 VSS 0.02188f $ **FLOATING
C8927 VDD.n1909 VSS 0.02792f $ **FLOATING
C8928 VDD.n1910 VSS 0.02713f $ **FLOATING
C8929 VDD.n1911 VSS 0.03303f $ **FLOATING
C8930 VDD.t4 VSS 1.07657f $ **FLOATING
C8931 VDD.t723 VSS 0.16701f $ **FLOATING
C8932 VDD.n1918 VSS 0.33312f $ **FLOATING
C8933 VDD.t1687 VSS 0.0246f $ **FLOATING
C8934 VDD.n1919 VSS 0.26098f $ **FLOATING
C8935 VDD.t1637 VSS 0.02072f $ **FLOATING
C8936 VDD.n1920 VSS 0.28004f $ **FLOATING
C8937 VDD.n1921 VSS 0.26098f $ **FLOATING
C8938 VDD.t1647 VSS 0.02072f $ **FLOATING
C8939 VDD.n1922 VSS 0.27835f $ **FLOATING
C8940 VDD.n1923 VSS 0.2609f $ **FLOATING
C8941 VDD.t1659 VSS 0.02072f $ **FLOATING
C8942 VDD.n1924 VSS 0.28133f $ **FLOATING
C8943 VDD.n1925 VSS 0.26098f $ **FLOATING
C8944 VDD.t1669 VSS 0.02072f $ **FLOATING
C8945 VDD.n1926 VSS 0.27776f $ **FLOATING
C8946 VDD.n1927 VSS 0.26098f $ **FLOATING
C8947 VDD.t1679 VSS 0.02072f $ **FLOATING
C8948 VDD.n1928 VSS 0.27906f $ **FLOATING
C8949 VDD.n1929 VSS 0.70604f $ **FLOATING
C8950 VDD.n1930 VSS 0.534f $ **FLOATING
C8951 VDD.n1931 VSS 13.4973f $ **FLOATING
C8952 VDD.n1932 VSS 9.32503f $ **FLOATING
C8953 VDD.n1933 VSS 9.36601f $ **FLOATING
C8954 VDD.n1934 VSS 9.36593f $ **FLOATING
C8955 VDD.n1935 VSS 9.34552f $ **FLOATING
C8956 VDD.n1936 VSS 9.34552f $ **FLOATING
C8957 VDD.n1937 VSS 9.31137f $ **FLOATING
C8958 VDD.n1938 VSS 0.534f $ **FLOATING
C8959 VDD.n1939 VSS 0.26098f $ **FLOATING
C8960 VDD.t1617 VSS 0.02072f $ **FLOATING
C8961 VDD.n1940 VSS 0.27839f $ **FLOATING
C8962 VDD.n1941 VSS 0.0547f $ **FLOATING
C8963 VDD.n1942 VSS 0.534f $ **FLOATING
C8964 VDD.n1945 VSS 0.02037f $ **FLOATING
C8965 VDD.n1954 VSS 0.02632f $ **FLOATING
C8966 VDD.t1621 VSS 0.04876f $ **FLOATING
C8967 VDD.n1955 VSS 0.02188f $ **FLOATING
C8968 VDD.n1957 VSS 0.02792f $ **FLOATING
C8969 VDD.n1958 VSS 0.02713f $ **FLOATING
C8970 VDD.n1959 VSS 0.03303f $ **FLOATING
C8971 VDD.t462 VSS 1.07657f $ **FLOATING
C8972 VDD.t618 VSS 0.16701f $ **FLOATING
C8973 VDD.n1966 VSS 0.33312f $ **FLOATING
C8974 VDD.n1969 VSS 0.02037f $ **FLOATING
C8975 VDD.n1978 VSS 0.02632f $ **FLOATING
C8976 VDD.t1569 VSS 0.04876f $ **FLOATING
C8977 VDD.n1979 VSS 0.02188f $ **FLOATING
C8978 VDD.n1981 VSS 0.02792f $ **FLOATING
C8979 VDD.n1982 VSS 0.02713f $ **FLOATING
C8980 VDD.n1983 VSS 0.03303f $ **FLOATING
C8981 VDD.t303 VSS 1.07657f $ **FLOATING
C8982 VDD.t480 VSS 0.16701f $ **FLOATING
C8983 VDD.n1990 VSS 0.27988f $ **FLOATING
C8984 VDD.n1991 VSS 0.23512f $ **FLOATING
C8985 VDD.n1992 VSS 2.18038f $ **FLOATING
C8986 VDD.t434 VSS 0.34573f $ **FLOATING
C8987 VDD.n2005 VSS 0.03965f $ **FLOATING
C8988 VDD.t597 VSS 0.58003f $ **FLOATING
C8989 VDD.n2024 VSS 0.03964f $ **FLOATING
C8990 VDD.n2027 VSS 0.15468f $ **FLOATING
C8991 VDD.t286 VSS 0.46912f $ **FLOATING
C8992 VDD.n2039 VSS 0.03964f $ **FLOATING
C8993 VDD.n2042 VSS 0.14823f $ **FLOATING
C8994 VDD.n2043 VSS 0.09715f $ **FLOATING
C8995 VDD.n2044 VSS 1.91555f $ **FLOATING
C8996 VDD.n2045 VSS 13.1846f $ **FLOATING
C8997 VDD.n2047 VSS 7.76968f $ **FLOATING
C8998 VDD.n2049 VSS 0.15075f $ **FLOATING
C8999 VDD.n2051 VSS 0.40199f $ **FLOATING
C9000 VDD.n2053 VSS 0.15075f $ **FLOATING
C9001 VDD.n2055 VSS 0.15075f $ **FLOATING
C9002 VDD.n2057 VSS 0.40199f $ **FLOATING
C9003 VDD.n2059 VSS 0.15075f $ **FLOATING
C9004 VDD.n2061 VSS 0.34968f $ **FLOATING
C9005 VDD.n2062 VSS 0.13113f $ **FLOATING
C9006 VDD.n2063 VSS 0.34968f $ **FLOATING
C9007 VDD.n2064 VSS 0.13113f $ **FLOATING
C9008 VDD.n2065 VSS 0.13113f $ **FLOATING
C9009 VDD.n2067 VSS 0.64882f $ **FLOATING
C9010 VDD.n2070 VSS 0.13113f $ **FLOATING
C9011 VDD.n2073 VSS 0.34968f $ **FLOATING
C9012 VDD.n2076 VSS 0.13113f $ **FLOATING
C9013 VDD.n2079 VSS 0.13113f $ **FLOATING
C9014 VDD.n2081 VSS 0.34968f $ **FLOATING
C9015 VDD.n2089 VSS 0.13113f $ **FLOATING
C9016 VDD.n2090 VSS 0.13113f $ **FLOATING
C9017 VDD.n2092 VSS 0.48992f $ **FLOATING
C9018 VDD.n2093 VSS 3.91614f $ **FLOATING
C9019 VDD.n2094 VSS 6.79689f $ **FLOATING
C9020 X1.t0 VSS 0.08117f $ **FLOATING
C9021 X1.n0 VSS 0.09827f $ **FLOATING
C9022 CLK.t0 VSS 1.3746f $ **FLOATING
C9023 CLK.t1 VSS 0.31154f $ **FLOATING
C9024 CLK.n0 VSS 13.6148f $ **FLOATING
C9025 CLK.t2 VSS 0.31154f $ **FLOATING
C9026 CLK.n1 VSS 7.1109f $ **FLOATING
C9027 CLK.t3 VSS 0.31154f $ **FLOATING
C9028 CLK.n2 VSS 7.1109f $ **FLOATING
C9029 CLK.t4 VSS 0.31154f $ **FLOATING
C9030 CLK.n3 VSS 7.1109f $ **FLOATING
C9031 CLK.t5 VSS 0.31154f $ **FLOATING
C9032 CLK.n4 VSS 7.1109f $ **FLOATING
C9033 CLK.t6 VSS 0.31154f $ **FLOATING
C9034 CLK.n5 VSS 7.1109f $ **FLOATING
C9035 CLK.t7 VSS 0.31154f $ **FLOATING
C9036 CLK.n6 VSS 7.47828f $ **FLOATING
C9037 CLK.t8 VSS 1.3746f $ **FLOATING
C9038 CLK.t9 VSS 0.31154f $ **FLOATING
C9039 CLK.n7 VSS 13.6148f $ **FLOATING
C9040 CLK.t10 VSS 0.31154f $ **FLOATING
C9041 CLK.n8 VSS 7.1109f $ **FLOATING
C9042 CLK.t11 VSS 0.31154f $ **FLOATING
C9043 CLK.n9 VSS 7.1109f $ **FLOATING
C9044 CLK.t12 VSS 0.31154f $ **FLOATING
C9045 CLK.n10 VSS 7.1109f $ **FLOATING
C9046 CLK.t13 VSS 0.31154f $ **FLOATING
C9047 CLK.n11 VSS 7.1109f $ **FLOATING
C9048 CLK.t14 VSS 0.31154f $ **FLOATING
C9049 CLK.n12 VSS 7.1109f $ **FLOATING
C9050 CLK.t15 VSS 0.31154f $ **FLOATING
C9051 CLK.n13 VSS 6.15624f $ **FLOATING
C9052 CLK.n14 VSS 7.03757f $ **FLOATING
C9053 CLK.t16 VSS 1.3746f $ **FLOATING
C9054 CLK.t17 VSS 0.31154f $ **FLOATING
C9055 CLK.n15 VSS 13.6148f $ **FLOATING
C9056 CLK.t18 VSS 0.31154f $ **FLOATING
C9057 CLK.n16 VSS 7.1109f $ **FLOATING
C9058 CLK.t19 VSS 0.31154f $ **FLOATING
C9059 CLK.n17 VSS 7.1109f $ **FLOATING
C9060 CLK.t20 VSS 0.31154f $ **FLOATING
C9061 CLK.n18 VSS 7.1109f $ **FLOATING
C9062 CLK.t21 VSS 0.31154f $ **FLOATING
C9063 CLK.n19 VSS 7.1109f $ **FLOATING
C9064 CLK.t22 VSS 0.31154f $ **FLOATING
C9065 CLK.n20 VSS 7.1109f $ **FLOATING
C9066 CLK.t23 VSS 0.31154f $ **FLOATING
C9067 CLK.n21 VSS 6.15624f $ **FLOATING
C9068 CLK.n22 VSS 3.55562f $ **FLOATING
C9069 CLK.t24 VSS 1.3746f $ **FLOATING
C9070 CLK.t25 VSS 0.31154f $ **FLOATING
C9071 CLK.n23 VSS 13.6148f $ **FLOATING
C9072 CLK.t26 VSS 0.31154f $ **FLOATING
C9073 CLK.n24 VSS 7.1109f $ **FLOATING
C9074 CLK.t27 VSS 0.31154f $ **FLOATING
C9075 CLK.n25 VSS 7.1109f $ **FLOATING
C9076 CLK.t28 VSS 0.31154f $ **FLOATING
C9077 CLK.n26 VSS 7.1109f $ **FLOATING
C9078 CLK.t29 VSS 0.31154f $ **FLOATING
C9079 CLK.n27 VSS 7.1109f $ **FLOATING
C9080 CLK.t30 VSS 0.31154f $ **FLOATING
C9081 CLK.n28 VSS 7.1109f $ **FLOATING
C9082 CLK.t31 VSS 0.31154f $ **FLOATING
C9083 CLK.n29 VSS 6.15624f $ **FLOATING
C9084 CLK.n30 VSS 3.55562f $ **FLOATING
C9085 CLK.t32 VSS 1.3746f $ **FLOATING
C9086 CLK.t33 VSS 0.31154f $ **FLOATING
C9087 CLK.n31 VSS 13.6148f $ **FLOATING
C9088 CLK.t34 VSS 0.31154f $ **FLOATING
C9089 CLK.n32 VSS 7.1109f $ **FLOATING
C9090 CLK.t35 VSS 0.31154f $ **FLOATING
C9091 CLK.n33 VSS 7.1109f $ **FLOATING
C9092 CLK.t36 VSS 0.31154f $ **FLOATING
C9093 CLK.n34 VSS 7.1109f $ **FLOATING
C9094 CLK.t37 VSS 0.31154f $ **FLOATING
C9095 CLK.n35 VSS 7.1109f $ **FLOATING
C9096 CLK.t38 VSS 0.31154f $ **FLOATING
C9097 CLK.n36 VSS 7.1109f $ **FLOATING
C9098 CLK.t39 VSS 0.31154f $ **FLOATING
C9099 CLK.n37 VSS 6.15624f $ **FLOATING
C9100 CLK.n38 VSS 3.55562f $ **FLOATING
C9101 CLK.t40 VSS 1.3746f $ **FLOATING
C9102 CLK.t41 VSS 0.31154f $ **FLOATING
C9103 CLK.n39 VSS 13.6148f $ **FLOATING
C9104 CLK.t42 VSS 0.31154f $ **FLOATING
C9105 CLK.n40 VSS 7.1109f $ **FLOATING
C9106 CLK.t43 VSS 0.31154f $ **FLOATING
C9107 CLK.n41 VSS 7.1109f $ **FLOATING
C9108 CLK.t44 VSS 0.31154f $ **FLOATING
C9109 CLK.n42 VSS 7.1109f $ **FLOATING
C9110 CLK.t45 VSS 0.31154f $ **FLOATING
C9111 CLK.n43 VSS 7.1109f $ **FLOATING
C9112 CLK.t46 VSS 0.31154f $ **FLOATING
C9113 CLK.n44 VSS 7.1109f $ **FLOATING
C9114 CLK.t47 VSS 0.31154f $ **FLOATING
C9115 CLK.n45 VSS 6.15624f $ **FLOATING
C9116 CLK.n46 VSS 3.55562f $ **FLOATING
C9117 CLK.t48 VSS 1.3746f $ **FLOATING
C9118 CLK.t49 VSS 0.31154f $ **FLOATING
C9119 CLK.n47 VSS 13.6148f $ **FLOATING
C9120 CLK.t50 VSS 0.31154f $ **FLOATING
C9121 CLK.n48 VSS 7.1109f $ **FLOATING
C9122 CLK.t51 VSS 0.31154f $ **FLOATING
C9123 CLK.n49 VSS 7.1109f $ **FLOATING
C9124 CLK.t52 VSS 0.31154f $ **FLOATING
C9125 CLK.n50 VSS 7.1109f $ **FLOATING
C9126 CLK.t53 VSS 0.31154f $ **FLOATING
C9127 CLK.n51 VSS 7.1109f $ **FLOATING
C9128 CLK.t54 VSS 0.31154f $ **FLOATING
C9129 CLK.n52 VSS 7.1109f $ **FLOATING
C9130 CLK.t55 VSS 0.31154f $ **FLOATING
C9131 CLK.n53 VSS 6.15624f $ **FLOATING
C9132 CLK.n54 VSS 3.55562f $ **FLOATING
C9133 CLK.t56 VSS 2.27498f $ **FLOATING
C9134 CLK.t57 VSS 0.31154f $ **FLOATING
C9135 CLK.n55 VSS 19.1235f $ **FLOATING
C9136 CLK.t58 VSS 0.31154f $ **FLOATING
C9137 CLK.n56 VSS 7.1109f $ **FLOATING
C9138 CLK.t59 VSS 0.31154f $ **FLOATING
C9139 CLK.n57 VSS 7.1109f $ **FLOATING
C9140 CLK.t60 VSS 0.31154f $ **FLOATING
C9141 CLK.n58 VSS 7.1109f $ **FLOATING
C9142 CLK.t61 VSS 0.31154f $ **FLOATING
C9143 CLK.n59 VSS 7.1109f $ **FLOATING
C9144 CLK.t62 VSS 0.31154f $ **FLOATING
C9145 CLK.n60 VSS 6.15624f $ **FLOATING
C9146 CLK.n61 VSS 2.31215f $ **FLOATING
C9147 CLK.t63 VSS 0.10594f $ **FLOATING
C9148 CLK.n62 VSS 0.07861f $ **FLOATING
C9149 CLK.t64 VSS 0.10596f $ **FLOATING
C9150 CLK.n63 VSS 0.07988f $ **FLOATING
C9151 CLK.t66 VSS 0.10608f $ **FLOATING
C9152 CLK.n64 VSS 0.14908f $ **FLOATING
C9153 CLK.t65 VSS 0.10603f $ **FLOATING
C9154 CLK.n65 VSS 0.08872f $ **FLOATING
C9155 CLK.n66 VSS 3.11388f $ **FLOATING
C9156 CLK.n67 VSS 1.64236f $ **FLOATING
C9157 CLK.n68 VSS 1.266f $ **FLOATING
C9158 CLK.n69 VSS 24.6288f $ **FLOATING
C9159 X2.t0 VSS 0.10676f $ **FLOATING
C9160 X7.t5 VSS 0.23716f $ **FLOATING
C9161 X7.t2 VSS 0.34099f $ **FLOATING
C9162 X7.n0 VSS 1.81562f $ **FLOATING
C9163 X7.t1 VSS 0.48608f $ **FLOATING
C9164 X7.n1 VSS 0.75547f $ **FLOATING
C9165 X7.t4 VSS 0.21282f $ **FLOATING
C9166 X7.n2 VSS 0.64949f $ **FLOATING
C9167 X7.t3 VSS 0.22339f $ **FLOATING
C9168 X7.n3 VSS 0.66037f $ **FLOATING
C9169 X7.t0 VSS 0.48587f $ **FLOATING
C9170 X7.n4 VSS 0.81628f $ **FLOATING
C9171 X5.t3 VSS 0.21657f $ **FLOATING
C9172 X5.t2 VSS 0.21956f $ **FLOATING
C9173 X5.n0 VSS 1.00625f $ **FLOATING
C9174 X5.t0 VSS 0.3925f $ **FLOATING
C9175 X5.n1 VSS 1.2568f $ **FLOATING
C9176 X5.t1 VSS 0.20878f $ **FLOATING
C9177 X5.n2 VSS 1.27814f $ **FLOATING
C9178 X6.t4 VSS 0.3682f $ **FLOATING
C9179 X6.t3 VSS 0.29246f $ **FLOATING
C9180 X6.n0 VSS 2.88279f $ **FLOATING
C9181 X6.t2 VSS 0.34359f $ **FLOATING
C9182 X6.n1 VSS 1.23652f $ **FLOATING
C9183 X6.t1 VSS 0.51988f $ **FLOATING
C9184 X6.n2 VSS 0.9236f $ **FLOATING
C9185 X6.t0 VSS 0.31655f $ **FLOATING
C9186 X6.n3 VSS 1.03569f $ **FLOATING
C9187 X3.t0 VSS 0.09877f $ **FLOATING
C9188 X4.t0 VSS 0.05846f $ **FLOATING
C9189 X8.t0 VSS 0.2653f $ **FLOATING
C9190 X8.t1 VSS 0.26897f $ **FLOATING
C9191 X8.n0 VSS 1.23269f $ **FLOATING
C9192 X8.t2 VSS 0.48083f $ **FLOATING
C9193 X8.n1 VSS 1.53962f $ **FLOATING
C9194 X8.t3 VSS 0.25576f $ **FLOATING
C9195 X8.n2 VSS 1.85257f $ **FLOATING
C9196 X9.t0 VSS 0.40696f $ **FLOATING
C9197 X9.t1 VSS 0.32324f $ **FLOATING
C9198 X9.n0 VSS 3.18619f $ **FLOATING
C9199 X9.t2 VSS 0.37975f $ **FLOATING
C9200 X9.n1 VSS 1.36666f $ **FLOATING
C9201 X9.t3 VSS 0.5746f $ **FLOATING
C9202 X9.n2 VSS 1.02081f $ **FLOATING
C9203 X9.t4 VSS 0.34986f $ **FLOATING
C9204 X9.n3 VSS 1.36822f $ **FLOATING
C9205 X10.t0 VSS 0.26387f $ **FLOATING
C9206 X10.t1 VSS 0.37939f $ **FLOATING
C9207 X10.n0 VSS 2.02008f $ **FLOATING
C9208 X10.t2 VSS 0.54082f $ **FLOATING
C9209 X10.n1 VSS 0.84054f $ **FLOATING
C9210 X10.t3 VSS 0.23679f $ **FLOATING
C9211 X10.n2 VSS 0.72263f $ **FLOATING
C9212 X10.t4 VSS 0.24854f $ **FLOATING
C9213 X10.n3 VSS 0.73474f $ **FLOATING
C9214 X10.t5 VSS 0.54059f $ **FLOATING
C9215 X10.n4 VSS 0.99391f $ **FLOATING
.ends

.GLOBAL GND
.GLOBAL net4
.GLOBAL net5
.GLOBAL net6
.GLOBAL net7
.GLOBAL net8
.end
