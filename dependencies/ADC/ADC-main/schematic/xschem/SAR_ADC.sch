v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 1500 -830 1550 -830 {lab=bias}
N 1630 -730 1630 -690 {lab=VSS}
N 1260 -1130 1300 -1130 {lab=VDD}
N 1240 -1150 1240 -1130 {lab=VSS}
N 1240 -1150 1360 -1150 {lab=VSS}
N 1030 -530 1030 -510 {lab=BN_MSB}
N 1070 -530 1070 -510 {lab=BN6}
N 1100 -530 1100 -510 {lab=BN5}
N 1130 -530 1130 -510 {lab=BN4}
N 1160 -530 1160 -510 {lab=BN3}
N 1190 -530 1190 -510 {lab=BN2}
N 1220 -530 1220 -510 {lab=BN1}
N 1260 -530 1300 -530 {lab=VDD}
N 1240 -530 1240 -510 {lab=VSS}
N 1240 -510 1360 -510 {lab=VSS}
N 1030 -1160 1030 -1130 {lab=B_MSB}
N 1070 -1160 1070 -1130 {lab=B6}
N 1100 -1160 1100 -1130 {lab=B5}
N 1130 -1160 1130 -1130 {lab=B4}
N 1160 -1160 1160 -1130 {lab=B3}
N 1190 -1160 1190 -1130 {lab=B2}
N 1220 -1160 1220 -1130 {lab=B1}
N 850 -770 970 -770 {lab=#net1}
N 710 -820 710 -810 {lab=VSS}
N 710 -700 710 -690 {lab=VSS}
N 770 -820 770 -800 {lab=VDD}
N 770 -700 770 -680 {lab=VDD}
N 830 -820 830 -800 {lab=clk_samp}
N 630 -890 680 -890 {lab=vin_pos}
N 630 -770 680 -770 {lab=vin_neg}
N 1630 -970 1630 -930 {lab=VDD}
N 1680 -750 1680 -720 {lab=clk_comp}
N 830 -700 830 -680 {lab=clk_samp}
N 1830 -840 1880 -840 {lab=Op}
N 1830 -820 1880 -820 {lab=Om}
N 850 -890 970 -890 {lab=#net2}
N 1230 -990 1230 -950 {lab=VDD}
N 1230 -990 1300 -990 {lab=VDD}
N 1230 -1010 1230 -990 {lab=VDD}
N 1300 -1130 1300 -990 {lab=VDD}
N 1200 -1010 1200 -950 {lab=#net3}
N 1170 -1010 1170 -950 {lab=#net4}
N 1140 -1010 1140 -950 {lab=#net5}
N 1110 -1010 1110 -950 {lab=#net6}
N 1080 -1010 1080 -950 {lab=#net7}
N 1050 -1010 1050 -950 {lab=#net8}
N 1020 -1010 1020 -950 {lab=#net9}
N 1020 -710 1020 -650 {lab=#net10}
N 1050 -710 1050 -650 {lab=#net11}
N 1080 -710 1080 -650 {lab=#net12}
N 1110 -710 1110 -650 {lab=#net13}
N 1140 -710 1140 -650 {lab=#net14}
N 1170 -710 1170 -650 {lab=#net15}
N 1200 -710 1200 -650 {lab=#net16}
N 1230 -680 1230 -650 {lab=VDD}
N 1230 -680 1300 -680 {lab=VDD}
N 1230 -710 1230 -680 {lab=VDD}
N 1300 -680 1300 -530 {lab=VDD}
N 1290 -890 1550 -890 {lab=CDAC_v+}
N 1290 -770 1550 -770 {lab=CDAC_v-}
N 1490 -1150 1510 -1150 {lab=Op}
N 1490 -1090 1510 -1090 {lab=Om}
N 1600 -1230 1600 -1200 {lab=VDD}
N 1600 -1040 1600 -1020 {lab=VSS}
N 1750 -1120 1760 -1120 {lab=clk_algo}
N 1600 -1040 1750 -1040 {lab=VSS}
N 1750 -1120 1750 -1100 {lab=clk_algo}
N 1740 -1120 1750 -1120 {lab=clk_algo}
N -310 -580 135 -580 {lab=D0}
N -310 -600 135 -600 {lab=D1}
N -310 -620 135 -620 {lab=D2}
N -310 -640 135 -640 {lab=D3}
N -310 -660 135 -660 {lab=D4}
N -310 -680 135 -680 {lab=D5}
N -310 -700 135 -700 {lab=D6}
N -310 -720 135 -720 {lab=D7}
N -310 -740 135 -740 {lab=BN1}
N -310 -760 135 -760 {lab=BN2}
N -310 -780 135 -780 {lab=BN3}
N -310 -800 135 -800 {lab=BN4}
N -310 -820 135 -820 {lab=BN5}
N -310 -840 135 -840 {lab=BN6}
N -310 -860 135 -860 {lab=BN_MSB}
N -310 -880 135 -880 {lab=B1}
N -310 -900 135 -900 {lab=B2}
N -310 -920 135 -920 {lab=B3}
N -310 -940 135 -940 {lab=B4}
N -310 -960 135 -960 {lab=B5}
N -310 -980 135 -980 {lab=B6}
N -310 -1000 135 -1000 {lab=B_MSB}
N -310 -1020 140 -1020 {lab=clk_samp}
N -310 -1040 140 -1040 {lab=clk_comp}
N -310 -1060 140 -1060 {lab=fdac_clk}
N -590 -890 -440 -890 {lab=VDD}
N -590 -870 -440 -870 {lab=VSS}
N -590 -810 -440 -810 {lab=Op}
N -590 -790 -440 -790 {lab=Om}
N -590 -750 -440 -750 {lab=clk_algo}
N -590 -770 -440 -770 {lab=En}
N -590 -830 -440 -830 {lab=rst}
N -590 -850 -440 -850 {lab=fclk_in}
C {devices/lab_pin.sym} 1300 -1130 2 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1880 -840 2 0 {name=p36 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 1880 -820 2 0 {name=p37 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1300 -530 0 1 {name=p38 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1030 -1160 1 0 {name=p40 sig_type=std_logic lab=B_MSB}
C {devices/lab_pin.sym} 1100 -1160 1 0 {name=p41 sig_type=std_logic lab=B5}
C {devices/lab_pin.sym} 1190 -1160 1 0 {name=p42 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 1160 -1160 1 0 {name=p43 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 1130 -1160 1 0 {name=p44 sig_type=std_logic lab=B4}
C {devices/lab_pin.sym} 1220 -1160 1 0 {name=p46 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 1070 -1160 1 0 {name=p45 sig_type=std_logic lab=B6}
C {devices/lab_pin.sym} 1030 -510 1 1 {name=p48 sig_type=std_logic lab=BN_MSB}
C {devices/lab_pin.sym} 1100 -510 1 1 {name=p49 sig_type=std_logic lab=BN5}
C {devices/lab_pin.sym} 1190 -510 1 1 {name=p50 sig_type=std_logic lab=BN2}
C {devices/lab_pin.sym} 1160 -510 1 1 {name=p51 sig_type=std_logic lab=BN3}
C {devices/lab_pin.sym} 1130 -510 1 1 {name=p52 sig_type=std_logic lab=BN4}
C {devices/lab_pin.sym} 1220 -510 1 1 {name=p53 sig_type=std_logic lab=BN1}
C {devices/lab_pin.sym} 1070 -510 1 1 {name=p54 sig_type=std_logic lab=BN6}
C {devices/lab_pin.sym} 770 -800 2 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1630 -970 2 0 {name=p65 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1680 -720 2 0 {name=p66 sig_type=std_logic lab=clk_comp}
C {devices/lab_pin.sym} 830 -800 2 0 {name=p22 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 770 -680 2 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 830 -680 2 0 {name=p23 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 1330 -890 3 1 {name=p74 sig_type=std_logic lab=CDAC_v+}
C {devices/lab_pin.sym} 1330 -770 1 1 {name=p73 sig_type=std_logic lab=CDAC_v-}
C {devices/lab_pin.sym} 1490 -1150 2 1 {name=p9 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 1490 -1090 2 1 {name=p11 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1600 -1230 2 1 {name=p34 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1760 -1120 2 0 {name=p35 sig_type=std_logic lab=clk_algo}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_5_analog_layout/switch_array/schematic/switch_array.sym} 1130 -590 0 0 {name=x7}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_5_analog_layout/switch_array/schematic/switch_array.sym} 1130 -1070 2 1 {name=x4}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_2_digital_comps/nand_gate/schematic/nand_gate.sym} 1660 -1110 0 0 {name=x8}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_2_digital_comps/bootstrap_switch/schematic/bootstrap_switch.sym} 750 -890 0 0 {name=x1}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_2_digital_comps/bootstrap_switch/schematic/bootstrap_switch.sym} 750 -770 0 0 {name=x6}
C {ipin.sym} 630 -890 0 0 {name=p39 lab=vin_pos}
C {ipin.sym} 630 -770 0 0 {name=p25 lab=vin_neg}
C {iopin.sym} 360 -1080 0 0 {name=p8 lab=VDD}
C {iopin.sym} 360 -1040 0 0 {name=p47 lab=VSS

}
C {ipin.sym} 1500 -830 0 0 {name=p26 lab=bias
}
C {devices/lab_pin.sym} 1360 -1150 0 1 {name=p10 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 1630 -690 0 1 {name=p17 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 1600 -1020 0 0 {name=p24 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 1360 -510 0 1 {name=p63 sig_type=std_logic lab=VSS
}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_5_analog_layout/comparator/layout/schematic/DIFF_COMPARATOR.sym} 1700 -830 0 0 {name=x9}
C {devices/lab_pin.sym} 710 -810 0 1 {name=p64 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 710 -690 0 1 {name=p68 sig_type=std_logic lab=VSS
}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_5_analog_layout/CDAC/schematic/CDAC.sym} 1130 -1130 2 1 {name=x3}
C {/home/designer/shared/IHP-AnalogAcademy/modules/module_3_8_bit_SAR_ADC/part_5_analog_layout/CDAC/schematic/CDAC.sym} 1130 -530 0 0 {name=x2}
C {sg13g2_pr/cap_cmim.sym} 1750 -1070 0 0 {name=C1
model=cap_cmim
w=3.60e-6
l=3.60e-6
m=1
spiceprefix=X}
C {lab_pin.sym} -590 -870 0 0 {name=p1 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -590 -810 0 0 {name=p2 sig_type=std_logic lab=Op}
C {lab_pin.sym} -590 -750 0 0 {name=p3 sig_type=std_logic lab=clk_algo}
C {lab_pin.sym} 130 -1020 0 1 {name=p6 sig_type=std_logic lab=clk_samp}
C {lab_pin.sym} -590 -790 0 0 {name=p7 sig_type=std_logic lab=Om}
C {lab_pin.sym} 130 -860 0 1 {name=p13 sig_type=std_logic lab=BN_MSB}
C {lab_pin.sym} -590 -890 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 130 -1000 0 1 {name=p15 sig_type=std_logic lab=B_MSB}
C {lab_pin.sym} 130 -840 0 1 {name=p16 sig_type=std_logic lab=BN6}
C {lab_pin.sym} 130 -980 0 1 {name=p18 sig_type=std_logic lab=B6}
C {lab_pin.sym} 130 -820 0 1 {name=p19 sig_type=std_logic lab=BN5}
C {lab_pin.sym} 130 -960 0 1 {name=p27 sig_type=std_logic lab=B5}
C {lab_pin.sym} 130 -800 0 1 {name=p28 sig_type=std_logic lab=BN4}
C {lab_pin.sym} 130 -940 0 1 {name=p29 sig_type=std_logic lab=B4}
C {lab_pin.sym} 130 -780 0 1 {name=p30 sig_type=std_logic lab=BN3}
C {lab_pin.sym} 130 -920 0 1 {name=p31 sig_type=std_logic lab=B3}
C {lab_pin.sym} 130 -760 0 1 {name=p32 sig_type=std_logic lab=BN2}
C {lab_pin.sym} 130 -900 0 1 {name=p33 sig_type=std_logic lab=B2}
C {lab_pin.sym} 130 -740 0 1 {name=p55 sig_type=std_logic lab=BN1}
C {opin.sym} 130 -580 0 0 {name=p56 lab=D0}
C {opin.sym} 130 -600 0 0 {name=p57 lab=D1}
C {opin.sym} 130 -620 0 0 {name=p58 lab=D2}
C {opin.sym} 130 -640 0 0 {name=p59 lab=D3}
C {opin.sym} 130 -660 0 0 {name=p60 lab=D4}
C {opin.sym} 130 -680 0 0 {name=p62 lab=D5}
C {opin.sym} 130 -720 0 0 {name=p67 lab=D7}
C {lab_pin.sym} 130 -880 0 1 {name=p69 sig_type=std_logic lab=B1}
C {opin.sym} 130 -700 0 0 {name=p70 lab=D6}
C {lab_pin.sym} -590 -850 0 0 {name=p4 sig_type=std_logic lab=fclk_in}
C {lab_pin.sym} -590 -830 0 0 {name=p5 sig_type=std_logic lab=rst}
C {lab_pin.sym} -590 -770 0 0 {name=p61 sig_type=std_logic lab=En}
C {lab_pin.sym} 130 -1040 0 1 {name=p71 sig_type=std_logic lab=clk_comp}
C {lab_pin.sym} 130 -1060 0 1 {name=p72 sig_type=std_logic lab=fdac_clk}
C {ipin.sym} 430 -1230 0 0 {name=p75 lab=fclk_in}
C {ipin.sym} 430 -1190 0 0 {name=p76 lab=rst}
C {ipin.sym} 430 -1150 0 0 {name=p77 lab=En}
C {opin.sym} 360 -1010 0 0 {name=p78 lab=fdac_clk}
C {sar_algo.sym} -640 -540 0 0 {name=x5
}
